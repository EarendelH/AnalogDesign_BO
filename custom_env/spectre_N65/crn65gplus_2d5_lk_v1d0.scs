+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.2545272e-009         lua=1.9117946e-016        ub=3e-018
+ uc=7.9976931e-011         luc=3.5902245e-017        eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=8.7610592              la0=-4.3534255e-007+dla0_na
+ ags=1.3513897+dagsn_na    lags=6.6908591e-007+dlagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.1498847            lpclm=1.7951123e-007
+ pdiblc1=0                 pdiblc2=0.0050494233      lpdiblc2=8.9755613e-010
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.3131598            lkt1=1.5258454e-008       kt1l=0
+ kt2=-0.10735519           lkt2=8.0780051e-009       ute=-2
+ ua1=3.971345e-009         lua1=-2.5621009e-016      ub1=-4.6085502e-018
+ lub1=-7.0009378e-025      uc1=1.970758e-010         prt=0
+ at=177794.73              lat=-0.0073599602         jss=2.25e-06
+ jsd=2.25e-06              jsws=2.22e-12             jswd=2.22e-12
+ jswgs=2.22e-12            jswgd=2.22e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19.0
+ bvd=19.0                  xjbvs=1                   xjbvd=1
+ pbs=0.4                   pbd=0.4                   cjs=cjn_na
+ cjd=cjn_na                mjs=0.31                  mjd=0.31
+ pbsws=0.4                 pbswd=0.4                 cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.01                mjswd=0.01
+ pbswgs=1.16               pbswgd=1.16               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.98               mjswgd=0.98
+ tpb=2.2e-3                tcj=2.55e-3               tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=5e-3               tcjswg=1.26e-2
+ xtis=3                    xtid=3                    dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163e-6
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    kvth0=2.0e-9
+ lkvth0=3e-7               wkvth0=1e-7               pkvth0=0
+ llodvth=1.00              wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=-4.86e-8
+ lku0=1.8e-7               wku0=6e-7                 pku0=0
+ llodku0=1                 wlodku0=1                 kvsat=-0.0
+ steta0=0.0e-06            tku0=0                    wvth0=0+dwvthn_na
+ pvth0=0+dpvthn_na         wk2=0+dwk2n_na            pk2=0+dpk2n_na
+ wcit=0+dwcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            wags=0+dwagsn_na
+ pags=0+dpagsn_na          fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian_na
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na
+ rnoib=0                   noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     4: type=n 
+ lmin=3e-007-(dxln_na+dlmisn_na)                     lmax=5e-007-(dxln_na+dlmisn_na)
+ wmin=1e-005-(dxwn_na+dwmisn_na)                     wmax=0.00090000001
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=3.259685e-09
+ ll=2.87292e-3             wl=0                      lln=-0.869
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=2.87292e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=3.259685e-09+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.10971809+(dvthn_na+vthmisn_na)
+ lvth0=1.20936e-008+dlvthn_na                        k1=0.070346
+ k2=0.026131719+dk2n_na    lk2=4.4555367e-010+dlk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0015616741+dcitn_na lcit=6.3650524e-011+dlcitn_na
+ voff=-0.081081075         lvoff=-9.1656754e-009     nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.5593393e-009         lua=5.0920419e-017        ub=3e-018
+ uc=1.4416741e-010         luc=6.3650524e-018        eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=14.682805              la0=-3.1602288e-006+dla0_na
+ ags=-0.78347666+dagsn_na  lags=1.6514428e-006+dlagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.775154             lpclm=-1.0820589e-007
+ pdiblc1=0                 pdiblc2=0.0083832587      lpdiblc2=-6.3650524e-010
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.30766517           lkt1=1.2730105e-008       kt1l=0
+ kt2=-0.096577968          lkt2=3.1188757e-009       ute=-2
+ ua1=3.6501948e-009        lua1=-1.0843312e-016      ub1=-7.8314082e-018
+ lub1=7.8290144e-025       uc1=2.6620526e-010        luc1=-3.1809858e-017
+ prt=0                     at=280483.59              lat=-0.054612149
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ wvth0=0+dwvthn_na         pvth0=0+dpvthn_na         wk2=0+dwk2n_na
+ pk2=0+dpk2n_na            wcit=0+dwcitn_na          pcit=0+dpcitn_na
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ wags=0+dwagsn_na          pags=0+dpagsn_na          fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian_na             rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na             rnoib=0                   noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     5: type=n 
+ lmin=2e-07                lmax=3e-007-(dxln_na+dlmisn_na)
+ wmin=1e-005-(dxwn_na+dwmisn_na)                     wmax=0.00090000001
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=4.72872e-3             wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=4.72872e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=2.8625e-10+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13854239+(dvthn_na+vthmisn_na)
+ lvth0=4.3953909e-009+dlvthn_na                      k1=0.070346
+ k2=0.023228442+dk2n_na    lk2=1.2209419e-009+dlk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0017268551+dcitn_na lcit=1.9535071e-011+dlcitn_na
+ voff=-0.11636917          lvoff=2.5883969e-010      nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.7458838e-009         lua=1.0993361e-018        ub=3.1828623e-018
+ lub=-4.8837677e-026       uc=1.68e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=3.3985869              la0=-1.4651303e-007+dla0_na
+ ags=5.4+dagsn_na          a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.09496
+ dwg=0                     dwb=0                     pclm=1.4980036
+ lpclm=-3.4186374e-008     pdiblc1=0                 pdiblc2=0.0094743839
+ lpdiblc2=-9.2791586e-010  pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.26731449           lkt1=1.9535071e-009
+ kt1l=0                    kt2=-0.091300181          lkt2=1.7093187e-009
+ ute=-2                    ua1=4.2663976e-009        lua1=-2.7300457e-016
+ ub1=-7.514931e-018        lub1=6.9837878e-025       uc1=1.471e-010
+ prt=0                     at=148047.75              lat=-0.019242045
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ wvth0=0+dwvthn_na         pvth0=0+dpvthn_na         wk2=0+dwk2n_na
+ pk2=0+dpk2n_na            wcit=0+dwcitn_na          pcit=0+dpcitn_na
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ lags=0+dlagsn_na          wags=0+dwagsn_na          pags=0+dpagsn_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noian_na             rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na             rnoib=0
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     6: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=2.000001e-05
+ wmin=1e-006-(dxwn_na+dwmisn_na)                     wmax=1e-005-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=2.058866e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=2.058866e-08+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.094435556+(dvthn_na+vthmisn_na)
+ wvth0=5.653476e-09+dwvthn_na                        k1=0.070346
+ k2=0.033201076+dk2n_na    wk2=8.5028273e-09+dwk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0011+dcitn_na       voff=-0.089109778         wvoff=-7.9148658e-009
+ nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na      etab=0.25
+ u0=0.08+du0n_na           ua=1.1247217e-009         wua=1.6560726e-016
+ ub=2e-18                  pub=0                     wub=0
+ lub=0                     uc=1.18e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=8.6613333              wa0=3.3920853e-006
+ ags=1.1811288+dagsn_na    wags=-1.1306953e-08+dwagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.10342215          wketa=8.4756906e-008
+ dwg=0                     dwb=0                     pclm=0.99774222
+ wpclm=2.2613902e-008      pdiblc1=0                 pdiblc2=0.003
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.34303396           wkt1=-6.6711012e-009      kt1l=0
+ kt2=-0.11091911           wkt2=1.9221817e-008       ute=-2
+ ua1=3.16888e-009          wua1=7.1233792e-016       ub1=-9.8871111e-019
+ wub1=-1.1306951e-025      uc1=1.970758e-010         prt=0
+ at=170000                 jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lvth0=0+dlvthn_na         pvth0=0+dpvthn_na
+ lk2=0+dlk2n_na            pk2=0+dpk2n_na            lcit=0+dlcitn_na
+ wcit=0+dwcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            la0=0+dla0_na
+ lags=0+dlagsn_na          pags=0+dpagsn_na          fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian_na             rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na             rnoib=0                   noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     7: type=n 
+ lmin=1e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=1e-006-(dxwn_na+dwmisn_na)                     wmax=1e-005-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=2.058866e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=2.058866e-08+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.092132492+(dvthn_na+vthmisn_na)
+ lvth0=2.2902183e-08+dlvthn_na                       wvth0=2.450592e-09+dwvthn_na
+ pvth0=3.1850191e-14+dpvthn_na                       k1=0.070346
+ k2=0.033802907+dk2n_na    lk2=-5.984753e-09+dlk2n_na
+ wk2=8.5170624e-09+dwk2n_na                          pk2=-1.4155639e-16+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0010695424+dcitn_na lcit=3.0287713e-10+dlcitn_na
+ wcit=9.49003e-11+dwcitn_na                          pcit=-9.4370937e-16+dpcitn_na
+ voff=-0.089359845         lvoff=2.4867266e-009      wvoff=-5.3051086e-009
+ pvoff=-2.5952008e-014     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.0858699e-009
+ lua=3.8635103e-016        wua=2.2295845e-016        pua=-5.7031307e-022
+ ub=1.8950864e-18          pub=0                     wub=0
+ lub=1.0432845e-24         uc=1.18e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=8.6423929              la0=1.8834763e-007+dla0_na
+ wa0=4.3173629e-006        pa0=-9.2011664e-012       ags=1.0984947+dagsn_na
+ lags=8.2173258e-07+dlagsn_na                        wags=-1.0836027e-07+dwagsn_na
+ pags=9.6511977e-13+dpagsn_na                        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.10430995          lketa=8.8284314e-009      wketa=9.364906e-008
+ pketa=-8.8425568e-014     dwg=0                     dwb=0
+ pclm=0.96183472           lpclm=3.5707225e-007      wpclm=2.4986409e-008
+ ppclm=-2.3592734e-014     pdiblc1=0                 pdiblc2=0.0026509127
+ lpdiblc2=3.4714018e-009   wpdiblc2=3.4401345e-010   ppdiblc2=-3.4209465e-015
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.34770366           lkt1=4.6436548e-008       wkt1=-8.9724325e-009
+ pkt1=2.2884952e-014       kt1l=0                    kt2=-0.11212543
+ lkt2=1.1995917e-008       wkt2=2.0586008e-008       pkt2=-1.3565822e-014
+ ute=-2                    ua1=3.1009269e-009        lua1=6.7574118e-016
+ wua1=9.0958171e-016       pua1=-1.9614362e-021      ub1=-5.2337123e-019
+ lub1=-4.6274436e-024      wub1=-2.0286888e-025      pub1=8.92985e-031
+ uc1=1.970758e-010         prt=0                     at=170082.91
+ lat=-0.00082442662        wat=-0.0008303773         pat=8.257457e-009
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noian_na             rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na             rnoib=0
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     8: type=n 
+ lmin=5e-007-(dxln_na+dlmisn_na)                     lmax=1e-006-(dxln_na+dlmisn_na)
+ wmin=1e-006-(dxwn_na+dwmisn_na)                     wmax=1e-005-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=3.259685e-09
+ ll=2.87292e-3             wl=0                      lln=-0.869
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=2.87292e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=3.259685e-09+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.099783304+(dvthn_na+vthmisn_na)
+ lvth0=1.5678112e-008+dlvthn_na                      wvth0=5.0154806e-008+dwvthn_na
+ pvth0=-1.319321e-014+dpvthn_na                      k1=0.070346
+ k2=0.028766279+dk2n_na    lk2=-1.2290535e-009+dlk2n_na
+ wk2=6.7549251e-009+dwk2n_na                         pk2=1.5222935e-015+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.001106659+dcitn_na  lcit=2.6783075e-010+dlcitn_na
+ wcit=-1.8718873e-009+dwcitn_na                      pcit=9.1337609e-016+dpcitn_na
+ voff=-0.074338306         lvoff=-1.1696951e-008     wvoff=-5.2136783e-008
+ pvoff=1.8267522e-014      nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.2778223e-009
+ lua=2.0510524e-016        wua=-2.3332418e-016       pua=-1.3948065e-022
+ ub=3e-018                 uc=7.9976931e-011         luc=3.5902245e-017
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=9.4086291
+ la0=-5.3514994e-007+dla0_na                         wa0=-6.4860601e-006
+ pa0=9.9967085e-013        ags=1.2372369+dagsn_na    lags=6.9072904e-007+dlagsn_na
+ wags=1.1433544e-006+dwagsn_na                       pags=-2.1677764e-013+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.131642             lpclm=1.9673632e-007
+ wpclm=1.8271812e-007      ppclm=-1.725266e-013      pdiblc1=0
+ pdiblc2=0.0053660701      lpdiblc2=9.0768854e-010   wpdiblc2=-3.1715346e-009
+ ppdiblc2=-1.0148623e-016  pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.31652953           lkt1=1.7001229e-008
+ wkt1=3.3751158e-008       pkt1=-1.7455632e-014      kt1l=0
+ kt2=-0.10725711           lkt2=7.3991336e-009       wkt2=-9.8242038e-010
+ pkt2=6.7995776e-015       ute=-2                    ua1=4.1402491e-009
+ lua1=-3.0561046e-016      wua1=-1.6917435e-015      pua1=4.947941e-022
+ ub1=-4.72532e-018         lub1=-6.5986811e-025      wub1=1.1695672e-024
+ pub1=-4.0290034e-031      uc1=1.970758e-010         prt=0
+ at=175952.87              lat=-0.0063669839         wat=0.018448028
+ pat=-9.9456508e-009       jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian_na
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na
+ rnoib=0                   noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     9: type=n 
+ lmin=3e-007-(dxln_na+dlmisn_na)                     lmax=5e-007-(dxln_na+dlmisn_na)
+ wmin=1e-006-(dxwn_na+dwmisn_na)                     wmax=1e-005-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=3.259685e-09
+ ll=2.87292e-3             wl=0                      lln=-0.869
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=2.87292e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=3.259685e-09+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.10562126+(dvthn_na+vthmisn_na)
+ lvth0=1.2991779e-008+dlvthn_na                      wvth0=4.1033755e-008+dwvthn_na
+ pvth0=-8.996167e-015+dpvthn_na                      k1=0.070346
+ k2=0.025033315+dk2n_na    lk2=4.8866629e-010+dlk2n_na
+ wk2=1.1001613e-008+dwk2n_na                         pk2=-4.3181602e-016+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0015347698+dcitn_na lcit=7.0835961e-011+dlcitn_na
+ wcit=2.6947389e-010+dwcitn_na                       pcit=-7.1969336e-017+dpcitn_na
+ voff=-0.078121597         lvoff=-9.9560735e-009     wvoff=-2.9642128e-008
+ pvoff=7.916627e-015       nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.6044109e-009
+ lua=5.4825776e-017        wua=-4.5143738e-016       pua=-3.9116054e-023
+ ub=3e-018                 uc=1.4416741e-010         luc=6.3650524e-018
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=15.542661
+ la0=-3.3577194e-006+dla0_na                         wa0=-8.6123178e-006
+ pa0=1.9780664e-012        ags=-0.82996015+dagsn_na  lags=1.6419479e-006+dlagsn_na
+ wags=4.6557863e-007+dwagsn_na                       pags=9.5100281e-014+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.8208914            lpclm=-1.2042113e-007
+ wpclm=-4.5810562e-007     ppclm=1.2234787e-013      pdiblc1=0
+ pdiblc2=0.0088780799      lpdiblc2=-7.0835961e-010  wpdiblc2=-4.9561292e-009
+ ppdiblc2=7.1969336e-016   pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.30729433           lkt1=1.2751661e-008
+ wkt1=-3.7143588e-009      pkt1=-2.1590801e-016      kt1l=0
+ kt2=-0.098704754          lkt2=3.4637766e-009       wkt2=2.1301891e-008
+ pkt2=-3.4545281e-015      ute=-2                    ua1=3.747956e-009
+ lua1=-1.2509716e-016      wua1=-9.7917637e-016      pua1=1.6690697e-022
+ ub1=-8.0686238e-018       lub1=8.785501e-025        wub1=2.3759514e-024
+ pub1=-9.5801694e-031      uc1=2.6620526e-010        luc1=-3.1809858e-017
+ prt=0                     at=284953.39              lat=-0.056523476
+ wat=-0.044769512          pat=1.9143843e-008        jss=2.25e-06
+ jsd=2.25e-06              jsws=2.22e-12             jswd=2.22e-12
+ jswgs=2.22e-12            jswgd=2.22e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19.0
+ bvd=19.0                  xjbvs=1                   xjbvd=1
+ pbs=0.4                   pbd=0.4                   cjs=cjn_na
+ cjd=cjn_na                mjs=0.31                  mjd=0.31
+ pbsws=0.4                 pbswd=0.4                 cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.01                mjswd=0.01
+ pbswgs=1.16               pbswgd=1.16               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.98               mjswgd=0.98
+ tpb=2.2e-3                tcj=2.55e-3               tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=5e-3               tcjswg=1.26e-2
+ xtis=3                    xtid=3                    dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163e-6
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    kvth0=2.0e-9
+ lkvth0=3e-7               wkvth0=1e-7               pkvth0=0
+ llodvth=1.00              wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=-4.86e-8
+ lku0=1.8e-7               wku0=6e-7                 pku0=0
+ llodku0=1                 wlodku0=1                 kvsat=-0.0
+ steta0=0.0e-06            tku0=0                    lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian_na             rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na             rnoib=0                   noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     10: type=n 
+ lmin=2e-07                lmax=3e-007-(dxln_na+dlmisn_na)
+ wmin=1e-006-(dxwn_na+dwmisn_na)                     wmax=1e-005-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=4.72872e-3             wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=4.72872e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=2.8625e-10+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.1373813+(dvthn_na+vthmisn_na)
+ lvth0=4.5095148e-009+dlvthn_na                      wvth0=1.1629482e-008+dwvthn_na
+ pvth0=-1.1430648e-015+dpvthn_na                     k1=0.070346
+ k2=0.021775386+dk2n_na    lk2=1.3587727e-009+dlk2n_na
+ wk2=1.4553807e-008+dwk2n_na                         pk2=-1.3805131e-015+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0017185978+dcitn_na lcit=2.1740363e-011+dlcitn_na
+ wcit=8.2704607e-011+dwcitn_na                       pcit=-2.2088209e-017+dpcitn_na
+ voff=-0.11611732          lvoff=1.9157827e-010      wvoff=-2.5224905e-009
+ pvoff=6.7369037e-016      nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.9976377e-009
+ lua=-5.0194663e-017       wua=-2.5215669e-015       pua=5.137607e-022
+ ub=2.8959229e-018         lub=2.7796235e-026        wub=2.8739851e-024
+ pub=-7.6756526e-031       uc=1.68e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=3.4114834              la0=-1.1780325e-007+dla0_na
+ wa0=-1.2917149e-007       pa0=-2.8755717e-013       ags=4.2575925+dagsn_na
+ lags=2.8319742e-007+dlagsn_na                       wags=1.1442353e-005+dwagsn_na
+ pags=-2.8365054e-012+dpagsn_na                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.09496             dwg=0                     dwb=0
+ pclm=1.5124538            lpclm=-3.8045635e-008     wpclm=-1.4473306e-007
+ ppclm=3.8654366e-014      pdiblc1=0                 pdiblc2=0.010092381
+ lpdiblc2=-1.0326672e-009  wpdiblc2=-6.1898591e-009  ppdiblc2=1.0491899e-015
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.26665651           lkt1=1.8983748e-009       wkt1=-6.5903956e-009
+ pkt1=5.5220522e-016       kt1l=0                    kt2=-0.091247904
+ lkt2=1.4722497e-009       wkt2=-5.2360145e-010      pkt2=2.3744825e-015
+ ute=-2                    ua1=4.3251109e-009        lua1=-2.7923992e-016
+ wua1=-5.8807183e-016      pua1=6.2453306e-023       ub1=-7.5485974e-018
+ lub1=7.3966483e-025       wub1=3.3720235e-025       pub1=-4.1352109e-031
+ uc1=1.471e-010            prt=0                     at=145278.42
+ lat=-0.019219992          wat=0.02773759            pat=-2.2088209e-010
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noian_na             rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na             rnoib=0
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     11: type=n 
+ lmin=1e-005-(dxln_na+dlmisn_na)                     lmax=2.000001e-05
+ wmin=5e-07                wmax=1e-006-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=2.058866e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=2.058866e-08+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.107224+(dvthn_na+vthmisn_na)
+ wvth0=-7.339584e-09+dwvthn_na                       k1=0.070346
+ k2=0.037958+dk2n_na       wk2=3.669792e-09+dwk2n_na k3=-0.375
+ k3b=-0.023928             w0=0                      dvt0=0.07
+ dvt1=0.05244              dvt2=0.35                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=-2.8623e-009        dvtp0=1e-007
+ dvtp1=0.203               lpe0=9e-007               lpeb=3e-008
+ xj=1.1e-007               ngate=3.6769e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0+dcdscdn_na        cit=0.0011+dcitn_na
+ voff=-0.1071168           wvoff=1.0380269e-008      nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.2626651e-009         wua=2.5456823e-017        ub=2e-18
+ pub=0                     wub=0                     lub=0
+ uc=1.18e-010              eu=1.67                   vsat=109000+dvsat_na
+ pvsat=0+dpvsat_na         wvsat=0+dwvsat_na         lvsat=0+dlvsat_na
+ a0=14.064                 wa0=-2.097024e-006        ags=1.25256+dagsn_na
+ wags=-8.388096e-08+dwagsn_na                        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.02                dwg=0                     dwb=0
+ pclm=1.04064              wpclm=-2.097024e-008      pdiblc1=0
+ pdiblc2=0.0026904         wpdiblc2=3.145536e-010    pdiblcb=0.16
+ drout=0.5                 pvag=10                   delta=0.01
+ pscbe1=2.2702e+008        pscbe2=2e-006             fprout=250
+ pdits=0.65                pditsd=0.7001             pditsl=0
+ rsh=16.39                 rsw=40+drdswn_na          rdw=40+drdswn_na
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.0455e-7          alpha1=3.3148e-1          beta0=12.87
+ agidl=3.466e-007          bgidl=2.185e+009          cgidl=0.5
+ aigbacc=0.0122            bigbacc=0.004014          cigbacc=0.1722
+ nigbacc=6.9984            aigbinv=0.04347           bigbinv=0.026295
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01107874           bigc=0.0021748            cigc=0.025272
+ aigsd=0.00875             bigsd=0.0001934           cigsd=0.0045111
+ nigc=3.9                  poxedge=1                 pigcd=3.8556
+ ntox=ntoxn_na             xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.07200
+ noff=3.247700             voffcv=-240.3800e-03      kt1=-0.339796
+ wkt1=-9.960864e-009       kt1l=0                    kt2=-0.0897296
+ wkt2=-2.3067264e-009      ute=-2                    ua1=4.29312e-009
+ wua1=-4.2988992e-016      ub1=-1.2032e-018          wub1=1.048512e-025
+ uc1=1.970758e-010         prt=0                     at=170000
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ lvth0=0+dlvthn_na         pvth0=0+dpvthn_na         lk2=0+dlk2n_na
+ pk2=0+dpk2n_na            lcit=0+dlcitn_na          wcit=0+dwcitn_na
+ pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            la0=0+dla0_na             lags=0+dlagsn_na
+ pags=0+dpagsn_na          fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian_na
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na
+ rnoib=0                   noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     12: type=n 
+ lmin=1e-006-(dxln_na+dlmisn_na)                     lmax=1e-005-(dxln_na+dlmisn_na)
+ wmin=5e-07                wmax=1e-006-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=2.058866e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=2.058866e-08+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.1023315+(dvthn_na+vthmisn_na)
+ lvth0=4.8652114e-08+dlvthn_na                       wvth0=-7.911601e-09+dwvthn_na
+ pvth0=5.688261e-15+dpvthn_na                        k1=0.070346
+ k2=0.038649633+dk2n_na    lk2=-6.877749e-09+dlk2n_na
+ wk2=3.5927898e-09+dwk2n_na                          pk2=7.657274e-16+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0011954294+dcitn_na lcit=-9.489716e-10+dlcitn_na
+ wcit=-3.3001e-11+dwcitn_na                          pcit=3.281689e-16+dpcitn_na
+ voff=-0.10561024          lvoff=-1.4981566e-008     wvoff=1.1205293e-008
+ pvoff=-8.2042226e-015     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.2776326e-009
+ lua=-1.4884026e-016       wua=2.8127591e-017        pua=-2.6558709e-023
+ ub=1.8950864e-18          pub=0                     wub=0
+ lub=1.0432845e-24         uc=1.18e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=15.226443              la0=-1.1559593e-005+dla0_na
+ wa0=-2.372032e-006        pa0=2.7347409e-012        ags=1.0529471+dagsn_na
+ lags=1.9849957e-06+dlagsn_na                        wags=-6.2083826e-08+dwagsn_na
+ pags=-2.1675557e-13+dpagsn_na                       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.012135674         lketa=-7.8204608e-008     dwg=0
+ dwb=0                     pclm=1.0103158            lpclm=3.0155096e-007
+ wpclm=-2.4270336e-008     ppclm=3.281689e-014       pdiblc1=0
+ pdiblc2=0.0028455631      lpdiblc2=-1.5429761e-009  wpdiblc2=1.462487e-010
+ ppdiblc2=1.6736614e-015   pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.34838734           lkt1=8.5434153e-008
+ wkt1=-8.277815e-009       pkt1=-1.6736614e-014      kt1l=0
+ kt2=-0.09038359           lkt2=6.5034185e-009       wkt2=-1.503703e-009
+ pkt2=-7.9854434e-015      ute=-2                    ua1=4.4579557e-009
+ lua1=-1.6391634e-015      wua1=-4.6915963e-016      pua1=3.9050678e-022
+ ub1=-7.3822111e-019       lub1=-4.6238537e-024      wub1=1.5418599e-026
+ pub1=8.8933773e-031       uc1=1.970758e-010         prt=0
+ at=169049.06              lat=0.009456331           wat=0.0002200064
+ pat=-2.1877927e-009       jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian_na
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na
+ rnoib=0                   noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     13: type=n 
+ lmin=5e-007-(dxln_na+dlmisn_na)                     lmax=1e-006-(dxln_na+dlmisn_na)
+ wmin=5e-07                wmax=1e-006-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=3.259685e-09
+ ll=2.87292e-3             wl=0                      lln=-0.869
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=2.87292e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=3.259685e-09+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.14835718+(dvthn_na+vthmisn_na)
+ lvth0=5.1936188e-009+dlvthn_na                      wvth0=8.0374439e-010+dwvthn_na
+ pvth0=-2.5409656e-015+dpvthn_na                     k1=0.070346
+ k2=0.027794093+dk2n_na    lk2=3.3722979e-009+dlk2n_na
+ wk2=7.7426656e-009+dwk2n_na                         pk2=-3.1526795e-015+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=-0.0014573677+dcitn_na                          lcit=1.5558597e-009+dlcitn_na
+ wcit=7.3316387e-010+dwcitn_na                       pcit=-3.9526132e-016+dpcitn_na
+ voff=-0.12263726          lvoff=1.0957365e-009      wvoff=-3.0650414e-009
+ pvoff=5.2701509e-015      nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.0460143e-009
+ lua=6.9858948e-017        wua=2.1927204e-018        pua=-2.0704164e-024
+ ub=3e-018                 uc=7.9976931e-011         luc=3.5902245e-017
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=-0.11054551
+ la0=2.9219401e-006+dla0_na                          wa0=3.1854213e-006
+ pa0=-2.5127326e-012       ags=3.805396+dagsn_na     lags=-6.1392911e-007+dlagsn_na
+ wags=-1.4658952e-006+dwagsn_na                      pags=1.108755e-012+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.2717328            lpclm=5.4715022e-008
+ wpclm=4.0385853e-008      ppclm=-2.8232951e-014     pdiblc1=0
+ pdiblc2=-0.00045830506    lpdiblc2=1.5766112e-009   wpdiblc2=2.7460306e-009
+ ppdiblc2=-7.8111165e-016  pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.24427665           lkt1=-1.2869519e-008
+ wkt1=-3.9657766e-008      pkt1=1.2893048e-014       kt1l=0
+ kt2=-0.079388748          lkt2=-3.8781605e-009      wkt2=-2.9296672e-008
+ pkt2=1.8257308e-014       ute=-2                    ua1=2.5818621e-009
+ lua1=1.3228683e-016       wua1=-1.0842235e-016      pua1=4.9890448e-023
+ ub1=-5.4120358e-018       lub1=-2.1073182e-025      wub1=1.8672704e-024
+ pub1=-8.5922281e-031      uc1=1.970758e-010         prt=0
+ at=194016.19              lat=-0.014118199          wat=9.5696439e-005
+ pat=-2.0704164e-009       jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian_na
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na
+ rnoib=0                   noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     14: type=n 
+ lmin=3e-007-(dxln_na+dlmisn_na)                     lmax=5e-007-(dxln_na+dlmisn_na)
+ wmin=5e-07                wmax=1e-006-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=3.259685e-09
+ ll=2.87292e-3             wl=0                      lln=-0.869
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=2.87292e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=3.259685e-09+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.16535631+(dvthn_na+vthmisn_na)
+ lvth0=-2.628512e-009+dlvthn_na                      wvth0=-1.9657046e-008+dwvthn_na
+ pvth0=6.8740488e-015+dpvthn_na                      k1=0.070346
+ k2=0.034913098+dk2n_na    lk2=9.6494194e-011+dlk2n_na
+ wk2=9.6375337e-010+dwk2n_na                         pk2=-3.3369169e-017+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.00192384+dcitn_na   wcit=-1.2582144e-010+dwcitn_na
+ voff=-0.1326832           lvoff=5.7183631e-009      wvoff=2.5792456e-008
+ pvoff=-8.0086006e-015     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.0957293e-009
+ lua=4.6982662e-017        wua=6.538318e-017         pua=-3.114745e-023
+ ub=3e-018                 uc=1.4416741e-010         luc=6.3650524e-018
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=10.831095
+ la0=-2.112846e-006+dla0_na                          wa0=-3.8253664e-006
+ pa0=7.13275e-013          ags=4.3714821+dagsn_na    lags=-8.7441308e-007+dlagsn_na
+ wags=-4.8190867e-006+dwagsn_na                      pags=2.6517231e-012+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.096387523         lketa=6.5687341e-010
+ wketa=1.4503633e-009      pketa=-6.6738338e-016     dwg=0
+ dwb=0                     pclm=1.39064              wpclm=-2.097024e-008
+ pdiblc1=0                 pdiblc2=0.002968          wpdiblc2=1.048512e-009
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.29935224           lkt1=1.2473466e-008       wkt1=-1.178352e-008
+ pkt1=6.6738338e-017       kt1l=0                    kt2=-0.097234025
+ lkt2=4.3333277e-009       wkt2=1.980763e-008        pkt2=-4.337992e-015
+ ute=-2                    ua1=2.7841997e-009        lua1=3.9181353e-017
+ ub1=-5.7300889e-018       lub1=-6.4379959e-026      uc1=2.6620526e-010
+ luc1=-3.1809858e-017      prt=0                     at=251504.42
+ lat=-0.040571353          wat=-0.010785349          pat=2.9364869e-009
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ lcit=0+dlcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian_na             rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na             rnoib=0                   noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     15: type=n 
+ lmin=2e-07                lmax=3e-007-(dxln_na+dlmisn_na)
+ wmin=5e-07                wmax=1e-006-(dxwn_na+dwmisn_na)
+ version=4.5               tempmod=0                 ud=0
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_na      permod=1
+ acnqsmod=0                trnqsmod=0                tnom=25
+ toxe=(toxn_na+toxmisn_na) toxm=2e-009               dtox=2.0684e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=4.72872e-3             wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=4.72872e-3            wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln_na+dlmisn_na)
+ xw=1.6e-08+(dxwn_na+dwmisn_na)                      dlc=2.8625e-10+ddlcn_na
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.14618228+(dvthn_na+vthmisn_na)
+ lvth0=2.4923625e-009+dlvthn_na                      wvth0=2.6876898e-009+dwvthn_na
+ pvth0=9.0636195e-016+dpvthn_na                      k1=0.070346
+ k2=0.035463114+dk2n_na    lk2=-5.0400482e-011+dlk2n_na
+ wk2=6.4707628e-010+dwk2n_na                         pk2=5.120689e-017+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.00192384+dcitn_na   wcit=-1.2582144e-010+dwcitn_na
+ voff=-0.12296422          lvoff=3.122681e-009       wvoff=4.4339516e-009
+ pvoff=-2.3043101e-015     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=-5.0355601e-010
+ lua=4.7410938e-016        wua=1.9645815e-017        pua=-1.8932211e-023
+ ub=6.0171549e-018         lub=-8.0580213e-025       wub=-2.9718665e-025
+ pub=7.937068e-032         uc=1.68e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=6.3563924              la0=-9.1777146e-007+dla0_na
+ wa0=-3.121199e-006        pa0=5.2521053e-013        ags=2.633742+dagsn_na
+ lags=-4.1030876e-007+dlagsn_na                      wags=1.3092186e-005+dwagsn_na
+ pags=-2.1319031e-012+dpagsn_na                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.084492305         lketa=-2.5200241e-009     wketa=-1.0635178e-008
+ pketa=2.5603445e-015      dwg=0                     dwb=0
+ pclm=1.39064              wpclm=-2.097024e-008      pdiblc1=0
+ pdiblc2=0.002968          wpdiblc2=1.048512e-009    pdiblcb=0.16
+ drout=0.5                 pvag=10                   delta=0.01
+ pscbe1=2.2702e+008        pscbe2=2e-006             fprout=250
+ pdits=0.65                pditsd=0.7001             pditsl=0
+ rsh=16.39                 rsw=40+drdswn_na          rdw=40+drdswn_na
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.0455e-7          alpha1=3.3148e-1          beta0=12.87
+ agidl=3.466e-007          bgidl=2.185e+009          cgidl=0.5
+ aigbacc=0.0122            bigbacc=0.004014          cigbacc=0.1722
+ nigbacc=6.9984            aigbinv=0.04347           bigbinv=0.026295
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01107874           bigc=0.0021748            cigc=0.025272
+ aigsd=0.00875             bigsd=0.0001934           cigsd=0.0045111
+ nigc=3.9                  poxedge=1                 pigcd=3.8556
+ ntox=ntoxn_na             xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.07200
+ noff=3.247700             voffcv=-240.3800e-03      kt1=-0.23471067
+ lkt1=-4.7905854e-009      wkt1=-3.9047364e-008      pkt1=7.3481887e-015
+ kt1l=0                    kt2=-0.11055789           lkt2=7.8917779e-009
+ wkt2=1.909534e-008        pkt2=-4.1477581e-015      ute=-2
+ ua1=2.2648959e-009        lua1=1.7787366e-016       wua1=1.5051066e-015
+ pua1=-4.0197409e-022      ub1=-5.1785952e-018       lub1=-2.1166933e-025
+ wub1=-2.0707199e-024      pub1=5.5303441e-031       uc1=1.471e-010
+ prt=0                     at=181431.07              lat=-0.021856618
+ wat=-0.0089934972         pat=2.4579307e-009        jss=2.25e-06
+ jsd=2.25e-06              jsws=2.22e-12             jswd=2.22e-12
+ jswgs=2.22e-12            jswgd=2.22e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19.0
+ bvd=19.0                  xjbvs=1                   xjbvd=1
+ pbs=0.4                   pbd=0.4                   cjs=cjn_na
+ cjd=cjn_na                mjs=0.31                  mjd=0.31
+ pbsws=0.4                 pbswd=0.4                 cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.01                mjswd=0.01
+ pbswgs=1.16               pbswgd=1.16               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.98               mjswgd=0.98
+ tpb=2.2e-3                tcj=2.55e-3               tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=5e-3               tcjswg=1.26e-2
+ xtis=3                    xtid=3                    dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163e-6
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    kvth0=2.0e-9
+ lkvth0=3e-7               wkvth0=1e-7               pkvth0=0
+ llodvth=1.00              wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=-4.86e-8
+ lku0=1.8e-7               wku0=6e-7                 pku0=0
+ llodku0=1                 wlodku0=1                 kvsat=-0.0
+ steta0=0.0e-06            tku0=0                    lcit=0+dlcitn_na
+ pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian_na
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na
+ rnoib=0                   noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
     } 
ends nch_na_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.0V NATIVE NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch_na bsim4  { 
     1: type=n 
+ lmin=1e-005-dxln_na       lmax=2.000001e-05         wmin=1e-005-dxwn_na
+ wmax=0.00090000001        version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.058866e-08+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.095+dvthn_na       k1=0.070346               k2=0.03405+dk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0011+dcitn_na       voff=-0.0899              nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.141256e-009          ub=2e-18                  pub=0
+ wub=0                     lub=0                     uc=1.18e-010
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=9
+ ags=1.18+dagsn_na         a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.09496
+ dwg=0                     dwb=0                     pclm=1
+ pdiblc1=0                 pdiblc2=0.003             pdiblcb=0.16
+ drout=0.5                 pvag=10                   delta=0.01
+ pscbe1=2.2702e+008        pscbe2=2e-006             fprout=250
+ pdits=0.65                pditsd=0.7001             pditsl=0
+ rsh=16.39                 rsw=40+drdswn_na          rdw=40+drdswn_na
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.0455e-7          alpha1=3.3148e-1          beta0=12.87
+ agidl=3.466e-007          bgidl=2.185e+009          cgidl=0.5
+ aigbacc=0.0122            bigbacc=0.004014          cigbacc=0.1722
+ nigbacc=6.9984            aigbinv=0.04347           bigbinv=0.026295
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01107874           bigc=0.0021748            cigc=0.025272
+ aigsd=0.00875             bigsd=0.0001934           cigsd=0.0045111
+ nigc=3.9                  poxedge=1                 pigcd=3.8556
+ ntox=ntoxn_na             xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.07200
+ noff=3.247700             voffcv=-240.3800e-03      kt1=-0.3437
+ kt1l=0                    kt2=-0.109                ute=-2
+ ua1=3.24e-009             ub1=-1e-018               uc1=1.970758e-010
+ prt=0                     at=170000                 jss=2.25e-06
+ jsd=2.25e-06              jsws=2.22e-12             jswd=2.22e-12
+ jswgs=2.22e-12            jswgd=2.22e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19.0
+ bvd=19.0                  xjbvs=1                   xjbvd=1
+ pbs=0.4                   pbd=0.4                   cjs=cjn_na
+ cjd=cjn_na                mjs=0.31                  mjd=0.31
+ pbsws=0.4                 pbswd=0.4                 cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.01                mjswd=0.01
+ pbswgs=1.16               pbswgd=1.16               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.98               mjswgd=0.98
+ tpb=2.2e-3                tcj=2.55e-3               tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=5e-3               tcjswg=1.26e-2
+ xtis=3                    xtid=3                    dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163e-6
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    kvth0=2.0e-9
+ lkvth0=3e-7               wkvth0=1e-7               pkvth0=0
+ llodvth=1.00              wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=-4.86e-8
+ lku0=1.8e-7               wku0=6e-7                 pku0=0
+ llodku0=1                 wlodku0=1                 kvsat=-0.0
+ steta0=0.0e-06            tku0=0                    lvth0=0+dlvthn_na
+ wvth0=0+dwvthn_na         pvth0=0+dpvthn_na         lk2=0+dlk2n_na
+ wk2=0+dwk2n_na            pk2=0+dpk2n_na            lcit=0+dlcitn_na
+ wcit=0+dwcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            la0=0+dla0_na
+ lags=0+dlagsn_na          wags=0+dwagsn_na          pags=0+dpagsn_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     2: type=n 
+ lmin=1e-006-dxln_na       lmax=1e-005-dxln_na       wmin=1e-005-dxwn_na
+ wmax=0.00090000001        version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.058866e-08+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.09237716+dvthn_na  lvth0=2.6082114e-08+dlvthn_na
+ k1=0.070346               k2=0.034653253+dk2n_na    lk2=-5.998886e-09+dlk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0010790172+dcitn_na lcit=2.086569e-10+dlcitn_na
+ voff=-0.089889509         lvoff=-1.0432845e-010     nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.1081302e-009         lua=3.2941083e-016        ub=1.8950864e-18
+ pub=0                     wub=0                     lub=1.0432845e-24
+ uc=1.18e-010              eu=1.67                   vsat=109000+dvsat_na
+ pvsat=0+dpvsat_na         wvsat=0+dwvsat_na         lvsat=0+dlvsat_na
+ a0=9.0734395              la0=-7.3029917e-007+dla0_na
+ ags=1.087676+dagsn_na     lags=9.1809038e-07+dlagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=0.96432937           lpclm=3.5471674e-007
+ pdiblc1=0                 pdiblc2=0.0026852591      lpdiblc2=3.1298536e-009
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.34859947           lkt1=4.8721388e-008       kt1l=0
+ kt2=-0.11007012           lkt2=1.0641502e-008       ute=-2
+ ua1=3.1917397e-009        lua1=4.7991088e-016       ub1=-5.4362571e-019
+ lub1=-4.5382877e-024      uc1=1.970758e-010         prt=0
+ at=170000                 jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    wvth0=0+dwvthn_na         pvth0=0+dpvthn_na
+ wk2=0+dwk2n_na            pk2=0+dpk2n_na            wcit=0+dwcitn_na
+ pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            wags=0+dwagsn_na          pags=0+dpagsn_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     3: type=n 
+ lmin=5e-007-dxln_na       lmax=1e-006-dxln_na       wmin=1e-005-dxwn_na
+ wmax=0.00090000001        version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=2.87292e-3             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=2.87292e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=3.259685e-09+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.10479077+dvthn_na  lvth0=1.4360898e-008+dlvthn_na
+ k1=0.070346               k2=0.029440692+dk2n_na    lk2=-1.0770674e-009+dlk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.00091976931+dcitn_na                          lcit=3.5902245e-010+dlcitn_na
+ voff=-0.079543656         lvoff=-9.8731174e-009     nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.2545272e-009         lua=1.9117946e-016        ub=3e-018
+ uc=7.9976931e-011         luc=3.5902245e-017        eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=8.7610592              la0=-4.3534255e-007+dla0_na
+ ags=1.3513897+dagsn_na    lags=6.6908591e-007+dlagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.1498847            lpclm=1.7951123e-007
+ pdiblc1=0                 pdiblc2=0.0050494233      lpdiblc2=8.9755613e-010
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.3131598            lkt1=1.5258454e-008       kt1l=0
+ kt2=-0.10735519           lkt2=8.0780051e-009       ute=-2
+ ua1=3.971345e-009         lua1=-2.5621009e-016      ub1=-4.6085502e-018
+ lub1=-7.0009378e-025      uc1=1.970758e-010         prt=0
+ at=177794.73              lat=-0.0073599602         jss=2.25e-06
+ jsd=2.25e-06              jsws=2.22e-12             jswd=2.22e-12
+ jswgs=2.22e-12            jswgd=2.22e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19.0
+ bvd=19.0                  xjbvs=1                   xjbvd=1
+ pbs=0.4                   pbd=0.4                   cjs=cjn_na
+ cjd=cjn_na                mjs=0.31                  mjd=0.31
+ pbsws=0.4                 pbswd=0.4                 cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.01                mjswd=0.01
+ pbswgs=1.16               pbswgd=1.16               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.98               mjswgd=0.98
+ tpb=2.2e-3                tcj=2.55e-3               tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=5e-3               tcjswg=1.26e-2
+ xtis=3                    xtid=3                    dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163e-6
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    kvth0=2.0e-9
+ lkvth0=3e-7               wkvth0=1e-7               pkvth0=0
+ llodvth=1.00              wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=-4.86e-8
+ lku0=1.8e-7               wku0=6e-7                 pku0=0
+ llodku0=1                 wlodku0=1                 kvsat=-0.0
+ steta0=0.0e-06            tku0=0                    wvth0=0+dwvthn_na
+ pvth0=0+dpvthn_na         wk2=0+dwk2n_na            pk2=0+dpk2n_na
+ wcit=0+dwcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            wags=0+dwagsn_na
+ pags=0+dpagsn_na          fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     4: type=n 
+ lmin=3e-007-dxln_na       lmax=5e-007-dxln_na       wmin=1e-005-dxwn_na
+ wmax=0.00090000001        version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=2.87292e-3             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=2.87292e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=3.259685e-09+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.10971809+dvthn_na  lvth0=1.20936e-008+dlvthn_na
+ k1=0.070346               k2=0.026131719+dk2n_na    lk2=4.4555367e-010+dlk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0015616741+dcitn_na lcit=6.3650524e-011+dlcitn_na
+ voff=-0.081081075         lvoff=-9.1656754e-009     nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.5593393e-009         lua=5.0920419e-017        ub=3e-018
+ uc=1.4416741e-010         luc=6.3650524e-018        eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=14.682805              la0=-3.1602288e-006+dla0_na
+ ags=-0.78347666+dagsn_na  lags=1.6514428e-006+dlagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.775154             lpclm=-1.0820589e-007
+ pdiblc1=0                 pdiblc2=0.0083832587      lpdiblc2=-6.3650524e-010
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.30766517           lkt1=1.2730105e-008       kt1l=0
+ kt2=-0.096577968          lkt2=3.1188757e-009       ute=-2
+ ua1=3.6501948e-009        lua1=-1.0843312e-016      ub1=-7.8314082e-018
+ lub1=7.8290144e-025       uc1=2.6620526e-010        luc1=-3.1809858e-017
+ prt=0                     at=280483.59              lat=-0.054612149
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ wvth0=0+dwvthn_na         pvth0=0+dpvthn_na         wk2=0+dwk2n_na
+ pk2=0+dpk2n_na            wcit=0+dwcitn_na          pcit=0+dpcitn_na
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ wags=0+dwagsn_na          pags=0+dpagsn_na          fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     5: type=n 
+ lmin=2e-07                lmax=3e-007-dxln_na       wmin=1e-005-dxwn_na
+ wmax=0.00090000001        version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=4.72872e-3             wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=4.72872e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.8625e-10+ddlcn_na   dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.13854239+dvthn_na  lvth0=4.3953909e-009+dlvthn_na
+ k1=0.070346               k2=0.023228442+dk2n_na    lk2=1.2209419e-009+dlk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0017268551+dcitn_na lcit=1.9535071e-011+dlcitn_na
+ voff=-0.11636917          lvoff=2.5883969e-010      nfactor=0.5+dnfactorn_na
+ eta0=0.029+deta0n_na      etab=0.25                 u0=0.08+du0n_na
+ ua=1.7458838e-009         lua=1.0993361e-018        ub=3.1828623e-018
+ lub=-4.8837677e-026       uc=1.68e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=3.3985869              la0=-1.4651303e-007+dla0_na
+ ags=5.4+dagsn_na          a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.09496
+ dwg=0                     dwb=0                     pclm=1.4980036
+ lpclm=-3.4186374e-008     pdiblc1=0                 pdiblc2=0.0094743839
+ lpdiblc2=-9.2791586e-010  pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.26731449           lkt1=1.9535071e-009
+ kt1l=0                    kt2=-0.091300181          lkt2=1.7093187e-009
+ ute=-2                    ua1=4.2663976e-009        lua1=-2.7300457e-016
+ ub1=-7.514931e-018        lub1=6.9837878e-025       uc1=1.471e-010
+ prt=0                     at=148047.75              lat=-0.019242045
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ wvth0=0+dwvthn_na         pvth0=0+dpvthn_na         wk2=0+dwk2n_na
+ pk2=0+dpk2n_na            wcit=0+dwcitn_na          pcit=0+dpcitn_na
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ lags=0+dlagsn_na          wags=0+dwagsn_na          pags=0+dpagsn_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     6: type=n 
+ lmin=1e-005-dxln_na       lmax=2.000001e-05         wmin=1e-006-dxwn_na
+ wmax=1e-005-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.058866e-08+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.094435556+dvthn_na wvth0=5.653476e-09+dwvthn_na
+ k1=0.070346               k2=0.033201076+dk2n_na    wk2=8.5028273e-09+dwk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0011+dcitn_na       voff=-0.089109778         wvoff=-7.9148658e-009
+ nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na      etab=0.25
+ u0=0.08+du0n_na           ua=1.1247217e-009         wua=1.6560726e-016
+ ub=2e-18                  pub=0                     wub=0
+ lub=0                     uc=1.18e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=8.6613333              wa0=3.3920853e-006
+ ags=1.1811288+dagsn_na    wags=-1.1306953e-08+dwagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.10342215          wketa=8.4756906e-008
+ dwg=0                     dwb=0                     pclm=0.99774222
+ wpclm=2.2613902e-008      pdiblc1=0                 pdiblc2=0.003
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.34303396           wkt1=-6.6711012e-009      kt1l=0
+ kt2=-0.11091911           wkt2=1.9221817e-008       ute=-2
+ ua1=3.16888e-009          wua1=7.1233792e-016       ub1=-9.8871111e-019
+ wub1=-1.1306951e-025      uc1=1.970758e-010         prt=0
+ at=170000                 jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lvth0=0+dlvthn_na         pvth0=0+dpvthn_na
+ lk2=0+dlk2n_na            pk2=0+dpk2n_na            lcit=0+dlcitn_na
+ wcit=0+dwcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            la0=0+dla0_na
+ lags=0+dlagsn_na          pags=0+dpagsn_na          fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     7: type=n 
+ lmin=1e-006-dxln_na       lmax=1e-005-dxln_na       wmin=1e-006-dxwn_na
+ wmax=1e-005-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.058866e-08+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.092132492+dvthn_na lvth0=2.2902183e-08+dlvthn_na
+ wvth0=2.450592e-09+dwvthn_na                        pvth0=3.1850191e-14+dpvthn_na
+ k1=0.070346               k2=0.033802907+dk2n_na    lk2=-5.984753e-09+dlk2n_na
+ wk2=8.5170624e-09+dwk2n_na                          pk2=-1.4155639e-16+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0010695424+dcitn_na lcit=3.0287713e-10+dlcitn_na
+ wcit=9.49003e-11+dwcitn_na                          pcit=-9.4370937e-16+dpcitn_na
+ voff=-0.089359845         lvoff=2.4867266e-009      wvoff=-5.3051086e-009
+ pvoff=-2.5952008e-014     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.0858699e-009
+ lua=3.8635103e-016        wua=2.2295845e-016        pua=-5.7031307e-022
+ ub=1.8950864e-18          pub=0                     wub=0
+ lub=1.0432845e-24         uc=1.18e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=8.6423929              la0=1.8834763e-007+dla0_na
+ wa0=4.3173629e-006        pa0=-9.2011664e-012       ags=1.0984947+dagsn_na
+ lags=8.2173258e-07+dlagsn_na                        wags=-1.0836027e-07+dwagsn_na
+ pags=9.6511977e-13+dpagsn_na                        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.10430995          lketa=8.8284314e-009      wketa=9.364906e-008
+ pketa=-8.8425568e-014     dwg=0                     dwb=0
+ pclm=0.96183472           lpclm=3.5707225e-007      wpclm=2.4986409e-008
+ ppclm=-2.3592734e-014     pdiblc1=0                 pdiblc2=0.0026509127
+ lpdiblc2=3.4714018e-009   wpdiblc2=3.4401345e-010   ppdiblc2=-3.4209465e-015
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.34770366           lkt1=4.6436548e-008       wkt1=-8.9724325e-009
+ pkt1=2.2884952e-014       kt1l=0                    kt2=-0.11212543
+ lkt2=1.1995917e-008       wkt2=2.0586008e-008       pkt2=-1.3565822e-014
+ ute=-2                    ua1=3.1009269e-009        lua1=6.7574118e-016
+ wua1=9.0958171e-016       pua1=-1.9614362e-021      ub1=-5.2337123e-019
+ lub1=-4.6274436e-024      wub1=-2.0286888e-025      pub1=8.92985e-031
+ uc1=1.970758e-010         prt=0                     at=170082.91
+ lat=-0.00082442662        wat=-0.0008303773         pat=8.257457e-009
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     8: type=n 
+ lmin=5e-007-dxln_na       lmax=1e-006-dxln_na       wmin=1e-006-dxwn_na
+ wmax=1e-005-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=2.87292e-3             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=2.87292e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=3.259685e-09+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.099783304+dvthn_na lvth0=1.5678112e-008+dlvthn_na
+ wvth0=5.0154806e-008+dwvthn_na                      pvth0=-1.319321e-014+dpvthn_na
+ k1=0.070346               k2=0.028766279+dk2n_na    lk2=-1.2290535e-009+dlk2n_na
+ wk2=6.7549251e-009+dwk2n_na                         pk2=1.5222935e-015+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.001106659+dcitn_na  lcit=2.6783075e-010+dlcitn_na
+ wcit=-1.8718873e-009+dwcitn_na                      pcit=9.1337609e-016+dpcitn_na
+ voff=-0.074338306         lvoff=-1.1696951e-008     wvoff=-5.2136783e-008
+ pvoff=1.8267522e-014      nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.2778223e-009
+ lua=2.0510524e-016        wua=-2.3332418e-016       pua=-1.3948065e-022
+ ub=3e-018                 uc=7.9976931e-011         luc=3.5902245e-017
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=9.4086291
+ la0=-5.3514994e-007+dla0_na                         wa0=-6.4860601e-006
+ pa0=9.9967085e-013        ags=1.2372369+dagsn_na    lags=6.9072904e-007+dlagsn_na
+ wags=1.1433544e-006+dwagsn_na                       pags=-2.1677764e-013+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.131642             lpclm=1.9673632e-007
+ wpclm=1.8271812e-007      ppclm=-1.725266e-013      pdiblc1=0
+ pdiblc2=0.0053660701      lpdiblc2=9.0768854e-010   wpdiblc2=-3.1715346e-009
+ ppdiblc2=-1.0148623e-016  pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.31652953           lkt1=1.7001229e-008
+ wkt1=3.3751158e-008       pkt1=-1.7455632e-014      kt1l=0
+ kt2=-0.10725711           lkt2=7.3991336e-009       wkt2=-9.8242038e-010
+ pkt2=6.7995776e-015       ute=-2                    ua1=4.1402491e-009
+ lua1=-3.0561046e-016      wua1=-1.6917435e-015      pua1=4.947941e-022
+ ub1=-4.72532e-018         lub1=-6.5986811e-025      wub1=1.1695672e-024
+ pub1=-4.0290034e-031      uc1=1.970758e-010         prt=0
+ at=175952.87              lat=-0.0063669839         wat=0.018448028
+ pat=-9.9456508e-009       jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     9: type=n 
+ lmin=3e-007-dxln_na       lmax=5e-007-dxln_na       wmin=1e-006-dxwn_na
+ wmax=1e-005-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=2.87292e-3             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=2.87292e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=3.259685e-09+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.10562126+dvthn_na  lvth0=1.2991779e-008+dlvthn_na
+ wvth0=4.1033755e-008+dwvthn_na                      pvth0=-8.996167e-015+dpvthn_na
+ k1=0.070346               k2=0.025033315+dk2n_na    lk2=4.8866629e-010+dlk2n_na
+ wk2=1.1001613e-008+dwk2n_na                         pk2=-4.3181602e-016+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0015347698+dcitn_na lcit=7.0835961e-011+dlcitn_na
+ wcit=2.6947389e-010+dwcitn_na                       pcit=-7.1969336e-017+dpcitn_na
+ voff=-0.078121597         lvoff=-9.9560735e-009     wvoff=-2.9642128e-008
+ pvoff=7.916627e-015       nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.6044109e-009
+ lua=5.4825776e-017        wua=-4.5143738e-016       pua=-3.9116054e-023
+ ub=3e-018                 uc=1.4416741e-010         luc=6.3650524e-018
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=15.542661
+ la0=-3.3577194e-006+dla0_na                         wa0=-8.6123178e-006
+ pa0=1.9780664e-012        ags=-0.82996015+dagsn_na  lags=1.6419479e-006+dlagsn_na
+ wags=4.6557863e-007+dwagsn_na                       pags=9.5100281e-014+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.8208914            lpclm=-1.2042113e-007
+ wpclm=-4.5810562e-007     ppclm=1.2234787e-013      pdiblc1=0
+ pdiblc2=0.0088780799      lpdiblc2=-7.0835961e-010  wpdiblc2=-4.9561292e-009
+ ppdiblc2=7.1969336e-016   pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.30729433           lkt1=1.2751661e-008
+ wkt1=-3.7143588e-009      pkt1=-2.1590801e-016      kt1l=0
+ kt2=-0.098704754          lkt2=3.4637766e-009       wkt2=2.1301891e-008
+ pkt2=-3.4545281e-015      ute=-2                    ua1=3.747956e-009
+ lua1=-1.2509716e-016      wua1=-9.7917637e-016      pua1=1.6690697e-022
+ ub1=-8.0686238e-018       lub1=8.785501e-025        wub1=2.3759514e-024
+ pub1=-9.5801694e-031      uc1=2.6620526e-010        luc1=-3.1809858e-017
+ prt=0                     at=284953.39              lat=-0.056523476
+ wat=-0.044769512          pat=1.9143843e-008        jss=2.25e-06
+ jsd=2.25e-06              jsws=2.22e-12             jswd=2.22e-12
+ jswgs=2.22e-12            jswgd=2.22e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19.0
+ bvd=19.0                  xjbvs=1                   xjbvd=1
+ pbs=0.4                   pbd=0.4                   cjs=cjn_na
+ cjd=cjn_na                mjs=0.31                  mjd=0.31
+ pbsws=0.4                 pbswd=0.4                 cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.01                mjswd=0.01
+ pbswgs=1.16               pbswgd=1.16               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.98               mjswgd=0.98
+ tpb=2.2e-3                tcj=2.55e-3               tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=5e-3               tcjswg=1.26e-2
+ xtis=3                    xtid=3                    dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163e-6
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    kvth0=2.0e-9
+ lkvth0=3e-7               wkvth0=1e-7               pkvth0=0
+ llodvth=1.00              wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=-4.86e-8
+ lku0=1.8e-7               wku0=6e-7                 pku0=0
+ llodku0=1                 wlodku0=1                 kvsat=-0.0
+ steta0=0.0e-06            tku0=0                    lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     10: type=n 
+ lmin=2e-07                lmax=3e-007-dxln_na       wmin=1e-006-dxwn_na
+ wmax=1e-005-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=4.72872e-3             wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=4.72872e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.8625e-10+ddlcn_na   dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.1373813+dvthn_na   lvth0=4.5095148e-009+dlvthn_na
+ wvth0=1.1629482e-008+dwvthn_na                      pvth0=-1.1430648e-015+dpvthn_na
+ k1=0.070346               k2=0.021775386+dk2n_na    lk2=1.3587727e-009+dlk2n_na
+ wk2=1.4553807e-008+dwk2n_na                         pk2=-1.3805131e-015+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0017185978+dcitn_na lcit=2.1740363e-011+dlcitn_na
+ wcit=8.2704607e-011+dwcitn_na                       pcit=-2.2088209e-017+dpcitn_na
+ voff=-0.11611732          lvoff=1.9157827e-010      wvoff=-2.5224905e-009
+ pvoff=6.7369037e-016      nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.9976377e-009
+ lua=-5.0194663e-017       wua=-2.5215669e-015       pua=5.137607e-022
+ ub=2.8959229e-018         lub=2.7796235e-026        wub=2.8739851e-024
+ pub=-7.6756526e-031       uc=1.68e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=3.4114834              la0=-1.1780325e-007+dla0_na
+ wa0=-1.2917149e-007       pa0=-2.8755717e-013       ags=4.2575925+dagsn_na
+ lags=2.8319742e-007+dlagsn_na                       wags=1.1442353e-005+dwagsn_na
+ pags=-2.8365054e-012+dpagsn_na                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.09496             dwg=0                     dwb=0
+ pclm=1.5124538            lpclm=-3.8045635e-008     wpclm=-1.4473306e-007
+ ppclm=3.8654366e-014      pdiblc1=0                 pdiblc2=0.010092381
+ lpdiblc2=-1.0326672e-009  wpdiblc2=-6.1898591e-009  ppdiblc2=1.0491899e-015
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.26665651           lkt1=1.8983748e-009       wkt1=-6.5903956e-009
+ pkt1=5.5220522e-016       kt1l=0                    kt2=-0.091247904
+ lkt2=1.4722497e-009       wkt2=-5.2360145e-010      pkt2=2.3744825e-015
+ ute=-2                    ua1=4.3251109e-009        lua1=-2.7923992e-016
+ wua1=-5.8807183e-016      pua1=6.2453306e-023       ub1=-7.5485974e-018
+ lub1=7.3966483e-025       wub1=3.3720235e-025       pub1=-4.1352109e-031
+ uc1=1.471e-010            prt=0                     at=145278.42
+ lat=-0.019219992          wat=0.02773759            pat=-2.2088209e-010
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na
+ leta0=0+dleta0n_na        weta0=0+dweta0n_na        peta0=0+dpeta0n_na
+ lu0=0+dlu0n_na            wu0=0+dwu0n_na            pu0=0+dpu0n_na
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_na             noib=noibn_na
+ noic=noicn_na             em=3e+5                   ef=0.9
+ lintnoi=0                 minr=1e-3
 
 
     11: type=n 
+ lmin=1e-005-dxln_na       lmax=2.000001e-05         wmin=5e-07
+ wmax=1e-006-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.058866e-08+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.107224+dvthn_na    wvth0=-7.339584e-09+dwvthn_na
+ k1=0.070346               k2=0.037958+dk2n_na       wk2=3.669792e-09+dwk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0011+dcitn_na       voff=-0.1071168           wvoff=1.0380269e-008
+ nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na      etab=0.25
+ u0=0.08+du0n_na           ua=1.2626651e-009         wua=2.5456823e-017
+ ub=2e-18                  pub=0                     wub=0
+ lub=0                     uc=1.18e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=14.064                 wa0=-2.097024e-006
+ ags=1.25256+dagsn_na      wags=-8.388096e-08+dwagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.02                dwg=0
+ dwb=0                     pclm=1.04064              wpclm=-2.097024e-008
+ pdiblc1=0                 pdiblc2=0.0026904         wpdiblc2=3.145536e-010
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.339796             wkt1=-9.960864e-009       kt1l=0
+ kt2=-0.0897296            wkt2=-2.3067264e-009      ute=-2
+ ua1=4.29312e-009          wua1=-4.2988992e-016      ub1=-1.2032e-018
+ wub1=1.048512e-025        uc1=1.970758e-010         prt=0
+ at=170000                 jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lvth0=0+dlvthn_na         pvth0=0+dpvthn_na
+ lk2=0+dlk2n_na            pk2=0+dpk2n_na            lcit=0+dlcitn_na
+ wcit=0+dwcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            la0=0+dla0_na
+ lags=0+dlagsn_na          pags=0+dpagsn_na          fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     12: type=n 
+ lmin=1e-006-dxln_na       lmax=1e-005-dxln_na       wmin=5e-07
+ wmax=1e-006-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.058866e-08+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.1023315+dvthn_na   lvth0=4.8652114e-08+dlvthn_na
+ wvth0=-7.911601e-09+dwvthn_na                       pvth0=5.688261e-15+dpvthn_na
+ k1=0.070346               k2=0.038649633+dk2n_na    lk2=-6.877749e-09+dlk2n_na
+ wk2=3.5927898e-09+dwk2n_na                          pk2=7.657274e-16+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.0011954294+dcitn_na lcit=-9.489716e-10+dlcitn_na
+ wcit=-3.3001e-11+dwcitn_na                          pcit=3.281689e-16+dpcitn_na
+ voff=-0.10561024          lvoff=-1.4981566e-008     wvoff=1.1205293e-008
+ pvoff=-8.2042226e-015     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.2776326e-009
+ lua=-1.4884026e-016       wua=2.8127591e-017        pua=-2.6558709e-023
+ ub=1.8950864e-18          pub=0                     wub=0
+ lub=1.0432845e-24         uc=1.18e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=15.226443              la0=-1.1559593e-005+dla0_na
+ wa0=-2.372032e-006        pa0=2.7347409e-012        ags=1.0529471+dagsn_na
+ lags=1.9849957e-06+dlagsn_na                        wags=-6.2083826e-08+dwagsn_na
+ pags=-2.1675557e-13+dpagsn_na                       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.012135674         lketa=-7.8204608e-008     dwg=0
+ dwb=0                     pclm=1.0103158            lpclm=3.0155096e-007
+ wpclm=-2.4270336e-008     ppclm=3.281689e-014       pdiblc1=0
+ pdiblc2=0.0028455631      lpdiblc2=-1.5429761e-009  wpdiblc2=1.462487e-010
+ ppdiblc2=1.6736614e-015   pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.34838734           lkt1=8.5434153e-008
+ wkt1=-8.277815e-009       pkt1=-1.6736614e-014      kt1l=0
+ kt2=-0.09038359           lkt2=6.5034185e-009       wkt2=-1.503703e-009
+ pkt2=-7.9854434e-015      ute=-2                    ua1=4.4579557e-009
+ lua1=-1.6391634e-015      wua1=-4.6915963e-016      pua1=3.9050678e-022
+ ub1=-7.3822111e-019       lub1=-4.6238537e-024      wub1=1.5418599e-026
+ pub1=8.8933773e-031       uc1=1.970758e-010         prt=0
+ at=169049.06              lat=0.009456331           wat=0.0002200064
+ pat=-2.1877927e-009       jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     13: type=n 
+ lmin=5e-007-dxln_na       lmax=1e-006-dxln_na       wmin=5e-07
+ wmax=1e-006-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=2.87292e-3             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=2.87292e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=3.259685e-09+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.14835718+dvthn_na  lvth0=5.1936188e-009+dlvthn_na
+ wvth0=8.0374439e-010+dwvthn_na                      pvth0=-2.5409656e-015+dpvthn_na
+ k1=0.070346               k2=0.027794093+dk2n_na    lk2=3.3722979e-009+dlk2n_na
+ wk2=7.7426656e-009+dwk2n_na                         pk2=-3.1526795e-015+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=-0.0014573677+dcitn_na                          lcit=1.5558597e-009+dlcitn_na
+ wcit=7.3316387e-010+dwcitn_na                       pcit=-3.9526132e-016+dpcitn_na
+ voff=-0.12263726          lvoff=1.0957365e-009      wvoff=-3.0650414e-009
+ pvoff=5.2701509e-015      nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.0460143e-009
+ lua=6.9858948e-017        wua=2.1927204e-018        pua=-2.0704164e-024
+ ub=3e-018                 uc=7.9976931e-011         luc=3.5902245e-017
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=-0.11054551
+ la0=2.9219401e-006+dla0_na                          wa0=3.1854213e-006
+ pa0=-2.5127326e-012       ags=3.805396+dagsn_na     lags=-6.1392911e-007+dlagsn_na
+ wags=-1.4658952e-006+dwagsn_na                      pags=1.108755e-012+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.09496             dwg=0
+ dwb=0                     pclm=1.2717328            lpclm=5.4715022e-008
+ wpclm=4.0385853e-008      ppclm=-2.8232951e-014     pdiblc1=0
+ pdiblc2=-0.00045830506    lpdiblc2=1.5766112e-009   wpdiblc2=2.7460306e-009
+ ppdiblc2=-7.8111165e-016  pdiblcb=0.16              drout=0.5
+ pvag=10                   delta=0.01                pscbe1=2.2702e+008
+ pscbe2=2e-006             fprout=250                pdits=0.65
+ pditsd=0.7001             pditsl=0                  rsh=16.39
+ rsw=40+drdswn_na          rdw=40+drdswn_na          prwg=0
+ prwb=0                    wr=1                      alpha0=1.0455e-7
+ alpha1=3.3148e-1          beta0=12.87               agidl=3.466e-007
+ bgidl=2.185e+009          cgidl=0.5                 aigbacc=0.0122
+ bigbacc=0.004014          cigbacc=0.1722            nigbacc=6.9984
+ aigbinv=0.04347           bigbinv=0.026295          cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.01107874
+ bigc=0.0021748            cigc=0.025272             aigsd=0.00875
+ bigsd=0.0001934           cigsd=0.0045111           nigc=3.9
+ poxedge=1                 pigcd=3.8556              ntox=ntoxn_na
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na
+ cgdo=cgon_na              cgbo=0                    cgdl=cgln_na
+ cgsl=cgln_na              clc=1e-007                cle=0.6
+ cf=cfn_na                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.07200             noff=3.247700
+ voffcv=-240.3800e-03      kt1=-0.24427665           lkt1=-1.2869519e-008
+ wkt1=-3.9657766e-008      pkt1=1.2893048e-014       kt1l=0
+ kt2=-0.079388748          lkt2=-3.8781605e-009      wkt2=-2.9296672e-008
+ pkt2=1.8257308e-014       ute=-2                    ua1=2.5818621e-009
+ lua1=1.3228683e-016       wua1=-1.0842235e-016      pua1=4.9890448e-023
+ ub1=-5.4120358e-018       lub1=-2.1073182e-025      wub1=1.8672704e-024
+ pub1=-8.5922281e-031      uc1=1.970758e-010         prt=0
+ at=194016.19              lat=-0.014118199          wat=9.5696439e-005
+ pat=-2.0704164e-009       jss=2.25e-06              jsd=2.25e-06
+ jsws=2.22e-12             jswd=2.22e-12             jswgs=2.22e-12
+ jswgd=2.22e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19.0                  bvd=19.0
+ xjbvs=1                   xjbvd=1                   pbs=0.4
+ pbd=0.4                   cjs=cjn_na                cjd=cjn_na
+ mjs=0.31                  mjd=0.31                  pbsws=0.4
+ pbswd=0.4                 cjsws=cjswn_na            cjswd=cjswn_na
+ mjsws=0.01                mjswd=0.01                pbswgs=1.16
+ pbswgd=1.16               cjswgs=cjswgn_na          cjswgd=cjswgn_na
+ mjswgs=0.98               mjswgd=0.98               tpb=2.2e-3
+ tcj=2.55e-3               tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=5e-3               tcjswg=1.26e-2            xtis=3
+ xtid=3                    dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163e-6           rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    kvth0=2.0e-9              lkvth0=3e-7
+ wkvth0=1e-7               pkvth0=0                  llodvth=1.00
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 ku0=-4.86e-8              lku0=1.8e-7
+ wku0=6e-7                 pku0=0                    llodku0=1
+ wlodku0=1                 kvsat=-0.0                steta0=0.0e-06
+ tku0=0                    lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
 
     14: type=n 
+ lmin=3e-007-dxln_na       lmax=5e-007-dxln_na       wmin=5e-07
+ wmax=1e-006-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=2.87292e-3             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=2.87292e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=3.259685e-09+ddlcn_na dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.16535631+dvthn_na  lvth0=-2.628512e-009+dlvthn_na
+ wvth0=-1.9657046e-008+dwvthn_na                     pvth0=6.8740488e-015+dpvthn_na
+ k1=0.070346               k2=0.034913098+dk2n_na    lk2=9.6494194e-011+dlk2n_na
+ wk2=9.6375337e-010+dwk2n_na                         pk2=-3.3369169e-017+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.00192384+dcitn_na   wcit=-1.2582144e-010+dwcitn_na
+ voff=-0.1326832           lvoff=5.7183631e-009      wvoff=2.5792456e-008
+ pvoff=-8.0086006e-015     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=1.0957293e-009
+ lua=4.6982662e-017        wua=6.538318e-017         pua=-3.114745e-023
+ ub=3e-018                 uc=1.4416741e-010         luc=6.3650524e-018
+ eu=1.67                   vsat=109000+dvsat_na      pvsat=0+dpvsat_na
+ wvsat=0+dwvsat_na         lvsat=0+dlvsat_na         a0=10.831095
+ la0=-2.112846e-006+dla0_na                          wa0=-3.8253664e-006
+ pa0=7.13275e-013          ags=4.3714821+dagsn_na    lags=-8.7441308e-007+dlagsn_na
+ wags=-4.8190867e-006+dwagsn_na                      pags=2.6517231e-012+dpagsn_na
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.096387523         lketa=6.5687341e-010
+ wketa=1.4503633e-009      pketa=-6.6738338e-016     dwg=0
+ dwb=0                     pclm=1.39064              wpclm=-2.097024e-008
+ pdiblc1=0                 pdiblc2=0.002968          wpdiblc2=1.048512e-009
+ pdiblcb=0.16              drout=0.5                 pvag=10
+ delta=0.01                pscbe1=2.2702e+008        pscbe2=2e-006
+ fprout=250                pdits=0.65                pditsd=0.7001
+ pditsl=0                  rsh=16.39                 rsw=40+drdswn_na
+ rdw=40+drdswn_na          prwg=0                    prwb=0
+ wr=1                      alpha0=1.0455e-7          alpha1=3.3148e-1
+ beta0=12.87               agidl=3.466e-007          bgidl=2.185e+009
+ cgidl=0.5                 aigbacc=0.0122            bigbacc=0.004014
+ cigbacc=0.1722            nigbacc=6.9984            aigbinv=0.04347
+ bigbinv=0.026295          cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.01107874           bigc=0.0021748
+ cigc=0.025272             aigsd=0.00875             bigsd=0.0001934
+ cigsd=0.0045111           nigc=3.9                  poxedge=1
+ pigcd=3.8556              ntox=ntoxn_na             xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na              cgdo=cgon_na
+ cgbo=0                    cgdl=cgln_na              cgsl=cgln_na
+ clc=1e-007                cle=0.6                   cf=cfn_na
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.07200             noff=3.247700             voffcv=-240.3800e-03
+ kt1=-0.29935224           lkt1=1.2473466e-008       wkt1=-1.178352e-008
+ pkt1=6.6738338e-017       kt1l=0                    kt2=-0.097234025
+ lkt2=4.3333277e-009       wkt2=1.980763e-008        pkt2=-4.337992e-015
+ ute=-2                    ua1=2.7841997e-009        lua1=3.9181353e-017
+ ub1=-5.7300889e-018       lub1=-6.4379959e-026      uc1=2.6620526e-010
+ luc1=-3.1809858e-017      prt=0                     at=251504.42
+ lat=-0.040571353          wat=-0.010785349          pat=2.9364869e-009
+ jss=2.25e-06              jsd=2.25e-06              jsws=2.22e-12
+ jswd=2.22e-12             jswgs=2.22e-12            jswgd=2.22e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19.0                  bvd=19.0                  xjbvs=1
+ xjbvd=1                   pbs=0.4                   pbd=0.4
+ cjs=cjn_na                cjd=cjn_na                mjs=0.31
+ mjd=0.31                  pbsws=0.4                 pbswd=0.4
+ cjsws=cjswn_na            cjswd=cjswn_na            mjsws=0.01
+ mjswd=0.01                pbswgs=1.16               pbswgd=1.16
+ cjswgs=cjswgn_na          cjswgd=cjswgn_na          mjswgs=0.98
+ mjswgd=0.98               tpb=2.2e-3                tcj=2.55e-3
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=5e-3
+ tcjswg=1.26e-2            xtis=3                    xtid=3
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163e-6           rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ kvth0=2.0e-9              lkvth0=3e-7               wkvth0=1e-7
+ pkvth0=0                  llodvth=1.00              wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ ku0=-4.86e-8              lku0=1.8e-7               wku0=6e-7
+ pku0=0                    llodku0=1                 wlodku0=1
+ kvsat=-0.0                steta0=0.0e-06            tku0=0
+ lcit=0+dlcitn_na          pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na
+ wnfactor=0+dwnfactorn_na  pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na
+ weta0=0+dweta0n_na        peta0=0+dpeta0n_na        lu0=0+dlu0n_na
+ wu0=0+dwu0n_na            pu0=0+dpu0n_na            fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_na             noib=noibn_na             noic=noicn_na
+ em=3e+5                   ef=0.9                      lintnoi=0
+ minr=1e-3
 
 
     15: type=n 
+ lmin=2e-07                lmax=3e-007-dxln_na       wmin=5e-07
+ wmax=1e-006-dxwn_na       version=4.5               tempmod=0
+ ud=0                      rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tnom=25                   toxe=toxn_na              toxm=2e-009
+ dtox=2.0684e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=4.72872e-3             wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=4.72872e-3
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_na
+ xw=1.6e-08+dxwn_na        dlc=2.8625e-10+ddlcn_na   dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.14618228+dvthn_na  lvth0=2.4923625e-009+dlvthn_na
+ wvth0=2.6876898e-009+dwvthn_na                      pvth0=9.0636195e-016+dpvthn_na
+ k1=0.070346               k2=0.035463114+dk2n_na    lk2=-5.0400482e-011+dlk2n_na
+ wk2=6.4707628e-010+dwk2n_na                         pk2=5.120689e-017+dpk2n_na
+ k3=-0.375                 k3b=-0.023928             w0=0
+ dvt0=0.07                 dvt1=0.05244              dvt2=0.35
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=-2.8623e-009
+ dvtp0=1e-007              dvtp1=0.203               lpe0=9e-007
+ lpeb=3e-008               xj=1.1e-007               ngate=3.6769e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0+dcdscdn_na
+ cit=0.00192384+dcitn_na   wcit=-1.2582144e-010+dwcitn_na
+ voff=-0.12296422          lvoff=3.122681e-009       wvoff=4.4339516e-009
+ pvoff=-2.3043101e-015     nfactor=0.5+dnfactorn_na  eta0=0.029+deta0n_na
+ etab=0.25                 u0=0.08+du0n_na           ua=-5.0355601e-010
+ lua=4.7410938e-016        wua=1.9645815e-017        pua=-1.8932211e-023
+ ub=6.0171549e-018         lub=-8.0580213e-025       wub=-2.9718665e-025
+ pub=7.937068e-032         uc=1.68e-010              eu=1.67
+ vsat=109000+dvsat_na      pvsat=0+dpvsat_na         wvsat=0+dwvsat_na
+ lvsat=0+dlvsat_na         a0=6.3563924              la0=-9.1777146e-007+dla0_na
+ wa0=-3.121199e-006        pa0=5.2521053e-013        ags=2.633742+dagsn_na
+ lags=-4.1030876e-007+dlagsn_na                      wags=1.3092186e-005+dwagsn_na
+ pags=-2.1319031e-012+dpagsn_na                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.084492305         lketa=-2.5200241e-009     wketa=-1.0635178e-008
+ pketa=2.5603445e-015      dwg=0                     dwb=0
+ pclm=1.39064              wpclm=-2.097024e-008      pdiblc1=0
+ pdiblc2=0.002968          wpdiblc2=1.048512e-009    pdiblcb=0.16
+ drout=0.5                 pvag=10                   delta=0.01
+ pscbe1=2.2702e+008        pscbe2=2e-006             fprout=250
+ pdits=0.65                pditsd=0.7001             pditsl=0
+ rsh=16.39                 rsw=40+drdswn_na          rdw=40+drdswn_na
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.0455e-7          alpha1=3.3148e-1          beta0=12.87
+ agidl=3.466e-007          bgidl=2.185e+009          cgidl=0.5
+ aigbacc=0.0122            bigbacc=0.004014          cigbacc=0.1722
+ nigbacc=6.9984            aigbinv=0.04347           bigbinv=0.026295
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.01107874           bigc=0.0021748            cigc=0.025272
+ aigsd=0.00875             bigsd=0.0001934           cigsd=0.0045111
+ nigc=3.9                  poxedge=1                 pigcd=3.8556
+ ntox=ntoxn_na             xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na              cgdo=cgon_na              cgbo=0
+ cgdl=cgln_na              cgsl=cgln_na              clc=1e-007
+ cle=0.6                   cf=cfn_na                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.07200
+ noff=3.247700             voffcv=-240.3800e-03      kt1=-0.23471067
+ lkt1=-4.7905854e-009      wkt1=-3.9047364e-008      pkt1=7.3481887e-015
+ kt1l=0                    kt2=-0.11055789           lkt2=7.8917779e-009
+ wkt2=1.909534e-008        pkt2=-4.1477581e-015      ute=-2
+ ua1=2.2648959e-009        lua1=1.7787366e-016       wua1=1.5051066e-015
+ pua1=-4.0197409e-022      ub1=-5.1785952e-018       lub1=-2.1166933e-025
+ wub1=-2.0707199e-024      pub1=5.5303441e-031       uc1=1.471e-010
+ prt=0                     at=181431.07              lat=-0.021856618
+ wat=-0.0089934972         pat=2.4579307e-009        jss=2.25e-06
+ jsd=2.25e-06              jsws=2.22e-12             jswd=2.22e-12
+ jswgs=2.22e-12            jswgd=2.22e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19.0
+ bvd=19.0                  xjbvs=1                   xjbvd=1
+ pbs=0.4                   pbd=0.4                   cjs=cjn_na
+ cjd=cjn_na                mjs=0.31                  mjd=0.31
+ pbsws=0.4                 pbswd=0.4                 cjsws=cjswn_na
+ cjswd=cjswn_na            mjsws=0.01                mjswd=0.01
+ pbswgs=1.16               pbswgd=1.16               cjswgs=cjswgn_na
+ cjswgd=cjswgn_na          mjswgs=0.98               mjswgd=0.98
+ tpb=2.2e-3                tcj=2.55e-3               tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=5e-3               tcjswg=1.26e-2
+ xtis=3                    xtid=3                    dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163e-6
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    kvth0=2.0e-9
+ lkvth0=3e-7               wkvth0=1e-7               pkvth0=0
+ llodvth=1.00              wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 ku0=-4.86e-8
+ lku0=1.8e-7               wku0=6e-7                 pku0=0
+ llodku0=1                 wlodku0=1                 kvsat=-0.0
+ steta0=0.0e-06            tku0=0                    lcit=0+dlcitn_na
+ pcit=0+dpcitn_na          lnfactor=0+dlnfactorn_na  wnfactor=0+dwnfactorn_na
+ pnfactor=0+dpnfactorn_na  leta0=0+dleta0n_na        weta0=0+dweta0n_na
+ peta0=0+dpeta0n_na        lu0=0+dlu0n_na            wu0=0+dwu0n_na
+ pu0=0+dpu0n_na            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_na
+ noib=noibn_na             noic=noicn_na             em=3e+5
+ ef=0.9                      lintnoi=0                 minr=1e-3
 
     } 
endsection mos_na
 
// **************************************************************
//                                                              *
//                      Native 2.5V IO DEVICE MODELS            *
//                                                              *
// **************************************************************

section mos_na25
 
// *********************************************************************************************
//                                                                            
//                   *
//                                2.5V NATIVE NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt nch_na25_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=1.135e-007 xw= + 
+ 7e-09 + dxwn_na25 ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg / 
+ factor * (w / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) 
+ ps=4 * dmcg / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf 
+ + xw / factor) nrs=dmcg / factor / (w / nf + xw / factor) sa=4.6e-7 / factor sb=4.6e-7 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parn1_na25 temp2=parn2_na25 fac1=0.010100 * temp1 * sigma 
+ + 0.999949 * temp2 * sigma fac2=0.010100 * temp1 * sigma - 0.999949 * temp2 * 
+ sigma lef=l * factor - 3.859e-8 wef=w / nf * factor + 7e-09 geo_fac=1 / sqrt(multi 
+ * nf * lef * wef * 1e12) vthmisn_na25=0.00190412 * geo_fac * fac1 * mismatchflag 
+ dlmisn_na25=0.00191205 * geo_fac * lef * fac2 * mismatchflag dwmisn_na25= - 0.00191205 
+ * geo_fac * wef * fac2 * mismatchflag toxmisn_na25=0.00191205 * geo_fac * toxn_na25 
+ * fac2 * mismatchflag tnoiax=1.903e04 / (l * 1e6) + 8.634e6 rnoiax= - 0.1171 / 
+ (l * 1e6) + 0.6655 
nch_na25_mac ( n1 n2 n3 n4 ) nch_na25 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
 
model nch_na25 bsim4  { 
     1: type=n 
+ lmin=9.99999e-006-(dxln_na25+dlmisn_na25)           lmax=900.00001e-06
+ wmin=1e-005-(dxwn_na25+dwmisn_na25)                 wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=-0.00094810982         k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000703125+dcitn_na25
+ voff=-0.12480063          nfactor=0.8+dnfactorn_na25
+ eta0=0.021196+deta0n_na25 etab=0.0010882964         u0=0.062834873+du0n_na25
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-4.7661329e-011
+ vsat=78400+dvsatn_na25    a0=3.5135779              ags=1.0683639
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.055602815         dwg=0
+ dwb=0                     pclm=0.01                 pdiblc1=0
+ pdiblc2=0.0001485         pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25871994
+ kt1l=0                    kt2=-0.018492824          ute=-1.48
+ ua1=1.67e-009             ub1=-3e-018               uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       lu0=0+dlu0n_na25          wu0=0+dwu0n_na25
+ pu0=0+dpu0n_na25          lcit=0+dlcitn_na25        wcit=0+dwcitn_na25
+ pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      weta0=0+dweta0n_na25      peta0=0+dpeta0n_na25
+ lvsat=0+dlvsatn_na25      wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25
+ fnoimod=1                 noia=noian_na25           rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na25           rnoib=0
+ noic=noicn_na25           em=1.1200e+08             ef=1.00
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.99999e-006-(dxln_na25+dlmisn_na25)           lmax=9.99999e-006-(dxln_na25+dlmisn_na25)
+ wmin=1e-005-(dxwn_na25+dwmisn_na25)                 wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=-4.5976888e-005        lk2=-8.986516e-009
+ k3=2.6118349              k3b=-4.9758566            w0=0
+ dvt0=0.064799587          dvt1=0.02075738           dvt2=0.30031818
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.03344              minv=-0.5                 voffl=0
+ dvtp0=8.4008771e-009      dvtp1=3.5                 lpe0=2.8116619e-009
+ lpeb=1.51e-010            xj=1.1e-007               ngate=5.9092e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00087551455+dcitn_na25                        lcit=-1.717243e-009+dlcitn_na25
+ voff=-0.12541317          lvoff=6.1017084e-009      nfactor=0.8+dnfactorn_na25
+ eta0=0.021196+deta0n_na25 etab=0.0010882964         u0=0.062126092+du0n_na25
+ lu0=7.0604626e-009+dlu0n_na25                       ua=1.0246402e-009
+ lua=1.9809716e-015        ub=2.7182203e-018         lub=-2.1739356e-024
+ uc=-1.5214257e-011        luc=-3.2321858e-016       vsat=78400+dvsatn_na25
+ a0=4.1247439              la0=-6.0880748e-006       ags=0.58809352
+ lags=4.7841698e-006       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.049079469
+ lketa=-6.4981729e-008     dwg=0                     dwb=0
+ pclm=-0.026664974         lpclm=3.6523484e-007      pdiblc1=0
+ pdiblc2=0.00015511976     lpdiblc2=-6.5942131e-011  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25            cgdo=cgon_na25
+ cgbo=0                    cgdl=cgln_na25            cgsl=cgln_na25
+ clc=1e-007                cle=0.6                   cf=cfn_na25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.25050115           lkt1=-8.1870746e-008      kt1l=0
+ kt2=-0.015762253          lkt2=-2.7200338e-008      ute=-1.48
+ ua1=1.67e-009             ub1=-3.0882242e-018       lub1=8.7883765e-025
+ uc1=-1.5421529e-010       luc1=6.9476141e-016       prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       wu0=0+dwu0n_na25          pu0=0+dpu0n_na25
+ wcit=0+dwcitn_na25        pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      weta0=0+dweta0n_na25      peta0=0+dpeta0n_na25
+ lvsat=0+dlvsatn_na25      wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25
+ fnoimod=1                 noia=noian_na25           rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na25           rnoib=0
+ noic=noicn_na25           em=1.1200e+08             ef=1.00
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na25+dlmisn_na25)
+ wmin=1e-005-(dxwn_na25+dwmisn_na25)                 wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=-0.00065388215         lk2=-7.7941645e-009
+ k3=2.6118349              k3b=-4.9758566            w0=0
+ dvt0=0.064799587          dvt1=0.02075738           dvt2=0.30031818
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.03344              minv=-0.5                 voffl=0
+ dvtp0=8.4008771e-009      dvtp1=3.5                 lpe0=2.8116619e-009
+ lpeb=1.51e-010            xj=1.1e-007               ngate=5.9092e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0+dcitn_na25          voff=-0.13332084          lvoff=2.1611887e-008
+ nfactor=0.8+dnfactorn_na25                          eta0=0.021196+deta0n_na25
+ etab=-0.0015372917        letab=5.1498547e-009      u0=0.062294657+du0n_na25
+ lu0=6.729838e-009+dlu0n_na25                        ua=1.2107717e-009
+ lua=1.6158914e-015        ub=2.478809e-018+1.1614245e-18
+ pub=0+0                   wub=0-0                   lub=-1.7043519e-024-2.278018e-24
+ uc=-1.654901e-010         luc=-2.8466042e-017       vsat=78400+dvsatn_na25
+ a0=2.1609292              la0=-2.2362292e-006       ags=-8.613579+3.6294516
+ pags=0+0                  wags=0-0                  lags=2.2832422e-005-7.1188064e-06
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080253643-0.029035613
+ pketa=0+0                 wketa=0-0                 lketa=-3.8364353e-09+5.6950451e-08
+ dwg=0                     dwb=0                     pclm=0.33322887
+ lpclm=-3.4066454e-007     pdiblc1=0                 pdiblc2=0.0001458025
+ lpdiblc2=-4.7667175e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=4.3901206e-011        luc1=3.0617374e-016       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       wu0=0+dwu0n_na25          pu0=0+dpu0n_na25
+ lcit=0+dlcitn_na25        wcit=0+dwcitn_na25        pcit=0+dpcitn_na25
+ lnfactor=0+dlnfactorn_na25                          wnfactor=0+dwnfactorn_na25
+ pnfactor=0+dpnfactorn_na25                          leta0=0+dleta0n_na25
+ weta0=0+dweta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25           rnoib=0                   noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     4: type=n 
+ lmin=9.99999e-006-(dxln_na25+dlmisn_na25)           lmax=900.00001e-06
+ wmin=1.2e-006-(dxwn_na25+dwmisn_na25)               wmax=1e-005-(dxwn_na25+dwmisn_na25)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=-0.00082308439         wk2=-1.2511295e-009
+ k3=2.6118349              k3b=-4.9758566            w0=0
+ dvt0=0.064799587          dvt1=0.02075738           dvt2=0.30031818
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.03344              minv=-0.5                 voffl=0
+ dvtp0=8.4008771e-009      dvtp1=3.5                 lpe0=2.8116619e-009
+ lpeb=1.51e-010            xj=1.1e-007               ngate=5.9092e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00079956499+dcitn_na25                        wcit=-9.6507494e-010+dwcitn_na25
+ voff=-0.12477695          wvoff=-2.3700525e-010     nfactor=0.8+dnfactorn_na25
+ eta0=0.021777966+deta0n_na25                        weta0=-5.823734e-009+dweta0n_na25
+ etab=0.0010882964         u0=0.062945581+du0n_na25  wu0=-1.1078502e-009+dwu0n_na25
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-5.7780526e-011
+ wuc=1.0126281e-016        vsat=78400+dvsatn_na25    a0=3.7916851
+ wa0=-2.783019e-006        ags=1.0095994             wags=5.8805572e-007
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.059213254         wketa=3.6129664e-008
+ dwg=0                     dwb=0                     pclm=-0.0085221351
+ wpclm=1.8535101e-007      pdiblc1=0                 pdiblc2=0.00015035165
+ wpdiblc2=-1.8529439e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25871994
+ kt1l=0                    kt2=-0.018492824          ute=-1.48
+ ua1=1.67e-009             ub1=-2.9809198e-018       wub1=-1.9093557e-025
+ uc1=-8.447e-011           prt=0                     at=164723.91
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na25              cjd=cjn_na25              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na25          cjswd=cjswn_na25          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na25        cjswgd=cjswgn_na25        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=0+dlvthn_na25
+ wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25       lu0=0+dlu0n_na25
+ pu0=0+dpu0n_na25          lcit=0+dlcitn_na25        pcit=0+dpcitn_na25
+ lnfactor=0+dlnfactorn_na25                          wnfactor=0+dwnfactorn_na25
+ pnfactor=0+dpnfactorn_na25                          leta0=0+dleta0n_na25
+ peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25      wvsat=0+dwvsatn_na25
+ pvsat=0+dpvsatn_na25      fnoimod=1                 noia=noian_na25
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na25
+ rnoib=0                   noic=noicn_na25           em=1.1200e+08
+ ef=1.00                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     5: type=n 
+ lmin=1.99999e-006-(dxln_na25+dlmisn_na25)           lmax=9.99999e-006-(dxln_na25+dlmisn_na25)
+ wmin=1.2e-006-(dxwn_na25+dwmisn_na25)               wmax=1e-005-(dxwn_na25+dwmisn_na25)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=0.00014232922          lk2=-9.6168808e-009
+ wk2=-1.8843792e-009       pk2=6.3080606e-015        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00099559933+dcitn_na25
+ lcit=-1.9527785e-009+dlcitn_na25                    wcit=-1.2016884e-009+dwcitn_na25
+ pcit=2.3570036e-015+dpcitn_na25                     voff=-0.12535694
+ lvoff=5.777557e-009       wvoff=-5.6264021e-010     pvoff=3.2437834e-015
+ nfactor=0.8+dnfactorn_na25                          eta0=0.021777966+deta0n_na25
+ weta0=-5.823734e-009+dweta0n_na25                   etab=0.0010882964
+ u0=0.062119625+du0n_na25  lu0=8.2276866e-009+dlu0n_na25
+ wu0=6.471586e-011+dwu0n_na25                        pu0=-1.1680411e-014+dpu0n_na25
+ ua=1.0066817e-009         lua=2.1598628e-015        wua=1.7970992e-016
+ pua=-1.7901642e-021       ub=2.7288894e-018         lub=-2.2802153e-024
+ wub=-1.0676613e-025       pub=1.0635412e-030        uc=-2.2362049e-011
+ luc=-3.5281798e-016       wuc=7.1527948e-017        puc=2.9620114e-022
+ vsat=78400+dvsatn_na25    a0=4.4672822              la0=-6.7298994e-006
+ wa0=-3.427781e-006        pa0=6.4227384e-012        ags=0.49648423
+ lags=5.1113508e-006       wags=9.1673415e-007       pags=-3.2741006e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.05319211+0.0003362798
+ lketa=-5.9979091e-008-3.3498176e-09                 wketa=4.1155197e-008-3.365152e-09
+ pketa=-5.0061403e-014+3.3521625e-14                 dwg=0
+ dwb=0                     pclm=-0.050216044         lpclm=4.1533012e-007
+ wpclm=2.3567555e-007      ppclm=-5.0130345e-013     pdiblc1=0
+ pdiblc2=0.00015787937     lpdiblc2=-7.4986694e-011  wpdiblc2=-2.7615395e-011
+ ppdiblc2=9.0508939e-017   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.064466e-018        lub1=8.3223805e-025       wub1=-2.3774844e-025
+ pub1=4.6632217e-031       uc1=-1.6378149e-010       luc1=7.9005425e-016
+ wuc1=9.5728966e-017       puc1=-9.5359548e-022      prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25           rnoib=0                   noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na25+dlmisn_na25)
+ wmin=1.2e-006-(dxwn_na25+dwmisn_na25)               wmax=1e-005-(dxwn_na25+dwmisn_na25)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=-0.0002474582          lk2=-8.8523478e-009
+ wk2=-4.0670845e-009       pk2=1.0589241e-014        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25
+ voff=-0.13409419          lvoff=2.2914876e-008      wvoff=7.7389381e-009
+ pvoff=-1.3039015e-014     nfactor=0.8+dnfactorn_na25
+ eta0=0.021777966+deta0n_na25                        weta0=-5.823734e-009+dweta0n_na25
+ etab=-0.0014451533        letab=4.9691335e-009      wetab=-9.2202907e-010
+ petab=1.808477e-015       u0=0.062618082+du0n_na25+0.00099562457
+ lu0=7.2500067e-009+dlu0n_na25-1.952818e-09          wu0=-3.2365228e-009+dwu0n_na25-9.9632151e-09
+ pu0=-5.2053284e-015+dpu0n_na25+1.954185e-14         ua=1.2361917e-009
+ lua=1.7096996e-015        wua=-2.5437827e-016       pua=-9.3873932e-022
+ ub=2.4638385e-018+1.3207244e-18-1.9912491e-20       lub=-1.7603418e-024-2.5904689e-24+3.9056361e-26
+ wub=1.4980948e-025-1.5941144e-24+1.992643e-25       pub=5.6029122e-031+3.126696e-30-3.90837e-31
+ uc=-1.9983058e-010        luc=-4.7294195e-018       wuc=3.4364521e-016
+ puc=-2.3753239e-022       vsat=78400+dvsatn_na25    a0=2.2652791-0.039824983
+ la0=-2.4108685e-006+7.8112721e-08                   wa0=-1.0442288e-006+3.985286e-07
+ pa0=1.7476153e-012-7.81674e-13                      ags=-9.9452213+4.1272639
+ lags=2.5591817e-005-8.0952154e-06                   wags=1.3325745e-005-4.9816075e-06
+ pags=-2.7613259e-011+9.770925e-12                   a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.083185601-0.033018111-0.00336284+0.0019912491
+ lketa=-1.1496065e-09+6.4761723e-08+3.9056361e-09-3.9056361e-09
+ wketa=2.9340101e-08+3.985286e-08+3.365194e-08-1.992643e-08
+ pketa=-2.6887095e-14-7.81674e-14-3.90837e-14+3.90837e-14
+ dwg=0                     dwb=0                     pclm=0.33215077
+ lpclm=-3.3464797e-007     wpclm=1.0788531e-008      ppclm=-6.0207799e-014
+ pdiblc1=0                 pdiblc2=0.00012335961     lpdiblc2=-7.2792913e-012
+ wpdiblc2=2.2458608e-010   ppdiblc2=-4.0416155e-016  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25            cgdo=cgon_na25
+ cgbo=0                    cgdl=cgln_na25            cgsl=cgln_na25
+ clc=1e-007                cle=0.6                   cf=cfn_na25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.2672704            lkt1=-4.897936e-008       kt1l=0
+ kt2=-0.02963              ute=-1.48                 ua1=1.67e-009
+ ub1=-2.64016e-018         uc1=6.1508484e-011        luc1=3.4816825e-016
+ wuc1=-1.7619603e-016      puc1=-4.2023907e-022      prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       lcit=0+dlcitn_na25        wcit=0+dwcitn_na25
+ pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25           rnoib=0                   noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     7: type=n 
+ lmin=9.99999e-006-(dxln_na25+dlmisn_na25)           lmax=900.00001e-06
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na25+dwmisn_na25)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=0.012003617            wk2=-1.6732958e-008
+ k3=2.6118349              k3b=-4.9758566            w0=0
+ dvt0=0.064799587          dvt1=0.02075738           dvt2=0.30031818
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.03344              minv=-0.5                 voffl=0
+ dvtp0=8.4008771e-009      dvtp1=3.5                 lpe0=2.8116619e-009
+ lpeb=1.51e-010            xj=1.1e-007               ngate=5.9092e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0+dcitn_na25          voff=-0.12783168          wvoff=3.4500609e-009
+ nfactor=0.8+dnfactorn_na25                          eta0=0.028641812+deta0n_na25
+ weta0=-1.4108396e-008+dweta0n_na25                  etab=0.0010882964
+ u0=0.06106174+du0n_na25   wu0=1.1659461e-009+dwu0n_na25
+ ua=1.2854346e-009         wua=-7.4749352e-017       ub=2.4999846e-018
+ uc=2.6115752e-011         vsat=78400+dvsatn_na25    a0=1.4808087+0.14485714
+ pa0=0+0                   la0=0-0                   wa0=6.2088783e-009-1.7484257e-07
+ ags=1.6647716             wags=-2.027371e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.029279813         dwg=0                     dwb=0
+ pclm=0.14504125           pdiblc1=0                 pdiblc2=0.000135
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25
+ cgdo=cgon_na25            cgbo=0                    cgdl=cgln_na25
+ cgsl=cgln_na25            clc=1e-007                cle=0.6
+ cf=cfn_na25               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3.13911e-018         uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25              cjd=cjn_na25
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25          cjswd=cjswn_na25
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25        cjswgd=cjswgn_na25
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25
+ lu0=0+dlu0n_na25          pu0=0+dpu0n_na25          lcit=0+dlcitn_na25
+ wcit=0+dwcitn_na25        pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25           rnoib=0                   noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     8: type=n 
+ lmin=1.99999e-006-(dxln_na25+dlmisn_na25)           lmax=9.99999e-006-(dxln_na25+dlmisn_na25)
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na25+dwmisn_na25)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=0.012933166            lk2=-9.2596208e-009
+ wk2=-1.7322919e-008       pk2=5.8768479e-015        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25
+ voff=-0.12905814          lvoff=1.221718e-008       wvoff=3.9046996e-009
+ pvoff=-4.528842e-015      nfactor=0.8+dnfactorn_na25
+ eta0=0.028641812+deta0n_na25                        weta0=-1.4108396e-008+dweta0n_na25
+ etab=0.0010882964         u0=0.062004206+du0n_na25  lu0=-9.3882913e-009+dlu0n_na25
+ wu0=2.040266e-010+dwu0n_na25                        pu0=9.5820743e-015+dpu0n_na25
+ ua=1.2896963e-009         lua=-4.2452701e-017       wua=-1.6188868e-016
+ pua=8.6803058e-022        ub=2.594245e-018          lub=-9.389669e-025
+ wub=5.5749704e-026        pub=-5.5534566e-031       uc=3.2781608e-011
+ luc=-6.6401324e-017       wuc=4.9695541e-018        puc=-4.9503766e-023
+ vsat=78400+dvsatn_na25    a0=1.5569963+0.18037249   la0=-7.5893653e-007-3.5378261e-07
+ wa0=8.4934061e-008-2.177096e-07                     pa0=-7.8421382e-013+4.2701561e-13
+ ags=1.5962099             lags=6.8297174e-007       wags=-4.1063467e-007
+ pags=2.0709529e-012       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.01641015-0.0042275175
+ lketa=-1.2819999e-007+4.2111993e-08                 wketa=-3.2406274e-009+2.1433514e-09
+ pketa=3.2281218e-014-2.135078e-14                   dwg=0
+ dwb=0                     pclm=0.14504125           pdiblc1=0
+ pdiblc2=0.000135          pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.2614407e-018       lub1=1.2185862e-024       uc1=-8.447e-011
+ prt=0                     at=183960.37              lat=-0.19162228
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na25              cjd=cjn_na25              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na25          cjswd=cjswn_na25          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na25        cjswgd=cjswgn_na25        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=0+dlvthn_na25
+ wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25       lcit=0+dlcitn_na25
+ wcit=0+dwcitn_na25        pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25           rnoib=0                   noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na25+dlmisn_na25)
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na25+dwmisn_na25)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na25+toxmisn_na25)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na25+dlmisn_na25)
+ xw=7e-09+(dxwn_na25+dwmisn_na25)                    dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25+vthmisn_na25)
+ k1=0.083826               k2=0.0070517436           lk2=2.2762599e-009
+ wk2=-1.2877221e-008       pk2=-2.842989e-015        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25
+ voff=-0.12106439          lvoff=-3.4618388e-009     wvoff=-7.9880317e-009
+ pvoff=1.879768e-014       nfactor=0.8+dnfactorn_na25
+ eta0=0.028641812+deta0n_na25                        leta0=-2.0005323e-016+dleta0n_na25
+ weta0=-1.4108396e-008+dweta0n_na25                  peta0=2.4146429e-022+dpeta0n_na25
+ etab=-0.0045972791        letab=1.1151745e-008      wetab=2.8825868e-009
+ petab=-5.6539345e-015     u0=0.061722716+du0n_na25-0.012516423+0.00052575199
+ lu0=-8.8361755e-009+dlu0n_na25+2.4549712e-08-1.03121e-09
+ wu0=-2.1558162e-009+dwu0n_na25+6.3458265e-09-6.3458265e-10
+ pu0=1.4210694e-014+dpu0n_na25-1.2446704e-14+1.2446704e-15
+ ua=1.6235236e-009         lua=-6.9722491e-016       wua=-7.2188788e-016
+ pua=1.9664186e-021        ub=1.8314711e-018+2.5032846e-19-5.2575199e-19
+ lub=5.5714547e-025-4.9099425e-25+1.03121e-24        wub=9.1307699e-025-1.2691653e-25+6.3458265e-25
+ pub=-2.236916e-030+2.4893408e-31-1.2446704e-30      uc=1.6131981e-010
+ luc=-3.1851744e-016       wuc=-9.2263315e-017       puc=1.4120976e-022
+ vsat=78400+dvsatn_na25-2103.008                     a0=1.8138372+0.50065693-0.1051504
+ la0=-1.2627068e-006-9.8198849e-07+2.0624199e-07     wa0=-4.9933847e-007-2.5383306e-07+1.2691653e-07
+ pa0=3.6178416e-013+4.9786817e-13-2.4893408e-13      ags=1.253264
+ lags=1.3556292e-006       wags=-1.9082677e-007      pags=1.6398195e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080802003+0.042275703-0.025032846
+ lketa=-1.9011631e-009-4.9099425e-08+4.9099425e-08   wketa=2.6463098e-008-2.1433782e-08+1.2691653e-08
+ pketa=-2.5979966e-014+2.4893408e-14-2.4893408e-14   dwg=0
+ dwb=0                     pclm=0.53198689           lpclm=-7.5895904e-007
+ wpclm=-2.3041366e-007     ppclm=4.5193566e-013      pdiblc1=0
+ pdiblc2=0.00030623536     lpdiblc2=-3.3586275e-010  wpdiblc2=3.8550414e-012
+ ppdiblc2=-7.5613168e-018  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=-8.447e-011           prt=0                     at=128258.51
+ lat=-0.082368082          jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25              cjd=cjn_na25
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25          cjswd=cjswn_na25
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25        cjswgd=cjswgn_na25
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25
+ lcit=0+dlcitn_na25        wcit=0+dwcitn_na25        pcit=0+dpcitn_na25
+ lnfactor=0+dlnfactorn_na25                          wnfactor=0+dwnfactorn_na25
+ pnfactor=0+dpnfactorn_na25                          lvsat=0+dlvsatn_na25+0.0041248398
+ wvsat=0+dwvsatn_na25+0.0025383306                   pvsat=0+dpvsatn_na25-4.9786817e-09
+ fnoimod=1                 noia=noian_na25           rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na25           rnoib=0
+ noic=noicn_na25           em=1.1200e+08             ef=1.00
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
     } 
ends nch_na25_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                2.5V NATIVE NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch_na25 bsim4  { 
     1: type=n 
+ lmin=9.99999e-006-dxln_na25                         lmax=900.00001e-06
+ wmin=1e-005-dxwn_na25     wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=-0.00094810982         k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.000703125+dcitn_na25
+ voff=-0.12480063          nfactor=0.8+dnfactorn_na25
+ eta0=0.021196+deta0n_na25 etab=0.0010882964         u0=0.062834873+du0n_na25
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-4.7661329e-011
+ vsat=78400+dvsatn_na25    a0=3.5135779              ags=1.0683639
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.055602815         dwg=0
+ dwb=0                     pclm=0.01                 pdiblc1=0
+ pdiblc2=0.0001485         pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25871994
+ kt1l=0                    kt2=-0.018492824          ute=-1.48
+ ua1=1.67e-009             ub1=-3e-018               uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       lu0=0+dlu0n_na25          wu0=0+dwu0n_na25
+ pu0=0+dpu0n_na25          lcit=0+dlcitn_na25        wcit=0+dwcitn_na25
+ pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      weta0=0+dweta0n_na25      peta0=0+dpeta0n_na25
+ lvsat=0+dlvsatn_na25      wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25
+ fnoimod=1                 noia=noian_na25           noib=noibn_na25
+ noic=noicn_na25           em=1.1200e+08             ef=1.00
+ tnoimod=0                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.99999e-006-dxln_na25                         lmax=9.99999e-006-dxln_na25
+ wmin=1e-005-dxwn_na25     wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=-4.5976888e-005        lk2=-8.986516e-009        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00087551455+dcitn_na25
+ lcit=-1.717243e-009+dlcitn_na25                     voff=-0.12541317
+ lvoff=6.1017084e-009      nfactor=0.8+dnfactorn_na25
+ eta0=0.021196+deta0n_na25 etab=0.0010882964         u0=0.062126092+du0n_na25
+ lu0=7.0604626e-009+dlu0n_na25                       ua=1.0246402e-009
+ lua=1.9809716e-015        ub=2.7182203e-018         lub=-2.1739356e-024
+ uc=-1.5214257e-011        luc=-3.2321858e-016       vsat=78400+dvsatn_na25
+ a0=4.1247439              la0=-6.0880748e-006       ags=0.58809352
+ lags=4.7841698e-006       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.049079469
+ lketa=-6.4981729e-008     dwg=0                     dwb=0
+ pclm=-0.026664974         lpclm=3.6523484e-007      pdiblc1=0
+ pdiblc2=0.00015511976     lpdiblc2=-6.5942131e-011  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25            cgdo=cgon_na25
+ cgbo=0                    cgdl=cgln_na25            cgsl=cgln_na25
+ clc=1e-007                cle=0.6                   cf=cfn_na25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.25050115           lkt1=-8.1870746e-008      kt1l=0
+ kt2=-0.015762253          lkt2=-2.7200338e-008      ute=-1.48
+ ua1=1.67e-009             ub1=-3.0882242e-018       lub1=8.7883765e-025
+ uc1=-1.5421529e-010       luc1=6.9476141e-016       prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       wu0=0+dwu0n_na25          pu0=0+dpu0n_na25
+ wcit=0+dwcitn_na25        pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      weta0=0+dweta0n_na25      peta0=0+dpeta0n_na25
+ lvsat=0+dlvsatn_na25      wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25
+ fnoimod=1                 noia=noian_na25           noib=noibn_na25
+ noic=noicn_na25           em=1.1200e+08             ef=1.00
+ tnoimod=0                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na25
+ wmin=1e-005-dxwn_na25     wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=-0.00065388215         lk2=-7.7941645e-009       k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25
+ voff=-0.13332084          lvoff=2.1611887e-008      nfactor=0.8+dnfactorn_na25
+ eta0=0.021196+deta0n_na25 etab=-0.0015372917        letab=5.1498547e-009
+ u0=0.062294657+du0n_na25  lu0=6.729838e-009+dlu0n_na25
+ ua=1.2107717e-009         lua=1.6158914e-015        ub=2.478809e-018+1.1614245e-18
+ pub=0+0                   wub=0-0                   lub=-1.7043519e-024-2.278018e-24
+ uc=-1.654901e-010         luc=-2.8466042e-017       vsat=78400+dvsatn_na25
+ a0=2.1609292              la0=-2.2362292e-006       ags=-8.613579+3.6294516
+ pags=0+0                  wags=0-0                  lags=2.2832422e-005-7.1188064e-06
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080253643-0.029035613
+ pketa=0+0                 wketa=0-0                 lketa=-3.8364353e-09+5.6950451e-08
+ dwg=0                     dwb=0                     pclm=0.33322887
+ lpclm=-3.4066454e-007     pdiblc1=0                 pdiblc2=0.0001458025
+ lpdiblc2=-4.7667175e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=4.3901206e-011        luc1=3.0617374e-016       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       wu0=0+dwu0n_na25          pu0=0+dpu0n_na25
+ lcit=0+dlcitn_na25        wcit=0+dwcitn_na25        pcit=0+dpcitn_na25
+ lnfactor=0+dlnfactorn_na25                          wnfactor=0+dwnfactorn_na25
+ pnfactor=0+dpnfactorn_na25                          leta0=0+dleta0n_na25
+ weta0=0+dweta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           noib=noibn_na25           noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     4: type=n 
+ lmin=9.99999e-006-dxln_na25                         lmax=900.00001e-06
+ wmin=1.2e-006-dxwn_na25   wmax=1e-005-dxwn_na25     version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=-0.00082308439         wk2=-1.2511295e-009       k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00079956499+dcitn_na25
+ wcit=-9.6507494e-010+dwcitn_na25                    voff=-0.12477695
+ wvoff=-2.3700525e-010     nfactor=0.8+dnfactorn_na25
+ eta0=0.021777966+deta0n_na25                        weta0=-5.823734e-009+dweta0n_na25
+ etab=0.0010882964         u0=0.062945581+du0n_na25  wu0=-1.1078502e-009+dwu0n_na25
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-5.7780526e-011
+ wuc=1.0126281e-016        vsat=78400+dvsatn_na25    a0=3.7916851
+ wa0=-2.783019e-006        ags=1.0095994             wags=5.8805572e-007
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.059213254         wketa=3.6129664e-008
+ dwg=0                     dwb=0                     pclm=-0.0085221351
+ wpclm=1.8535101e-007      pdiblc1=0                 pdiblc2=0.00015035165
+ wpdiblc2=-1.8529439e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25871994
+ kt1l=0                    kt2=-0.018492824          ute=-1.48
+ ua1=1.67e-009             ub1=-2.9809198e-018       wub1=-1.9093557e-025
+ uc1=-8.447e-011           prt=0                     at=164723.91
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na25              cjd=cjn_na25              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na25          cjswd=cjswn_na25          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na25        cjswgd=cjswgn_na25        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=0+dlvthn_na25
+ wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25       lu0=0+dlu0n_na25
+ pu0=0+dpu0n_na25          lcit=0+dlcitn_na25        pcit=0+dpcitn_na25
+ lnfactor=0+dlnfactorn_na25                          wnfactor=0+dwnfactorn_na25
+ pnfactor=0+dpnfactorn_na25                          leta0=0+dleta0n_na25
+ peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25      wvsat=0+dwvsatn_na25
+ pvsat=0+dpvsatn_na25      fnoimod=1                 noia=noian_na25
+ noib=noibn_na25           noic=noicn_na25           em=1.1200e+08
+ ef=1.00                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     5: type=n 
+ lmin=1.99999e-006-dxln_na25                         lmax=9.99999e-006-dxln_na25
+ wmin=1.2e-006-dxwn_na25   wmax=1e-005-dxwn_na25     version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=0.00014232922          lk2=-9.6168808e-009       wk2=-1.8843792e-009
+ pk2=6.3080606e-015        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00099559933+dcitn_na25
+ lcit=-1.9527785e-009+dlcitn_na25                    wcit=-1.2016884e-009+dwcitn_na25
+ pcit=2.3570036e-015+dpcitn_na25                     voff=-0.12535694
+ lvoff=5.777557e-009       wvoff=-5.6264021e-010     pvoff=3.2437834e-015
+ nfactor=0.8+dnfactorn_na25                          eta0=0.021777966+deta0n_na25
+ weta0=-5.823734e-009+dweta0n_na25                   etab=0.0010882964
+ u0=0.062119625+du0n_na25  lu0=8.2276866e-009+dlu0n_na25
+ wu0=6.471586e-011+dwu0n_na25                        pu0=-1.1680411e-014+dpu0n_na25
+ ua=1.0066817e-009         lua=2.1598628e-015        wua=1.7970992e-016
+ pua=-1.7901642e-021       ub=2.7288894e-018         lub=-2.2802153e-024
+ wub=-1.0676613e-025       pub=1.0635412e-030        uc=-2.2362049e-011
+ luc=-3.5281798e-016       wuc=7.1527948e-017        puc=2.9620114e-022
+ vsat=78400+dvsatn_na25    a0=4.4672822              la0=-6.7298994e-006
+ wa0=-3.427781e-006        pa0=6.4227384e-012        ags=0.49648423
+ lags=5.1113508e-006       wags=9.1673415e-007       pags=-3.2741006e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.05319211+0.0003362798
+ lketa=-5.9979091e-008-3.3498176e-09                 wketa=4.1155197e-008-3.365152e-09
+ pketa=-5.0061403e-014+3.3521625e-14                 dwg=0
+ dwb=0                     pclm=-0.050216044         lpclm=4.1533012e-007
+ wpclm=2.3567555e-007      ppclm=-5.0130345e-013     pdiblc1=0
+ pdiblc2=0.00015787937     lpdiblc2=-7.4986694e-011  wpdiblc2=-2.7615395e-011
+ ppdiblc2=9.0508939e-017   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.064466e-018        lub1=8.3223805e-025       wub1=-2.3774844e-025
+ pub1=4.6632217e-031       uc1=-1.6378149e-010       luc1=7.9005425e-016
+ wuc1=9.5728966e-017       puc1=-9.5359548e-022      prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           noib=noibn_na25           noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na25
+ wmin=1.2e-006-dxwn_na25   wmax=1e-005-dxwn_na25     version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=-0.0002474582          lk2=-8.8523478e-009       wk2=-4.0670845e-009
+ pk2=1.0589241e-014        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0+dcitn_na25          voff=-0.13409419
+ lvoff=2.2914876e-008      wvoff=7.7389381e-009      pvoff=-1.3039015e-014
+ nfactor=0.8+dnfactorn_na25                          eta0=0.021777966+deta0n_na25
+ weta0=-5.823734e-009+dweta0n_na25                   etab=-0.0014451533
+ letab=4.9691335e-009      wetab=-9.2202907e-010     petab=1.808477e-015
+ u0=0.062618082+du0n_na25+0.00099562457              lu0=7.2500067e-009+dlu0n_na25-1.952818e-09
+ wu0=-3.2365228e-009+dwu0n_na25-9.9632151e-09        pu0=-5.2053284e-015+dpu0n_na25+1.954185e-14
+ ua=1.2361917e-009         lua=1.7096996e-015        wua=-2.5437827e-016
+ pua=-9.3873932e-022       ub=2.4638385e-018+1.3207244e-18-1.9912491e-20
+ lub=-1.7603418e-024-2.5904689e-24+3.9056361e-26     wub=1.4980948e-025-1.5941144e-24+1.992643e-25
+ pub=5.6029122e-031+3.126696e-30-3.90837e-31         uc=-1.9983058e-010
+ luc=-4.7294195e-018       wuc=3.4364521e-016        puc=-2.3753239e-022
+ vsat=78400+dvsatn_na25    a0=2.2652791-0.039824983  la0=-2.4108685e-006+7.8112721e-08
+ wa0=-1.0442288e-006+3.985286e-07                    pa0=1.7476153e-012-7.81674e-13
+ ags=-9.9452213+4.1272639  lags=2.5591817e-005-8.0952154e-06
+ wags=1.3325745e-005-4.9816075e-06                   pags=-2.7613259e-011+9.770925e-12
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.083185601-0.033018111-0.00336284+0.0019912491
+ lketa=-1.1496065e-09+6.4761723e-08+3.9056361e-09-3.9056361e-09
+ wketa=2.9340101e-08+3.985286e-08+3.365194e-08-1.992643e-08
+ pketa=-2.6887095e-14-7.81674e-14-3.90837e-14+3.90837e-14
+ dwg=0                     dwb=0                     pclm=0.33215077
+ lpclm=-3.3464797e-007     wpclm=1.0788531e-008      ppclm=-6.0207799e-014
+ pdiblc1=0                 pdiblc2=0.00012335961     lpdiblc2=-7.2792913e-012
+ wpdiblc2=2.2458608e-010   ppdiblc2=-4.0416155e-016  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25            cgdo=cgon_na25
+ cgbo=0                    cgdl=cgln_na25            cgsl=cgln_na25
+ clc=1e-007                cle=0.6                   cf=cfn_na25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.2672704            lkt1=-4.897936e-008       kt1l=0
+ kt2=-0.02963              ute=-1.48                 ua1=1.67e-009
+ ub1=-2.64016e-018         uc1=6.1508484e-011        luc1=3.4816825e-016
+ wuc1=-1.7619603e-016      puc1=-4.2023907e-022      prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25
+ cjd=cjn_na25              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25
+ cjswd=cjswn_na25          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25
+ cjswgd=cjswgn_na25        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25
+ pvth0=0+dpvthn_na25       lcit=0+dlcitn_na25        wcit=0+dwcitn_na25
+ pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           noib=noibn_na25           noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     7: type=n 
+ lmin=9.99999e-006-dxln_na25                         lmax=900.00001e-06
+ wmin=5e-07                wmax=1.2e-006-dxwn_na25   version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=0.012003617            wk2=-1.6732958e-008       k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25
+ voff=-0.12783168          wvoff=3.4500609e-009      nfactor=0.8+dnfactorn_na25
+ eta0=0.028641812+deta0n_na25                        weta0=-1.4108396e-008+dweta0n_na25
+ etab=0.0010882964         u0=0.06106174+du0n_na25   wu0=1.1659461e-009+dwu0n_na25
+ ua=1.2854346e-009         wua=-7.4749352e-017       ub=2.4999846e-018
+ uc=2.6115752e-011         vsat=78400+dvsatn_na25    a0=1.4808087+0.14485714
+ pa0=0+0                   la0=0-0                   wa0=6.2088783e-009-1.7484257e-07
+ ags=1.6647716             wags=-2.027371e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.029279813         dwg=0                     dwb=0
+ pclm=0.14504125           pdiblc1=0                 pdiblc2=0.000135
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25
+ cgdo=cgon_na25            cgbo=0                    cgdl=cgln_na25
+ cgsl=cgln_na25            clc=1e-007                cle=0.6
+ cf=cfn_na25               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3.13911e-018         uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25              cjd=cjn_na25
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25          cjswd=cjswn_na25
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25        cjswgd=cjswgn_na25
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25
+ lu0=0+dlu0n_na25          pu0=0+dpu0n_na25          lcit=0+dlcitn_na25
+ wcit=0+dwcitn_na25        pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           noib=noibn_na25           noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     8: type=n 
+ lmin=1.99999e-006-dxln_na25                         lmax=9.99999e-006-dxln_na25
+ wmin=5e-07                wmax=1.2e-006-dxwn_na25   version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=0.012933166            lk2=-9.2596208e-009       wk2=-1.7322919e-008
+ pk2=5.8768479e-015        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0+dcitn_na25          voff=-0.12905814
+ lvoff=1.221718e-008       wvoff=3.9046996e-009      pvoff=-4.528842e-015
+ nfactor=0.8+dnfactorn_na25                          eta0=0.028641812+deta0n_na25
+ weta0=-1.4108396e-008+dweta0n_na25                  etab=0.0010882964
+ u0=0.062004206+du0n_na25  lu0=-9.3882913e-009+dlu0n_na25
+ wu0=2.040266e-010+dwu0n_na25                        pu0=9.5820743e-015+dpu0n_na25
+ ua=1.2896963e-009         lua=-4.2452701e-017       wua=-1.6188868e-016
+ pua=8.6803058e-022        ub=2.594245e-018          lub=-9.389669e-025
+ wub=5.5749704e-026        pub=-5.5534566e-031       uc=3.2781608e-011
+ luc=-6.6401324e-017       wuc=4.9695541e-018        puc=-4.9503766e-023
+ vsat=78400+dvsatn_na25    a0=1.5569963+0.18037249   la0=-7.5893653e-007-3.5378261e-07
+ wa0=8.4934061e-008-2.177096e-07                     pa0=-7.8421382e-013+4.2701561e-13
+ ags=1.5962099             lags=6.8297174e-007       wags=-4.1063467e-007
+ pags=2.0709529e-012       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.01641015-0.0042275175
+ lketa=-1.2819999e-007+4.2111993e-08                 wketa=-3.2406274e-009+2.1433514e-09
+ pketa=3.2281218e-014-2.135078e-14                   dwg=0
+ dwb=0                     pclm=0.14504125           pdiblc1=0
+ pdiblc2=0.000135          pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.2614407e-018       lub1=1.2185862e-024       uc1=-8.447e-011
+ prt=0                     at=183960.37              lat=-0.19162228
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na25              cjd=cjn_na25              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na25          cjswd=cjswn_na25          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na25        cjswgd=cjswgn_na25        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=0+dlvthn_na25
+ wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25       lcit=0+dlcitn_na25
+ wcit=0+dwcitn_na25        pcit=0+dpcitn_na25        lnfactor=0+dlnfactorn_na25
+ wnfactor=0+dwnfactorn_na25                          pnfactor=0+dpnfactorn_na25
+ leta0=0+dleta0n_na25      peta0=0+dpeta0n_na25      lvsat=0+dlvsatn_na25
+ wvsat=0+dwvsatn_na25      pvsat=0+dpvsatn_na25      fnoimod=1
+ noia=noian_na25           noib=noibn_na25           noic=noicn_na25
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na25
+ wmin=5e-07                wmax=1.2e-006-dxwn_na25   version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25    xw=7e-09+dxwn_na25        dlc=0+ddlcn_na25
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na25  k1=0.083826
+ k2=0.0070517436           lk2=2.2762599e-009        wk2=-1.2877221e-008
+ pk2=-2.842989e-015        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0+dcitn_na25          voff=-0.12106439
+ lvoff=-3.4618388e-009     wvoff=-7.9880317e-009     pvoff=1.879768e-014
+ nfactor=0.8+dnfactorn_na25                          eta0=0.028641812+deta0n_na25
+ leta0=-2.0005323e-016+dleta0n_na25                  weta0=-1.4108396e-008+dweta0n_na25
+ peta0=2.4146429e-022+dpeta0n_na25                   etab=-0.0045972791
+ letab=1.1151745e-008      wetab=2.8825868e-009      petab=-5.6539345e-015
+ u0=0.061722716+du0n_na25-0.012516423+0.00052575199  lu0=-8.8361755e-009+dlu0n_na25+2.4549712e-08-1.03121e-09
+ wu0=-2.1558162e-009+dwu0n_na25+6.3458265e-09-6.3458265e-10
+ pu0=1.4210694e-014+dpu0n_na25-1.2446704e-14+1.2446704e-15
+ ua=1.6235236e-009         lua=-6.9722491e-016       wua=-7.2188788e-016
+ pua=1.9664186e-021        ub=1.8314711e-018+2.5032846e-19-5.2575199e-19
+ lub=5.5714547e-025-4.9099425e-25+1.03121e-24        wub=9.1307699e-025-1.2691653e-25+6.3458265e-25
+ pub=-2.236916e-030+2.4893408e-31-1.2446704e-30      uc=1.6131981e-010
+ luc=-3.1851744e-016       wuc=-9.2263315e-017       puc=1.4120976e-022
+ vsat=78400+dvsatn_na25-2103.008                     a0=1.8138372+0.50065693-0.1051504
+ la0=-1.2627068e-006-9.8198849e-07+2.0624199e-07     wa0=-4.9933847e-007-2.5383306e-07+1.2691653e-07
+ pa0=3.6178416e-013+4.9786817e-13-2.4893408e-13      ags=1.253264
+ lags=1.3556292e-006       wags=-1.9082677e-007      pags=1.6398195e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080802003+0.042275703-0.025032846
+ lketa=-1.9011631e-009-4.9099425e-08+4.9099425e-08   wketa=2.6463098e-008-2.1433782e-08+1.2691653e-08
+ pketa=-2.5979966e-014+2.4893408e-14-2.4893408e-14   dwg=0
+ dwb=0                     pclm=0.53198689           lpclm=-7.5895904e-007
+ wpclm=-2.3041366e-007     ppclm=4.5193566e-013      pdiblc1=0
+ pdiblc2=0.00030623536     lpdiblc2=-3.3586275e-010  wpdiblc2=3.8550414e-012
+ ppdiblc2=-7.5613168e-018  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25            cgdo=cgon_na25            cgbo=0
+ cgdl=cgln_na25            cgsl=cgln_na25            clc=1e-007
+ cle=0.6                   cf=cfn_na25               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=-8.447e-011           prt=0                     at=128258.51
+ lat=-0.082368082          jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25              cjd=cjn_na25
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25          cjswd=cjswn_na25
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25        cjswgd=cjswgn_na25
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25       wvth0=0+dwvthn_na25       pvth0=0+dpvthn_na25
+ lcit=0+dlcitn_na25        wcit=0+dwcitn_na25        pcit=0+dpcitn_na25
+ lnfactor=0+dlnfactorn_na25                          wnfactor=0+dwnfactorn_na25
+ pnfactor=0+dpnfactorn_na25                          lvsat=0+dlvsatn_na25+0.0041248398
+ wvsat=0+dwvsatn_na25+0.0025383306                   pvsat=0+dpvsatn_na25-4.9786817e-09
+ fnoimod=1                 noia=noian_na25           noib=noibn_na25
+ noic=noicn_na25           em=1.1200e+08             ef=1.00
+ tnoimod=0                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
     } 
endsection mos_na25
 

section mos_na25od33
// *********************************************************************************************
//                                                                            
//                   *
//                                3.3V NATIVE NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt nch_na25od33_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=1.135e-007 xw= + 
+ 7e-09 + dxwn_na25od33 ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg 
+ / factor * (w / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) 
+ ps=4 * dmcg / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf 
+ + xw / factor) nrs=dmcg / factor / (w / nf + xw / factor) sa=4.6e-7 / factor sb=4.6e-7 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parn1_na25od33 temp2=parn2_na25od33 fac1=0.010100 * temp1 
+ * sigma + 0.999949 * temp2 * sigma fac2=0.010100 * temp1 * sigma - 0.999949 * 
+ temp2 * sigma lef=l * factor - 3.859e-8 wef=w / nf * factor + 7e-09 geo_fac=1 
+ / sqrt(multi * nf * lef * wef * 1e12) vthmisn_na25od33=0.00190412 * geo_fac * 
+ fac1 * mismatchflag dlmisn_na25od33=0.00191205 * geo_fac * lef * fac2 * mismatchflag 
+ dwmisn_na25od33= - 0.00191205 * geo_fac * wef * fac2 * mismatchflag toxmisn_na25od33=0.00191205 
+ * geo_fac * toxn_na25od33 * fac2 * mismatchflag tnoiax=1.903e04 / (l * 1e6) + 
+ 8.634e6 rnoiax= - 0.1171 / (l * 1e6) + 0.6655 
nch_na25od33_mac ( n1 n2 n3 n4 ) nch_na25od33 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs 
+ m=multi nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
 
model nch_na25od33 bsim4  { 
     1: type=n 
+ lmin=9.99999e-006-(dxln_na25od33+dlmisn_na25od33)   lmax=900.00001e-06
+ wmin=1e-005-(dxwn_na25od33+dwmisn_na25od33)         wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=-0.0019481098          pk2=0
+ wk2=0                     lk2=0                     k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000703125+dcitn_na25od33
+ voff=-0.12480063          nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021196+deta0n_na25od33                       etab=0.0010882964
+ u0=0.062834873+du0n_na25od33                        ua=1.2235048e-009
+ ub=2.4999846e-018         uc=-4.7661329e-011        vsat=78400+dvsatn_na25od33
+ a0=3.1835779              pa0=0                     wa0=0
+ la0=0                     ags=1.0683639             a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.055602815         dwg=0                     dwb=0
+ pclm=0.01                 pdiblc1=0                 pdiblc2=0.0001485
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25od33
+ cgdo=cgon_na25od33        cgbo=0                    cgdl=cgln_na25od33
+ cgsl=cgln_na25od33        clc=1e-007                cle=0.6
+ cf=cfn_na25od33           ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3e-018               uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25od33   wvth0=0+dwvthn_na25od33   pvth0=0+dpvthn_na25od33
+ lu0=0+dlu0n_na25od33      wu0=0+dwu0n_na25od33      pu0=0+dpu0n_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ weta0=0+dweta0n_na25od33  peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33
+ wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33  fnoimod=1
+ noia=noian_na25od33       rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25od33       rnoib=0                   noic=noicn_na25od33
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     2: type=n 
+ lmin=1.99999e-006-(dxln_na25od33+dlmisn_na25od33)   lmax=9.99999e-006-(dxln_na25od33+dlmisn_na25od33)
+ wmin=1e-005-(dxwn_na25od33+dwmisn_na25od33)         wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.03365+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=-0.0012911519          pk2=0
+ wk2=0                     lk2=-6.5442298e-09        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00087551455+dcitn_na25od33
+ lcit=-1.717243e-009+dlcitn_na25od33                 voff=-0.12541317
+ lvoff=6.1017084e-009      nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021196+deta0n_na25od33                       etab=0.0010882964
+ u0=0.062126092+du0n_na25od33                        lu0=7.0604626e-009+dlu0n_na25od33
+ ua=1.0246402e-009         lua=1.9809716e-015        ub=2.8162903e-18
+ pub=0                     wub=0                     lub=-3.1508501e-24
+ uc=-1.5214257e-011        luc=-3.2321858e-016       vsat=78400+dvsatn_na25od33
+ a0=3.7775816              pa0=0                     wa0=0
+ la0=-5.9171147e-06        ags=0.58809352            lags=4.7841698e-006
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.049079469         lketa=-6.4981729e-008
+ dwg=0                     dwb=0                     pclm=-0.026664974
+ lpclm=3.6523484e-007      pdiblc1=0                 pdiblc2=0.00015511976
+ lpdiblc2=-6.5942131e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.0882242e-018       lub1=8.7883765e-025       uc1=-1.5421529e-010
+ luc1=6.9476141e-016       prt=0                     at=183960.37
+ lat=-0.19162228           jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25od33   wvth0=0+dwvthn_na25od33   pvth0=0+dpvthn_na25od33
+ wu0=0+dwu0n_na25od33      pu0=0+dpu0n_na25od33      wcit=0+dwcitn_na25od33
+ pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ leta0=0+dleta0n_na25od33  weta0=0+dweta0n_na25od33  peta0=0+dpeta0n_na25od33
+ lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33
+ fnoimod=1                 noia=noian_na25od33       rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na25od33       rnoib=0
+ noic=noicn_na25od33       em=1.1200e+08             ef=1.00
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na25od33+dlmisn_na25od33)
+ wmin=1e-005-(dxwn_na25od33+dwmisn_na25od33)         wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.026391097+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=0.00079789845          pk2=0
+ wk2=0                     lk2=-1.0641687e-08        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25od33
+ voff=-0.13332084          lvoff=2.1611887e-008      nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021196+deta0n_na25od33                       etab=-0.0015372917
+ letab=5.1498547e-009      u0=0.056487534+du0n_na25od33
+ lu0=1.8119928e-08+dlu0n_na25od33                    ua=1.2107717e-009
+ lua=1.6158914e-015        ub=1.7884528e-18          pub=0
+ wub=0                     lub=-1.1348474e-24        uc=-1.654901e-010
+ luc=-2.8466042e-017       vsat=78400+dvsatn_na25od33
+ a0=1.6134766              pa0=0                     wa0=0
+ la0=-1.6724197e-06        ags=-8.613579+3.6294516   pags=0+0
+ wags=0-0                  lags=2.2832422e-005-7.1188064e-06
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080253643-0.029035613
+ pketa=0+0                 wketa=0-0                 lketa=-3.8364353e-09+5.6950451e-08
+ dwg=0                     dwb=0                     pclm=0.33322887
+ lpclm=-3.4066454e-007     pdiblc1=0                 pdiblc2=0.0001458025
+ lpdiblc2=-4.7667175e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=4.3901206e-011        luc1=3.0617374e-016       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.4237613e-08+dlvthn_na25od33
+ wvth0=0+dwvthn_na25od33   pvth0=0+dpvthn_na25od33   wu0=0+dwu0n_na25od33
+ pu0=0+dpu0n_na25od33      lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33
+ pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ leta0=0+dleta0n_na25od33  weta0=0+dweta0n_na25od33  peta0=0+dpeta0n_na25od33
+ lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33
+ fnoimod=1                 noia=noian_na25od33       rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na25od33       rnoib=0
+ noic=noicn_na25od33       em=1.1200e+08             ef=1.00
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     4: type=n 
+ lmin=9.99999e-006-(dxln_na25od33+dlmisn_na25od33)   lmax=900.00001e-06
+ wmin=1.2e-006-(dxwn_na25od33+dwmisn_na25od33)       wmax=1e-005-(dxwn_na25od33+dwmisn_na25od33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.034198636+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=-0.0018230844          pk2=0
+ lk2=0                     wk2=-1.2511295e-09        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00079956499+dcitn_na25od33
+ wcit=-9.6507494e-010+dwcitn_na25od33                voff=-0.12477695
+ wvoff=-2.3700525e-010     nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021777966+deta0n_na25od33                    weta0=-5.823734e-009+dweta0n_na25od33
+ etab=0.0010882964         u0=0.062945581+du0n_na25od33
+ wu0=-1.1078502e-009+dwu0n_na25od33                  ua=1.2235048e-009
+ ub=2.4999846e-018         uc=-5.7780526e-011        wuc=1.0126281e-016
+ vsat=78400+dvsatn_na25od33                          a0=3.4328817
+ pa0=0                     la0=0                     wa0=-2.4947833e-06
+ ags=1.0095994             wags=5.8805572e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.059213254         wketa=3.6129664e-008      dwg=0
+ dwb=0                     pclm=-0.0085221351        wpclm=1.8535101e-007
+ pdiblc1=0                 pdiblc2=0.00015035165     wpdiblc2=-1.8529439e-011
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25od33
+ cgdo=cgon_na25od33        cgbo=0                    cgdl=cgln_na25od33
+ cgsl=cgln_na25od33        clc=1e-007                cle=0.6
+ cf=cfn_na25od33           ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-2.9809198e-018       wub1=-1.9093557e-025      uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25od33   wvth0=5.4902041e-09+dwvthn_na25od33
+ pvth0=0+dpvthn_na25od33   lu0=0+dlu0n_na25od33      pu0=0+dpu0n_na25od33
+ lcit=0+dlcitn_na25od33    pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ leta0=0+dleta0n_na25od33  peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33
+ wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33  fnoimod=1
+ noia=noian_na25od33       rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25od33       rnoib=0                   noic=noicn_na25od33
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     5: type=n 
+ lmin=1.99999e-006-(dxln_na25od33+dlmisn_na25od33)   lmax=9.99999e-006-(dxln_na25od33+dlmisn_na25od33)
+ wmin=1.2e-006-(dxwn_na25od33+dwmisn_na25od33)       wmax=1e-005-(dxwn_na25od33+dwmisn_na25od33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.034333148+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=-0.0011532878          lk2=-6.672122e-09
+ wk2=-1.3796064e-09        pk2=1.2798169e-15         k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00099559933+dcitn_na25od33
+ lcit=-1.9527785e-009+dlcitn_na25od33                wcit=-1.2016884e-009+dwcitn_na25od33
+ pcit=2.3570036e-015+dpcitn_na25od33                 voff=-0.12535694
+ lvoff=5.777557e-009       wvoff=-5.6264021e-010     pvoff=3.2437834e-015
+ nfactor=0.8+dnfactorn_na25od33                      eta0=0.021777966+deta0n_na25od33
+ weta0=-5.823734e-009+dweta0n_na25od33               etab=0.0010882964
+ u0=0.062119625+du0n_na25od33                        lu0=8.2276866e-009+dlu0n_na25od33
+ wu0=6.471586e-011+dwu0n_na25od33                    pu0=-1.1680411e-014+dpu0n_na25od33
+ ua=1.0066817e-009         lua=2.1598628e-015        wua=1.7970992e-016
+ pua=-1.7901642e-021       ub=2.8343576e-18          lub=-3.3308258e-24
+ wub=-1.8079948e-25        pub=1.801017e-30          uc=-2.2362049e-011
+ luc=-3.5281798e-016       wuc=7.1527948e-017        puc=2.9620114e-022
+ vsat=78400+dvsatn_na25od33                          a0=4.08829
+ la0=-6.5287911e-06        wa0=-3.1092591e-06        pa0=6.1210439e-12
+ ags=0.49648423            lags=5.1113508e-006       wags=9.1673415e-007
+ pags=-3.2741006e-012      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.05319211+0.0003362798
+ lketa=-5.9979091e-008-3.3498176e-09                 wketa=4.1155197e-008-3.365152e-09
+ pketa=-5.0061403e-014+3.3521625e-14                 dwg=0
+ dwb=0                     pclm=-0.050216044         lpclm=4.1533012e-007
+ wpclm=2.3567555e-007      ppclm=-5.0130345e-013     pdiblc1=0
+ pdiblc2=0.00015787937     lpdiblc2=-7.4986694e-011  wpdiblc2=-2.7615395e-011
+ ppdiblc2=9.0508939e-017   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.064466e-018        lub1=8.3223805e-025       wub1=-2.3774844e-025
+ pub1=4.6632217e-031       uc1=-1.6310893e-10        luc1=7.8335461e-16
+ wuc1=8.8998662e-17        puc1=-8.8655223e-22       prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=1.339927e-09+dlvthn_na25od33
+ wvth0=6.8362649e-09+dwvthn_na25od33                 pvth0=-1.340865e-14+dpvthn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33
+ pvsat=0+dpvsatn_na25od33  fnoimod=1                 noia=noian_na25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na25od33
+ rnoib=0                   noic=noicn_na25od33       em=1.1200e+08
+ ef=1.00                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na25od33+dlmisn_na25od33)
+ wmin=1.2e-006-(dxwn_na25od33+dwmisn_na25od33)       wmax=1e-005-(dxwn_na25od33+dwmisn_na25od33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.025395472+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=0.0007131239           lk2=-1.0332897e-08
+ wk2=8.48339e-10           pk2=-3.090054e-15         k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25od33
+ voff=-0.13409419          lvoff=2.2914876e-008      wvoff=7.7389381e-009
+ pvoff=-1.3039015e-014     nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021777966+deta0n_na25od33                    weta0=-5.823734e-009+dweta0n_na25od33
+ etab=-0.0014451533        letab=4.9691335e-009      wetab=-9.2202907e-010
+ petab=1.808477e-015       u0=0.057010084+du0n_na25od33
+ lu0=1.8249534e-08+dlu0n_na25od33                    wu0=-5.2291659e-09+dwu0n_na25od33
+ pu0=-1.2969584e-15+dpu0n_na25od33                   ua=1.2361917e-009
+ lua=1.7096996e-015        wua=-2.5437827e-016       pua=-9.3873932e-022
+ ub=1.7194123e-18          lub=-1.1439695e-24        wub=6.9088787e-25
+ pub=9.12868e-32           uc=-1.9983058e-010        luc=-4.7294195e-018
+ wuc=3.4364521e-016        puc=-2.3753239e-022       vsat=78400+dvsatn_na25od33
+ a0=1.6454133              la0=-1.7373106e-06        wa0=-3.1958999e-07
+ pa0=6.4936333e-13         ags=-9.9452213+4.1272639  lags=2.5591817e-005-8.0952154e-06
+ wags=1.3325745e-005-4.9816075e-06                   pags=-2.7613259e-011+9.770925e-12
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.083185601-0.033018111-0.00336284+0.0019912491
+ lketa=-1.1496065e-09+6.4761723e-08+3.9056361e-09-3.9056361e-09
+ wketa=2.9340101e-08+3.985286e-08+3.365194e-08-1.992643e-08
+ pketa=-2.6887095e-14-7.81674e-14-3.90837e-14+3.90837e-14
+ dwg=0                     dwb=0                     pclm=0.33215077
+ lpclm=-3.3464797e-007     wpclm=1.0788531e-008      ppclm=-6.0207799e-014
+ pdiblc1=0                 pdiblc2=0.00012335961     lpdiblc2=-7.2792913e-012
+ wpdiblc2=2.2458608e-010   ppdiblc2=-4.0416155e-016  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25od33        cgdo=cgon_na25od33
+ cgbo=0                    cgdl=cgln_na25od33        cgsl=cgln_na25od33
+ clc=1e-007                cle=0.6                   cf=cfn_na25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.2672704            lkt1=-4.897936e-008       kt1l=0
+ kt2=-0.02963              ute=-1.48                 ua1=1.67e-009
+ ub1=-2.64016e-018         uc1=5.4782804e-11         luc1=3.5597952e-16
+ wuc1=-1.0889215e-16       puc1=-4.9840647e-22       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.6190431e-08+dlvthn_na25od33
+ wvth0=-9.9632151e-09+dwvthn_na25od33                pvth0=1.954185e-14+dpvthn_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33
+ pvsat=0+dpvsatn_na25od33  fnoimod=1                 noia=noian_na25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na25od33
+ rnoib=0                   noic=noicn_na25od33       em=1.1200e+08
+ ef=1.00                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     7: type=n 
+ lmin=9.99999e-006-(dxln_na25od33+dlmisn_na25od33)   lmax=900.00001e-06
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na25od33+dwmisn_na25od33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.031822857+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=0.0081064739           pk2=0
+ lk2=0                     wk2=-1.3236106e-08        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25od33
+ voff=-0.12783168          wvoff=3.4500609e-009      nfactor=0.8+dnfactorn_na25od33
+ eta0=0.028641812+deta0n_na25od33                    weta0=-1.4108396e-008+dweta0n_na25od33
+ etab=0.0010882964         u0=0.06106174+du0n_na25od33
+ wu0=1.1659461e-009+dwu0n_na25od33                   ua=1.2854346e-009
+ wua=-7.4749352e-017       ub=2.4999846e-018         uc=2.6115752e-011
+ vsat=78400+dvsatn_na25od33                          a0=1.4766944
+ pa0=0                     la0=0                     wa0=-1.3366518e-07
+ ags=1.6647716             wags=-2.027371e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.029279813         dwg=0                     dwb=0
+ pclm=0.14504125           pdiblc1=0                 pdiblc2=0.000135
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25od33
+ cgdo=cgon_na25od33        cgbo=0                    cgdl=cgln_na25od33
+ cgsl=cgln_na25od33        clc=1e-007                cle=0.6
+ cf=cfn_na25od33           ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3.13911e-018         uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25od33   wvth0=2.6226386e-09+dwvthn_na25od33
+ pvth0=0+dpvthn_na25od33   lu0=0+dlu0n_na25od33      pu0=0+dpu0n_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33
+ pvsat=0+dpvsatn_na25od33  fnoimod=1                 noia=noian_na25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na25od33
+ rnoib=0                   noic=noicn_na25od33       em=1.1200e+08
+ ef=1.00                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     8: type=n 
+ lmin=1.99999e-006-(dxln_na25od33+dlmisn_na25od33)   lmax=9.99999e-006-(dxln_na25od33+dlmisn_na25od33)
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na25od33+dwmisn_na25od33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.029954273+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=0.0087146696           lk2=-6.0584809e-09
+ wk2=-1.329023e-08         pk2=5.391529e-16          k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25od33
+ voff=-0.12905814          lvoff=1.221718e-008       wvoff=3.9046996e-009
+ pvoff=-4.528842e-015      nfactor=0.8+dnfactorn_na25od33
+ eta0=0.028641812+deta0n_na25od33                    weta0=-1.4108396e-008+dweta0n_na25od33
+ etab=0.0010882964         u0=0.062004206+du0n_na25od33
+ lu0=-9.3882913e-009+dlu0n_na25od33                  wu0=2.040266e-010+dwu0n_na25od33
+ pu0=9.5820743e-015+dpu0n_na25od33                   ua=1.2896963e-009
+ lua=-4.2452701e-017       wua=-1.6188868e-016       pua=8.6803058e-022
+ ub=2.6703403e-18          lub=-1.6969828e-24        wub=1.7169379e-26
+ pub=-1.7103161e-31        uc=3.2781608e-011         luc=-6.6401324e-017
+ wuc=4.9695541e-018        puc=-4.9503766e-023       vsat=78400+dvsatn_na25od33
+ a0=1.5933008              la0=-1.1615648e-06        wa0=-9.7807026e-08
+ pa0=-3.571982e-13         ags=1.5962099             lags=6.8297174e-007
+ wags=-4.1063467e-007      pags=2.0709529e-012       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.01641015-0.0042275175                       lketa=-1.2819999e-007+4.2111993e-08
+ wketa=-3.2406274e-009+2.1433514e-09                 pketa=3.2281218e-014-2.135078e-14
+ dwg=0                     dwb=0                     pclm=0.14504125
+ pdiblc1=0                 pdiblc2=0.000135          pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25od33        cgdo=cgon_na25od33
+ cgbo=0                    cgdl=cgln_na25od33        cgsl=cgln_na25od33
+ clc=1e-007                cle=0.6                   cf=cfn_na25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.25050115           lkt1=-8.1870746e-008      kt1l=0
+ kt2=-0.015762253          lkt2=-2.7200338e-008      ute=-1.48
+ ua1=1.67e-009             ub1=-3.2614407e-018       lub1=1.2185862e-024
+ uc1=-9.2925035e-11        puc1=-4.2701561e-23       wuc1=4.2867027e-18
+ luc1=8.4223986e-17        prt=0                     at=183960.37
+ lat=-0.19162228           jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=-1.861371e-08+dlvthn_na25od33                 wvth0=1.5509629e-09+dwvthn_na25od33
+ pvth0=1.067539e-14+dpvthn_na25od33                  lcit=0+dlcitn_na25od33
+ wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ leta0=0+dleta0n_na25od33  peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33
+ wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33  fnoimod=1
+ noia=noian_na25od33       rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na25od33       rnoib=0                   noic=noicn_na25od33
+ em=1.1200e+08             ef=1.00                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na25od33+dlmisn_na25od33)
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na25od33+dwmisn_na25od33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn_na25od33+toxmisn_na25od33)
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+(dxln_na25od33+dlmisn_na25od33)        xw=7e-09+(dxwn_na25od33+dwmisn_na25od33)
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.04049579+(dvthn_na25od33+vthmisn_na25od33)
+ k1=0.083826               k2=0.0094210721           lk2=-7.4439613e-09
+ wk2=-9.6621541e-09        pk2=-6.5770003e-15        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25od33
+ voff=-0.12106439          lvoff=-3.4618388e-009     wvoff=-7.9880317e-009
+ pvoff=1.879768e-014       nfactor=0.8+dnfactorn_na25od33
+ eta0=0.028641812+deta0n_na25od33                    leta0=-2.0005323e-016+dleta0n_na25od33
+ weta0=-1.4108396e-008+dweta0n_na25od33              peta0=2.4146429e-022+dpeta0n_na25od33
+ etab=-0.0045972791        letab=1.1151745e-008      wetab=2.8825868e-009
+ petab=-5.6539345e-015     u0=0.053938061+du0n_na25od33
+ lu0=6.4326469e-09+dlu0n_na25od33                    wu0=-1.5212336e-09+dwu0n_na25od33
+ pu0=1.2966024e-14+dpu0n_na25od33                    ua=1.6235236e-009
+ lua=-6.9722491e-016       wua=-7.2188788e-016       pua=1.9664186e-021
+ ub=1.4259873e-18          lub=7.43699e-25           wub=1.045052e-24
+ pub=-2.1871292e-30        uc=1.6131981e-010         luc=-3.1851744e-016
+ wuc=-9.2263315e-017       puc=1.4120976e-022        vsat=78400+dvsatn_na25od33-2103.008
+ a0=1.8316083              la0=-1.6289837e-06        wa0=-5.4432737e-07
+ pa0=5.1861263e-13         ags=1.253264              lags=1.3556292e-006
+ wags=-1.9082677e-007      pags=1.6398195e-012       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.080802003+0.042275703-0.025032846           lketa=-1.9011631e-009-4.9099425e-08+4.9099425e-08
+ wketa=2.6463098e-008-2.1433782e-08+1.2691653e-08    pketa=-2.5979966e-014+2.4893408e-14-2.4893408e-14
+ dwg=0                     dwb=0                     pclm=0.53198689
+ lpclm=-7.5895904e-007     wpclm=-2.3041366e-007     ppclm=4.5193566e-013
+ pdiblc1=0                 pdiblc2=0.00030623536     lpdiblc2=-3.3586275e-010
+ wpdiblc2=3.8550414e-012   ppdiblc2=-7.5613168e-018  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25od33        cgdo=cgon_na25od33
+ cgbo=0                    cgdl=cgln_na25od33        cgsl=cgln_na25od33
+ clc=1e-007                cle=0.6                   cf=cfn_na25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.2672704            lkt1=-4.897936e-008       kt1l=0
+ kt2=-0.02963              ute=-1.48                 ua1=1.67e-009
+ ub1=-2.64016e-018         uc1=2.1111487e-11         puc1=9.9573634e-23
+ wuc1=-6.8250869e-17       luc1=-1.3944725e-16       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=2.06242e-09+dlvthn_na25od33
+ wvth0=8.2628678e-09+dwvthn_na25od33                 pvth0=-2.489341e-15+dpvthn_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      lvsat=0+dlvsatn_na25od33+0.0041248398
+ wvsat=0+dwvsatn_na25od33+0.0025383306               pvsat=0+dpvsatn_na25od33-4.9786817e-09
+ fnoimod=1                 noia=noian_na25od33       rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na25od33       rnoib=0
+ noic=noicn_na25od33       em=1.1200e+08             ef=1.00
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
     } 
ends nch_na25od33_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                3.3V NATIVE NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch_na25od33 bsim4  { 
     1: type=n 
+ lmin=9.99999e-006-dxln_na25od33                     lmax=900.00001e-06
+ wmin=1e-005-dxwn_na25od33 wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25od33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25od33                          xw=7e-09+dxwn_na25od33
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.03365+dvthn_na25od33
+ k1=0.083826               k2=-0.0019481098          pk2=0
+ wk2=0                     lk2=0                     k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000703125+dcitn_na25od33
+ voff=-0.12480063          nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021196+deta0n_na25od33                       etab=0.0010882964
+ u0=0.062834873+du0n_na25od33                        ua=1.2235048e-009
+ ub=2.4999846e-018         uc=-4.7661329e-011        vsat=78400+dvsatn_na25od33
+ a0=3.1835779              pa0=0                     wa0=0
+ la0=0                     ags=1.0683639             a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.055602815         dwg=0                     dwb=0
+ pclm=0.01                 pdiblc1=0                 pdiblc2=0.0001485
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25od33
+ cgdo=cgon_na25od33        cgbo=0                    cgdl=cgln_na25od33
+ cgsl=cgln_na25od33        clc=1e-007                cle=0.6
+ cf=cfn_na25od33           ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3e-018               uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25od33   wvth0=0+dwvthn_na25od33   pvth0=0+dpvthn_na25od33
+ lu0=0+dlu0n_na25od33      wu0=0+dwu0n_na25od33      pu0=0+dpu0n_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ weta0=0+dweta0n_na25od33  peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33
+ wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33  fnoimod=1
+ noia=noian_na25od33       noib=noibn_na25od33       noic=noicn_na25od33
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     2: type=n 
+ lmin=1.99999e-006-dxln_na25od33                     lmax=9.99999e-006-dxln_na25od33
+ wmin=1e-005-dxwn_na25od33 wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25od33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25od33                          xw=7e-09+dxwn_na25od33
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.03365+dvthn_na25od33
+ k1=0.083826               k2=-0.0012911519          pk2=0
+ wk2=0                     lk2=-6.5442298e-09        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00087551455+dcitn_na25od33
+ lcit=-1.717243e-009+dlcitn_na25od33                 voff=-0.12541317
+ lvoff=6.1017084e-009      nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021196+deta0n_na25od33                       etab=0.0010882964
+ u0=0.062126092+du0n_na25od33                        lu0=7.0604626e-009+dlu0n_na25od33
+ ua=1.0246402e-009         lua=1.9809716e-015        ub=2.8162903e-18
+ pub=0                     wub=0                     lub=-3.1508501e-24
+ uc=-1.5214257e-011        luc=-3.2321858e-016       vsat=78400+dvsatn_na25od33
+ a0=3.7775816              pa0=0                     wa0=0
+ la0=-5.9171147e-06        ags=0.58809352            lags=4.7841698e-006
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.049079469         lketa=-6.4981729e-008
+ dwg=0                     dwb=0                     pclm=-0.026664974
+ lpclm=3.6523484e-007      pdiblc1=0                 pdiblc2=0.00015511976
+ lpdiblc2=-6.5942131e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.0882242e-018       lub1=8.7883765e-025       uc1=-1.5421529e-010
+ luc1=6.9476141e-016       prt=0                     at=183960.37
+ lat=-0.19162228           jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25od33   wvth0=0+dwvthn_na25od33   pvth0=0+dpvthn_na25od33
+ wu0=0+dwu0n_na25od33      pu0=0+dpu0n_na25od33      wcit=0+dwcitn_na25od33
+ pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ leta0=0+dleta0n_na25od33  weta0=0+dweta0n_na25od33  peta0=0+dpeta0n_na25od33
+ lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33
+ fnoimod=1                 noia=noian_na25od33       noib=noibn_na25od33
+ noic=noicn_na25od33       em=1.1200e+08             ef=1.00
+ tnoimod=0                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na25od33
+ wmin=1e-005-dxwn_na25od33 wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na25od33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na25od33                          xw=7e-09+dxwn_na25od33
+ dlc=0+ddlcn_na25od33      dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.026391097+dvthn_na25od33
+ k1=0.083826               k2=0.00079789845          pk2=0
+ wk2=0                     lk2=-1.0641687e-08        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na25od33
+ voff=-0.13332084          lvoff=2.1611887e-008      nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021196+deta0n_na25od33                       etab=-0.0015372917
+ letab=5.1498547e-009      u0=0.056487534+du0n_na25od33
+ lu0=1.8119928e-08+dlu0n_na25od33                    ua=1.2107717e-009
+ lua=1.6158914e-015        ub=1.7884528e-18          pub=0
+ wub=0                     lub=-1.1348474e-24        uc=-1.654901e-010
+ luc=-2.8466042e-017       vsat=78400+dvsatn_na25od33
+ a0=1.6134766              pa0=0                     wa0=0
+ la0=-1.6724197e-06        ags=-8.613579+3.6294516   pags=0+0
+ wags=0-0                  lags=2.2832422e-005-7.1188064e-06
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080253643-0.029035613
+ pketa=0+0                 wketa=0-0                 lketa=-3.8364353e-09+5.6950451e-08
+ dwg=0                     dwb=0                     pclm=0.33322887
+ lpclm=-3.4066454e-007     pdiblc1=0                 pdiblc2=0.0001458025
+ lpdiblc2=-4.7667175e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=4.3901206e-011        luc1=3.0617374e-016       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.4237613e-08+dlvthn_na25od33
+ wvth0=0+dwvthn_na25od33   pvth0=0+dpvthn_na25od33   wu0=0+dwu0n_na25od33
+ pu0=0+dpu0n_na25od33      lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33

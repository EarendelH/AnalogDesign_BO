+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     24: type=n 
+ lmin=2.6e-07              lmax=2.8e-007-dxln_25ud18 wmin=4e-07
+ wmax=6e-007-dxwn_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_25ud18          toxm=5.6e-009             dtox=2.835e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxln_25ud18   xw=7e-09+dxwn_25ud18
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.61323109+dvthn_25ud18
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-2.1781951e-008+dlvthn_25ud18
+ wvth0=-6.5999619e-008+dwvthn_25ud18                 pvth0=1.7162553e-014+dpvthn_25ud18
+ k1=0.3969                 k2=0.20860917+dk2n_25ud18 lk2=-3.3598734e-008+dlk2n_25ud18
+ wk2=-1.4501787e-007+dwk2n_25ud18                    pk2=4.0099169e-014+dpk2n_25ud18
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            xj=8.1e-008               ngate=4.282e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0019600887+dcitn_25ud18                       lcit=-8.5879563e-016+dlcitn_25ud18
+ wcit=-5.323928e-010+dwcitn_25ud18                   pcit=5.2128884e-022+dpcitn_25ud18
+ voff=-0.15145017          lvoff=1.9704524e-008      wvoff=2.2975198e-008
+ pvoff=-8.0197359e-015     nfactor=0.55              eta0=1.601503+deta0n_25ud18
+ leta0=-2.9189826e-007+dleta0n_25ud18                weta0=-7.4296965e-007+dweta0n_25ud18
+ peta0=1.9688694e-013+dpeta0n_25ud18                 etab=-0.090000106
+ letab=2.955712e-014       wetab=4.2924754e-014      petab=-1.202975e-020
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.14552361+du0n_25ud18 ku0=-6.6e-8
+ pku0=2.0e-15              wku0=20.8e-07             lku0=7e-7
+ lu0=-2.926504e-008+dlu0n_25ud18                     wu0=-6.6662931e-008+dwu0n_25ud18
+ pu0=1.7763879e-014+dpu0n_25ud18                     ua=-1.23e-009
+ ub=2.2303937e-017         lub=-4.9938288e-024       wub=-1.0670416e-023
+ pub=2.8342069e-030        uc=1.1057961e-010         luc=-2.9784369e-023
+ wuc=-1.6922936e-017       puc=2.0049576e-029        vsat=541779.21
+ lvsat=-0.11990832         wvsat=-0.1854411          kvsat=0
+ pvsat=5.012391e-008       a0=44.547045              la0=-1.1822856e-005
+ wa0=-1.7857962e-005       pa0=4.8119035e-012        ags=-37.325973
+ lags=9.8523746e-006       wags=1.5032944e-005       pags=-4.0099173e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.016069953         lketa=-1.9100935e-014
+ wketa=2.4704636e-009      pketa=9.623794e-021       dwg=0
+ dwb=0                     pclm=0.13895387           lpclm=-9.2485666e-013
+ wpclm=3.7055022e-008      ppclm=5.6138796e-019      pdiblc1=0
+ pdiblc2=0.00073850054     lpdiblc2=-1.3212247e-016  wpdiblc2=-1.2352483e-010
+ ppdiblc2=8.0198266e-023   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.39463              wkt1=2.223441e-008
+ kt1l=0                    kt2=-0.065983785          lkt2=1.3098632e-014
+ wkt2=8.178571e-009        pkt2=-4.009915e-021       ute=-1.5171311
+ wute=8.9308461e-008       ua1=1.059953e-009         wua1=1.5341743e-016
+ ub1=-2.6604928e-018       lub1=-9.8523655e-031      wub1=2.9633376e-025
+ pub1=4.0099151e-037       uc1=-9.4125847e-011       luc1=4.9034611e-023
+ wuc1=3.101086e-017        puc1=-1.2029741e-029      prt=0
+ at=26658.865              lat=-1.9704739e-008       wat=-0.0049410066
+ pat=8.0198271e-015        fnoimod=1                 tnoimod=0
+ noia=noian_25ud18         noib=noibn_25ud18         noic=noicn_25ud18
+ em=1.12e+008              ef=1                      jss=1.32e-07
+ jsd=1.32e-07              jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25ud18
+ cjd=cjn_25ud18            mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25ud18
+ cjswd=cjswn_25ud18        mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25ud18
+ cjswgd=cjswgn_25ud18      mjswgs=0.56               mjswgd=0.56
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.0025             tcjswg=0.00168
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-08
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=8.5e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=1.5e-2            pkvth0we=-11e-17          wkvth0we=-3e-10
+ lkvth0we=+5.83e-9         ku0we=-0.002              pku0we=-5e-17
+ wku0we=-0.9e-9            lku0we=-2e-10             k2we=0.0040
+ pk2we=-2e-17              lk2we=0e-10               wk2we=0.4e-9
+ minr=1e-3
 
 
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    1.8V PMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
     } 
model pch_25ud18 bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_25ud18   lmax=0.000901             wmin=1e-005-dxwp_25ud18
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.6329+dvthp_25ud18
+ k1=0.7812                 kvth0=+1.1e-09            pkvth0=0
+ wkvth0=+3.00e-007         lkvth0=-1.5e-7            k2=-0.082342292+dk2_25ud18
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=5e-006+dcitp_25ud18   voff=-0.15000001          nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.4                  etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.01425+du0p_25ud18    ua=1.997e-009             ub=1.95678e-019
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              uc=-1.025e-012            vsat=110000+dvsatp_25ud18
+ a0=1.1000002              kvsat=1                   ags=0.28435
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.02109             dwg=0
+ dwb=0                     pclm=0.27                 pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.30317              kt1l=0                    kt2=-0.03
+ ute=-1                    ua1=2.76e-009             ub1=-3.99e-018
+ uc1=-1.2000001e-010       prt=0                     at=200000.05
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ la0=0+dla0p_25ud18        wa0=0+dwa0p_25ud18        pa0=0+dpa0p_25ud18
+ lvth0=0+dlvthp_25ud18     wvth0=0+dwvthp_25ud18     pvth0=0+dpvthp_25ud18
+ lu0=0+dlu0p_25ud18        wu0=0+dwu0p_25ud18        pu0=0+dpu0p_25ud18
+ lcit=0+dlcitp_25ud18      wcit=0+dwcitp_25ud18      pcit=0+dpcitp_25ud18
+ lnfactor=0+dlnfactorp_25ud18                        wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        lvsat=0+dlvsatp_25ud18
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    leta0=0+dleta0p_25ud18
+ peta0=0+dpeta0p_25ud18    lkt1=0+dlkt1p_25ud18      saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     2: type=p 
+ lmin=1.2e-006-dxlp_25ud18 lmax=1e-005-dxlp_25ud18   wmin=1e-005-dxwp_25ud18
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63447551+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=1.5731481e-008+dlvthp_25ud18
+ k1=0.7812                 k2=-0.082398628+dk2_25ud18
+ lk2=5.6251473e-010        k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=5e-006+dcitp_25ud18   voff=-0.15518439
+ lvoff=5.1765998e-008      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.4                  etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.014244614+du0p_25ud18                          ku0=3.9e-9
+ pku0=2.0e-15              wku0=1.1e-06              lku0=+1.5e-8
+ lu0=5.3782841e-011+dlu0p_25ud18                     ua=2.0512676e-009
+ lua=-5.4186212e-016       ub=1.3040133e-019         lub=6.5178753e-025
+ uc=-9.2802756e-012        luc=8.2428927e-017        vsat=110000+dvsatp_25ud18
+ a0=1.126932               la0=-2.6891416e-007+dla0p_25ud18
+ kvsat=1                   ags=0.26194946            lags=2.2366939e-007
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.016910182         lketa=-4.1735485e-008
+ dwg=0                     dwb=0                     pclm=0.2533696
+ lpclm=1.6605452e-007      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-009          cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25ud18          cgdo=cgop_25ud18
+ cgbo=0                    cgdl=cglp_25ud18          cgsl=cglp_25ud18
+ clc=1e-007                cle=0.6                   cf=cfp_25ud18
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.2995571
+ lkt1=-3.6074841e-008+dlkt1p_25ud18                  kt1l=0
+ kt2=-0.03                 ute=-1                    ua1=2.76e-009
+ ub1=-3.9051648e-018       lub1=-8.4707974e-025      uc1=-1.2000001e-010
+ prt=0                     at=202019.94              lat=-0.020168565
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wa0=0+dwa0p_25ud18        pa0=0+dpa0p_25ud18        wvth0=0+dwvthp_25ud18
+ pvth0=0+dpvthp_25ud18     wu0=0+dwu0p_25ud18        pu0=0+dpu0p_25ud18
+ lcit=0+dlcitp_25ud18      wcit=0+dwcitp_25ud18      pcit=0+dpcitp_25ud18
+ lnfactor=0+dlnfactorp_25ud18                        wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        lvsat=0+dlvsatp_25ud18
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    leta0=0+dleta0p_25ud18
+ peta0=0+dpeta0p_25ud18    saref=4.6e-7              sbref=4.6e-7
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=5.0e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=-0.57e-2
+ pkvth0we=-0.0e-17         wkvth0we=-2.2e-10         lkvth0we=-2.48e-9
+ ku0we=-0.0150             pku0we=-0e-17             wku0we=-1.2e-9
+ lku0we=-1.0e-10           k2we=0.0125               pk2we=-6e-16
+ lk2we=-6e-10              wk2we=-0.1e-9             minr=1e-3
 
 
     3: type=p 
+ lmin=7e-007-dxlp_25ud18   lmax=1.2e-006-dxlp_25ud18 wmin=1e-005-dxwp_25ud18
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.627776+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=7.79256e-009+dlvthp_25ud18
+ k1=0.7812                 k2=-0.085934212+dk2_25ud18
+ lk2=4.7521823e-009        k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.000213241+dcitp_25ud18
+ lcit=2.5861559e-010+dlcitp_25ud18                   voff=-0.1314746
+ lvoff=2.3669906e-008      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.4                  etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.012509+du0p_25ud18   lu0=2.110485e-009+dlu0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              ua=1.41864e-009           lua=2.078016e-016
+ ub=4.5322534e-019         lub=2.6924108e-025        uc=-9.2064e-012
+ luc=8.2341384e-017        vsat=110000+dvsatp_25ud18 a0=0.89087635
+ la0=1.0811804e-008+dla0p_25ud18                     kvsat=1
+ ags=0.193688              lags=3.0455922e-007       a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.0260863           lketa=-3.0861785e-008     dwg=0
+ dwb=0                     pclm=0.288695             lpclm=1.2419393e-007
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-009
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25ud18          cgdo=cgop_25ud18          cgbo=0
+ cgdl=cglp_25ud18          cgsl=cglp_25ud18          clc=1e-007
+ cle=0.6                   cf=cfp_25ud18             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.33                 kt1l=0
+ kt2=-0.03                 ute=-1                    ua1=2.76e-009
+ ub1=-4.62e-018            uc1=-1.2000002e-010       luc1=1.62345e-023
+ prt=0                     at=285010.15              lat=-0.11851196
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wa0=0+dwa0p_25ud18        pa0=0+dpa0p_25ud18        wvth0=0+dwvthp_25ud18
+ pvth0=0+dpvthp_25ud18     wu0=0+dwu0p_25ud18        pu0=0+dpu0p_25ud18
+ wcit=0+dwcitp_25ud18      pcit=0+dpcitp_25ud18      lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    lkt1=0+dlkt1p_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
 
     4: type=p 
+ lmin=3.8e-007-dxlp_25ud18 lmax=7e-007-dxlp_25ud18   wmin=1e-005-dxwp_25ud18
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63932656+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=1.5704695e-008+dlvthp_25ud18
+ k1=0.7812                 k2=-0.071986651+dk2_25ud18
+ lk2=-4.8018973e-009       k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00016157655+dcitp_25ud18
+ lcit=2.2322544e-010+dlcitp_25ud18                   voff=-0.15750999
+ lvoff=4.1504142e-008      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.4                  etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.017107031+du0p_25ud18                          ku0=3.9e-9
+ pku0=2.0e-15              wku0=1.1e-06              lku0=+1.5e-8
+ lu0=-1.0391664e-009+dlu0p_25ud18                    ua=2.6060984e-009
+ lua=-6.0560743e-016       ub=-2.0279885e-020        lub=5.9359216e-025
+ uc=1.0153281e-010         luc=6.4850234e-018        vsat=110000+dvsatp_25ud18
+ a0=1.0739441              la0=-1.1458958e-007+dla0p_25ud18
+ kvsat=1                   ags=0.079165625           lags=3.8300705e-007
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.068459531         lketa=-1.8361211e-009
+ dwg=0                     dwb=0                     pclm=0.31873296
+ lpclm=1.0361792e-007      pdiblc1=0                 pdiblc2=9.9999989e-006
+ lpdiblc2=7.8132812e-019   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.29578124           lkt1=-2.3439852e-008+dlkt1p_25ud18
+ kt1l=0                    kt2=-0.01175              lkt2=-1.250125e-008
+ ute=-1                    ua1=2.76e-009             ub1=-4.4619094e-018
+ lub1=-1.0829208e-025      uc1=-2.1581249e-010       luc1=6.5631555e-017
+ prt=0                     at=194124.95              lat=-0.056255602
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wa0=0+dwa0p_25ud18        pa0=0+dpa0p_25ud18        wvth0=0+dwvthp_25ud18
+ pvth0=0+dpvthp_25ud18     wu0=0+dwu0p_25ud18        pu0=0+dpu0p_25ud18
+ wcit=0+dwcitp_25ud18      pcit=0+dpcitp_25ud18      lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     5: type=p 
+ lmin=2.8e-007-dxlp_25ud18 lmax=3.8e-007-dxlp_25ud18 wmin=1e-005-dxwp_25ud18
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.524803+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-2.6096405e-008+dlvthp_25ud18
+ k1=0.7812                 k2=-0.030506249+dk2_25ud18
+ lk2=-1.9942244e-008       k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0016159998+dcitp_25ud18
+ lcit=-4.2558993e-010+dlcitp_25ud18                  voff=0.015983988
+ lvoff=-2.1821158e-008     nfactor=0.63002+dnfactorp_25ud18
+ eta0=-0.27045             leta0=2.4471425e-007+dleta0p_25ud18
+ etab=-0.023250002         letab=4.8362506e-009      ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.010974+du0p_25ud18   lu0=1.19939e-009+dlu0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              ua=8.05655e-010           lua=5.1554425e-017
+ ub=7.271e-020             lub=5.5965085e-025        uc=3.0294501e-010
+ luc=-6.7030429e-017       vsat=110000+dvsatp_25ud18 a0=1.7669998
+ la0=-3.6755491e-007+dla0p_25ud18                    kvsat=1
+ ags=-2.1614753            lags=1.200841e-006        a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.21523852          lketa=5.1738208e-008      dwg=0
+ dwb=0                     pclm=0.18290445           lpclm=1.5319533e-007
+ pdiblc1=0                 pdiblc2=1.0000004e-005    lpdiblc2=-9.6725001e-019
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-009          cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25ud18          cgdo=cgop_25ud18
+ cgbo=0                    cgdl=cglp_25ud18          cgsl=cglp_25ud18
+ clc=1e-007                cle=0.6                   cf=cfp_25ud18
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.41830001
+ lkt1=2.12795e-008+dlkt1p_25ud18                     kt1l=0
+ kt2=-0.0778               lkt2=1.1607e-008          ute=-1
+ ua1=2.2565e-009           lua1=1.837775e-016        ub1=-3.27089e-018
+ lub1=-5.4301415e-025      uc1=-1.2080003e-010       luc1=3.0952007e-017
+ prt=0                     at=82400.031              lat=-0.015476008
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wa0=0+dwa0p_25ud18        pa0=0+dpa0p_25ud18        wvth0=0+dwvthp_25ud18
+ pvth0=0+dpvthp_25ud18     wu0=0+dwu0p_25ud18        pu0=0+dpu0p_25ud18
+ wcit=0+dwcitp_25ud18      pcit=0+dpcitp_25ud18      lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ peta0=0+dpeta0p_25ud18    saref=4.6e-7              sbref=4.6e-7
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=5.0e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=-0.57e-2
+ pkvth0we=-0.0e-17         wkvth0we=-2.2e-10         lkvth0we=-2.48e-9
+ ku0we=-0.0150             pku0we=-0e-17             wku0we=-1.2e-9
+ lku0we=-1.0e-10           k2we=0.0125               pk2we=-6e-16
+ lk2we=-6e-10              wk2we=-0.1e-9             minr=1e-3
 
 
     6: type=p 
+ lmin=2.6e-07              lmax=2.8e-007-dxlp_25ud18 wmin=1e-005-dxwp_25ud18
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.76146+dvthp_25ud18
+ lvth0=3.66177e-008+dlvthp_25ud18                    kvth0=+1.1e-09
+ pkvth0=0                  wkvth0=+3.00e-007         lkvth0=-1.5e-7
+ k1=0.7812                 k2=0.01674+dk2_25ud18     lk2=-3.24625e-008
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=1.0000838e-005+dcitp_25ud18                     lcit=-2.0548763e-016+dlcitp_25ud18
+ voff=-0.066360079         lvoff=1.94775e-014        nfactor=-0.59497976+dnfactorp_25ud18
+ lnfactor=3.2462494e-007+dlnfactorp_25ud18           eta0=-0.53525
+ leta0=3.1488625e-007+dleta0p_25ud18                 etab=-0.0049999908
+ letab=-2.272375e-015      ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.011825+du0p_25ud18
+ lu0=9.73875e-010+dlu0p_25ud18                       ku0=3.9e-9
+ pku0=2.0e-15              wku0=1.1e-06              lku0=+1.5e-8
+ ua=1.0001988e-009         lua=3.2462499e-022        ub=2.1846e-018
+ uc=4.9999947e-011         luc=1.2985e-023           vsat=2200+dvsatp_25ud18
+ kvsat=1                   lvsat=0.028567+dlvsatp_25ud18
+ a0=3.8100008              la0=-9.089502e-007+dla0p_25ud18
+ ags=2.3700013             lags=-3.2462501e-013      a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.14249991          lketa=3.2462477e-008      dwg=0
+ dwb=0                     pclm=0.7610004            lpclm=-9.7387504e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-009
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25ud18          cgdo=cgop_25ud18          cgbo=0
+ cgdl=cglp_25ud18          cgsl=cglp_25ud18          clc=1e-007
+ cle=0.6                   cf=cfp_25ud18             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.33800001           kt1l=0
+ kt2=-0.034                ute=-1                    ua1=2.95e-009
+ ub1=-5.32e-018            uc1=-4.000047e-012        luc1=1.16865e-023
+ prt=0                     at=24000.002              fnoimod=1
+ tnoimod=0                 noia=noiap_25ud18         noib=noibp_25ud18
+ noic=noicp_25ud18         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25ud18            cjd=cjp_25ud18            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25ud18        cjswd=cjswp_25ud18        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-6.56e-09
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   wa0=0+dwa0p_25ud18
+ pa0=0+dpa0p_25ud18        wvth0=0+dwvthp_25ud18     pvth0=0+dpvthp_25ud18
+ wu0=0+dwu0p_25ud18        pu0=0+dpu0p_25ud18        wcit=0+dwcitp_25ud18
+ pcit=0+dpcitp_25ud18      wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        wvsat=0+dwvsatp_25ud18
+ pvsat=0+dpvsatp_25ud18    peta0=0+dpeta0p_25ud18    lkt1=0+dlkt1p_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
 
     7: type=p 
+ lmin=1e-005-dxlp_25ud18   lmax=0.000901             wmin=1e-006-dxwp_25ud18
+ wmax=1e-005-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63143426+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            wvth0=-1.4667705e-008+dwvthp_25ud18
+ k1=0.7812                 k2=-0.082798282+dk2_25ud18
+ wk2=4.5630905e-009        k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=5e-006+dcitp_25ud18   voff=-0.15000001
+ nfactor=0.63002+dnfactorp_25ud18                    eta0=0.39239156
+ weta0=7.6137704e-008      etab=-0.0077622222        wetab=-2.2393442e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.014247762+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              wu0=2.2393442e-011+dwu0p_25ud18
+ ua=2.0577557e-009         wua=-6.0798196e-016       ub=1.6449524e-019
+ wub=3.120459e-025         uc=1.5486833e-013         wuc=-1.1806942e-017
+ vsat=110000+dvsatp_25ud18 a0=1.1000002              ags=0.28466888
+ kvsat=1                   wags=-3.1910655e-009      a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.022152944         wketa=1.0636885e-008      dwg=0
+ dwb=0                     pclm=0.27279722           wpclm=-2.7991803e-008
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-009
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25ud18          cgdo=cgop_25ud18          cgbo=0
+ cgdl=cglp_25ud18          cgsl=cglp_25ud18          clc=1e-007
+ cle=0.6                   cf=cfp_25ud18             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.30317              kt1l=0
+ kt2=-0.028353891          wkt2=-1.6472616e-008      ute=-1
+ ua1=2.76e-009             ub1=-4.0448256e-018       wub1=5.4863933e-025
+ uc1=-1.2984623e-010       wuc1=9.8531153e-017       prt=0
+ at=200000.05              fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   la0=0+dla0p_25ud18        wa0=0+dwa0p_25ud18
+ pa0=0+dpa0p_25ud18        lvth0=0+dlvthp_25ud18     pvth0=0+dpvthp_25ud18
+ lu0=0+dlu0p_25ud18        pu0=0+dpu0p_25ud18        lcit=0+dlcitp_25ud18
+ wcit=0+dwcitp_25ud18      pcit=0+dpcitp_25ud18      lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    lkt1=0+dlkt1p_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
 
     8: type=p 
+ lmin=1.2e-006-dxlp_25ud18 lmax=1e-005-dxlp_25ud18   wmin=1e-006-dxwp_25ud18
+ wmax=1e-005-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63295251+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=1.5159799e-008+dlvthp_25ud18
+ wvth0=-1.5240646e-008+dwvthp_25ud18                 pvth0=5.720819e-015+dpvthp_25ud18
+ k1=0.7812                 k2=-0.082869907+dk2_25ud18
+ lk2=7.1517316e-010        wk2=4.7160852e-009        pk2=-1.5276529e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=5e-006+dcitp_25ud18   voff=-0.15516179          lvoff=5.1540334e-008
+ wvoff=-2.2616104e-010     pvoff=2.258218e-015       nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.39239156           weta0=7.6137704e-008      etab=-0.0077622222
+ wetab=-2.2393442e-008     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.014241773+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=5.9800543e-011+dlu0p_25ud18
+ wu0=2.8424403e-011+dwu0p_25ud18                     pu0=-6.0219147e-017+dpu0p_25ud18
+ ua=2.1129273e-009         lua=-5.5088868e-016       wua=-6.170284e-016
+ pua=9.0328721e-023        ub=9.83936e-020           lub=6.6002486e-025
+ wub=3.2030138e-025        pub=-8.2430979e-032       uc=-8.158942e-012
+ luc=8.3013396e-017        wuc=-1.1221185e-017       puc=-5.8487847e-024
+ vsat=110000+dvsatp_25ud18 a0=1.1272334              la0=-2.7192302e-007+dla0p_25ud18
+ kvsat=1                   wa0=-3.0154821e-009+dwa0p_25ud18
+ pa0=3.0109589e-014+dpa0p_25ud18                     ags=0.2624499
+ lags=2.2185656e-007       wags=-5.0078926e-009      pags=1.8141018e-014
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.017971017         lketa=-4.1756547e-008
+ wketa=1.0615777e-008      pketa=2.1076702e-016      dwg=0
+ dwb=0                     pclm=0.25689003           lpclm=1.5883328e-007
+ wpclm=-3.5228956e-008     ppclm=7.2262976e-014      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.2995571            lkt1=-3.6074841e-008+dlkt1p_25ud18
+ kt1l=0                    kt2=-0.028435252          lkt2=8.1238981e-010
+ wkt2=-1.5658436e-008      pkt2=-8.1295849e-015      ute=-1
+ ua1=2.76e-009             ub1=-3.9599903e-018       lub1=-8.4707974e-025
+ wub1=5.4863933e-025       pub1=-2.1825274e-046      uc1=-1.3026811e-010
+ luc1=4.2123918e-018       wuc1=1.0275283e-016       puc1=-4.2153404e-023
+ prt=0                     at=201884.34              lat=-0.018814582
+ wat=0.0013569663          pat=-1.3549308e-008       fnoimod=1
+ tnoimod=0                 noia=noiap_25ud18         noib=noibp_25ud18
+ noic=noicp_25ud18         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25ud18            cjd=cjp_25ud18            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25ud18        cjswd=cjswp_25ud18        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-6.56e-09
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lcit=0+dlcitp_25ud18
+ wcit=0+dwcitp_25ud18      pcit=0+dpcitp_25ud18      lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     9: type=p 
+ lmin=7e-007-dxlp_25ud18   lmax=1.2e-006-dxlp_25ud18 wmin=1e-006-dxwp_25ud18
+ wmax=1e-005-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.62725748+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=8.4111864e-009+dlvthp_25ud18
+ wvth0=-5.1888204e-009+dwvthp_25ud18                 pvth0=-6.1905943e-015+dpvthp_25ud18
+ k1=0.7812                 k2=-0.086622656+dk2_25ud18
+ lk2=5.1621814e-009        wk2=6.8892561e-009        pk2=-4.1028604e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00023765974+dcitp_25ud18                     lcit=2.875518e-010+dlcitp_25ud18
+ wcit=2.4435837e-010+dwcitp_25ud18                   pcit=-2.8956467e-016+dpcitp_25ud18
+ voff=-0.13223413          lvoff=2.437106e-008       wvoff=7.6005582e-009
+ pvoff=-7.0164443e-015     nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.39239156           weta0=7.6137704e-008      etab=-0.0077622222
+ wetab=-2.2393442e-008     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.012521968+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=2.0977698e-009+dlu0p_25ud18
+ wu0=-1.2977e-010+dwu0p_25ud18                       pu0=1.2724122e-016+dpu0p_25ud18
+ ua=1.478354e-009          lua=2.010807e-016         wua=-5.9755781e-016
+ pua=6.7256073e-023        ub=4.2353689e-019         lub=2.7473006e-025
+ wub=2.9709231e-025        pub=-5.4928234e-032       uc=-8.7644947e-012
+ luc=8.3730976e-017        wuc=-4.4221465e-018       puc=-1.3905646e-023
+ vsat=110000+dvsatp_25ud18 a0=0.86289442             la0=4.1318618e-008+dla0p_25ud18
+ kvsat=1                   wa0=2.8001514e-007+dwa0p_25ud18
+ pa0=-3.0528169e-013+dpa0p_25ud18                    ags=0.19187643
+ lags=3.0548612e-007       wags=1.8128428e-008       pags=-9.2755213e-015
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.027155712         lketa=-3.0872683e-008
+ wketa=1.0701602e-008      pketa=1.090639e-016       dwg=0
+ dwb=0                     pclm=0.28259594           lpclm=1.2837178e-007
+ wpclm=6.1033327e-008      ppclm=-4.1807829e-014     pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.33                 kt1l=0                    kt2=-0.027119371
+ lkt2=-7.4692842e-010      wkt2=-2.8826451e-008      pkt2=7.4745127e-015
+ ute=-1                    ua1=2.76e-009             ub1=-4.6640954e-018
+ lub1=-1.2715221e-026      wub1=4.4126278e-025       pub1=1.2724122e-031
+ uc1=-1.2855281e-010       luc1=2.1797699e-018       wuc1=8.5587754e-017
+ puc1=-2.1812795e-023      prt=0                     at=284330.98
+ lat=-0.11651386           wat=0.006796402           pat=-1.999504e-008
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lnfactor=0+dlnfactorp_25ud18                        wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        lvsat=0+dlvsatp_25ud18
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    leta0=0+dleta0p_25ud18
+ peta0=0+dpeta0p_25ud18    lkt1=0+dlkt1p_25ud18      saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     10: type=p 
+ lmin=3.8e-007-dxlp_25ud18 lmax=7e-007-dxlp_25ud18   wmin=1e-006-dxwp_25ud18
+ wmax=1e-005-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63687343+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=1.499811e-008+dlvthp_25ud18
+ wvth0=-2.4548517e-008+dwvthp_25ud18                 pvth0=7.0707978e-015+dpvthp_25ud18
+ k1=0.7812                 k2=-0.070814345+dk2_25ud18
+ lk2=-5.666512e-009        wk2=-1.1731268e-008       pk2=8.6521989e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-8.069374e-005+dcitp_25ud18                     lcit=1.8003008e-010+dlcitp_25ud18
+ wcit=-8.0939429e-010+dwcitp_25ud18                  pcit=4.322559e-016+dpcitp_25ud18
+ voff=-0.15687837          lvoff=4.1252367e-008      wvoff=-6.3205491e-009
+ pvoff=2.5195142e-015      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.39239156           weta0=7.6137704e-008      etab=-0.0077622222
+ wetab=-2.2393442e-008     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.017107818+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=-1.0435375e-009+dlu0p_25ud18
+ wu0=-7.8726945e-012+dwu0p_25ud18                    pu0=4.3741566e-017+dpu0p_25ud18
+ ua=2.6580301e-009         lua=-6.0699744e-016       wua=-5.1968007e-016
+ pua=1.3909818e-023        ub=-4.2391949e-020        lub=5.9389132e-025
+ wub=2.2127542e-025        pub=-2.993664e-033        uc=1.0231614e-010
+ luc=7.6407415e-018        wuc=-7.8387521e-018       puc=-1.1565271e-023
+ vsat=110000+dvsatp_25ud18 a0=1.1269911              la0=-1.3958757e-007+dla0p_25ud18
+ kvsat=1                   wa0=-5.3084129e-007+dwa0p_25ud18
+ pa0=2.5015496e-013+dpa0p_25ud18                     ags=0.055509926
+ lags=3.9889718e-007       wags=2.3672258e-007       pags=-1.5901252e-013
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.069239834         lketa=-2.0450595e-009
+ wketa=7.8084883e-009      pketa=2.0908468e-015      dwg=0
+ dwb=0                     pclm=0.30705568           lpclm=1.1161686e-007
+ wpclm=1.1685458e-007      ppclm=-8.0045385e-014     pdiblc1=0
+ pdiblc2=1.0002551e-005    lpdiblc2=-1.7476574e-015  wpdiblc2=-2.554252e-014
+ ppdiblc2=1.7496626e-020   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.29394346           lkt1=-2.4698728e-008+dlkt1p_25ud18
+ wkt1=-1.8390627e-008      pkt1=1.259758e-014        kt1l=0
+ kt2=-0.0085048726         lkt2=-1.349786e-008       wkt2=-3.247399e-008
+ pkt2=9.973077e-015        ute=-1                    ua1=2.76e-009
+ ub1=-4.5426131e-018       lub1=-9.5930616e-026      wub1=8.07602e-025
+ pub1=-1.2370115e-031      uc1=-2.2935104e-010       luc1=7.1226559e-017
+ wuc1=1.3548032e-016       puc1=-5.5989205e-023      prt=0
+ at=195341.74              lat=-0.055556226          wat=-0.012176421
+ pat=-6.9986557e-009       fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     11: type=p 
+ lmin=2.8e-007-dxlp_25ud18 lmax=3.8e-007-dxlp_25ud18 wmin=1e-006-dxwp_25ud18
+ wmax=1e-005-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.51953178+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-2.7831591e-008+dlvthp_25ud18
+ wvth0=-5.2749074e-008+dwvthp_25ud18                 pvth0=1.7364001e-014+dpvthp_25ud18
+ k1=0.7812                 k2=-0.031348028+dk2_25ud18
+ lk2=-2.0071717e-008       wk2=8.4236856e-009        pk2=1.2956407e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0015244856+dcitp_25ud18                       lcit=-4.0586038e-010+dlcitp_25ud18
+ wcit=9.157824e-010+dwcitp_25ud18                    pcit=-1.9743359e-016+dpcitp_25ud18
+ voff=0.022401486          lvoff=-2.4184781e-008     wvoff=-6.4219905e-008
+ pvoff=2.3652779e-014      nfactor=0.63002+dnfactorp_25ud18
+ eta0=-0.30800551          leta0=2.5564493e-007+dleta0p_25ud18
+ weta0=3.7581797e-007      peta0=-1.093833e-013+dpeta0p_25ud18
+ etab=-0.019529696         letab=4.295128e-009       wetab=-3.7229096e-008
+ petab=5.4150136e-015      ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.010944428+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.2060999e-009+dlu0p_25ud18
+ wu0=2.9592934e-010+dwu0p_25ud18                     pu0=-6.7146177e-017+dpu0p_25ud18
+ ua=8.9444711e-010         lua=3.671035e-017         wua=-8.8854265e-016
+ pua=1.4854466e-022        ub=-2.300535e-020         lub=5.8681521e-025
+ wub=9.5782351e-025        pub=-2.7183372e-031       uc=3.1736134e-010
+ luc=-7.0850755e-017       wuc=-1.4426417e-016       puc=3.8230005e-023
+ vsat=110000+dvsatp_25ud18 a0=1.8055231              la0=-3.8725178e-007+dla0p_25ud18
+ kvsat=1                   wa0=-3.855031e-007+dwa0p_25ud18
+ pa0=1.9710652e-013+dpa0p_25ud18                     ags=-2.3468771
+ lags=1.2757685e-006       wags=1.8553163e-006       pags=-7.4979923e-013
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.21869348          lketa=5.2505521e-008
+ wketa=3.4573804e-008      pketa=-7.6784935e-015     dwg=0
+ dwb=0                     pclm=0.23800278           lpclm=1.3682117e-007
+ wpclm=-5.51369e-007       ppclm=1.6385622e-013      pdiblc1=0
+ pdiblc2=9.9948008e-006    lpdiblc2=1.081278e-015    wpdiblc2=5.2064753e-014
+ ppdiblc2=-1.0830029e-020  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.42197489           lkt1=2.2032744e-008+dlkt1p_25ud18
+ wkt1=3.6774552e-008       pkt1=-7.5377107e-015      kt1l=0
+ kt2=-0.071770308          lkt2=9.5940238e-009       wkt2=-6.033913e-008
+ pkt2=2.0143853e-014       ute=-1                    ua1=2.3158011e-009
+ lua1=1.6213259e-016       wua1=-5.9342622e-016      pua1=2.1660057e-022
+ ub1=-3.4418439e-018       lub1=-4.9771136e-025      wub1=1.7107358e-024
+ pub1=-4.5334499e-031      uc1=-1.1426572e-010       luc1=2.9220414e-017
+ wuc1=-6.5388872e-017      puc1=1.7328052e-023       prt=0
+ at=87311.954              lat=-0.016125355          wat=-0.049153607
+ pat=6.4980171e-009        fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
 
     12: type=p 
+ lmin=2.6e-07              lmax=2.8e-007-dxlp_25ud18 wmin=1e-006-dxwp_25ud18
+ wmax=1e-005-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.78111691+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=4.1488467e-008+dlvthp_25ud18
+ wvth0=1.9670666e-007+dwvthp_25ud18                  pvth0=-4.8741768e-014+dpvthp_25ud18
+ k1=0.7812                 k2=0.029116042+dk2_25ud18 lk2=-3.6094696e-008
+ wk2=-1.2384705e-007       pk2=3.6347385e-014        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-7.0622123e-006+dcitp_25ud18
+ lcit=-2.0668625e-016+dlcitp_25ud18                  wcit=1.7074995e-010+dwcitp_25ud18
+ pcit=1.1994629e-023+dpcitp_25ud18                   voff=-0.083938932
+ lvoff=3.9954293e-009      wvoff=1.7591159e-007      pvoff=-3.9982066e-014
+ nfactor=-0.70463084+dnfactorp_25ud18                lnfactor=3.5368247e-007+dlnfactorp_25ud18
+ wnfactor=1.0972784e-006+dwnfactorp_25ud18           pnfactor=-2.9077878e-013+dpnfactorp_25ud18
+ eta0=-0.52744574          leta0=3.1379659e-007+dleta0p_25ud18
+ weta0=-7.8097278e-008     peta0=1.0904243e-014+dpeta0p_25ud18
+ etab=-0.0033216565        letab=-2.5266285e-015     wetab=-1.6795092e-008
+ petab=2.5443148e-021      ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.011409557+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.0828408e-009+dlu0p_25ud18
+ wu0=4.1573426e-009+dwu0p_25ud18                     pu0=-1.0904207e-015+dpu0p_25ud18
+ ua=1.0329755e-009         lua=3.3915377e-022        wua=-3.2799621e-016
+ pua=-1.4538943e-028       ub=2.1913917e-018         wub=-6.7964097e-026
+ uc=4.9999941e-011         luc=1.4437877e-023        wuc=5.9342621e-023
+ puc=-1.4538942e-029       vsat=-815.40556+dvsatp_25ud18
+ kvsat=1                   lvsat=0.029366083+dlvsatp_25ud18
+ wvsat=0.030175163+dwvsatp_25ud18                    pvsat=-7.9964183e-009+dpvsatp_25ud18
+ a0=3.4726559              la0=-8.2904195e-007+dla0p_25ud18
+ wa0=3.3758113e-006+dwa0p_25ud18                     pa0=-7.9964179e-013+dpa0p_25ud18
+ ags=2.4673447             lags=-3.2462501e-013      wags=-9.7411474e-007
+ pags=1.906774e-026        a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.15676575
+ lketa=3.6094671e-008      wketa=1.4275823e-007      pketa=-3.6347367e-014
+ dwg=0                     dwb=0                     pclm=0.75430949
+ lpclm=-1.0828408e-013     wpclm=6.6955947e-008      ppclm=1.0904207e-019
+ pdiblc1=0                 pdiblc2=9.9988811e-006    wpdiblc2=1.1196721e-014
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-009          cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25ud18          cgdo=cgop_25ud18
+ cgbo=0                    cgdl=cglp_25ud18          cgsl=cglp_25ud18
+ clc=1e-007                cle=0.6                   cf=cfp_25ud18
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.33883246
+ wkt1=8.3303605e-009       kt1l=0                    kt2=-0.035566443
+ lkt2=-3.6321941e-016      wkt2=1.5675396e-008       pkt2=3.6347361e-021
+ ute=-1                    ua1=2.9276222e-009        wua1=2.2393442e-016
+ ub1=-5.32e-018            uc1=-4.0000495e-012       luc1=1.2303973e-023
+ wuc1=2.499668e-023        puc1=-6.1790505e-030      prt=0
+ at=26461.559              lat=-3.268973e-010        wat=-0.0246328
+ pat=3.271262e-015         fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lkt1=0+dlkt1p_25ud18      saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     13: type=p 
+ lmin=1e-005-dxlp_25ud18   lmax=0.000901             wmin=6e-007-dxwp_25ud18
+ wmax=1e-006-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63370825+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            wvth0=-1.2377792e-008+dwvthp_25ud18
+ k1=0.7812                 k2=-0.083807352+dk2_25ud18
+ wk2=5.5792242e-009        k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=2.7283025e-006+dcitp_25ud18
+ wcit=2.2875994e-012+dwcitp_25ud18                   voff=-0.15000003
+ wvoff=1.5281225e-014      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.556015             weta0=-8.8631105e-008     etab=-0.0224125
+ wetab=-7.6406125e-009     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.01448245+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              wu0=-2.1393715e-010+dwu0p_25ud18
+ ua=1.912285e-009          wua=-4.61493e-016         ub=2.5675036e-019
+ wub=2.1914499e-025        uc=-1.5360715e-011        wuc=3.81725e-018
+ vsat=110000+dvsatp_25ud18 a0=1.1000005              wa0=-3.056245e-013+dwa0p_25ud18
+ kvsat=1                   ags=0.26890475            wags=1.2683417e-008
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.016063589         wketa=4.5049041e-009
+ dwg=0                     dwb=0                     pclm=0.2313425
+ wpclm=1.3753103e-008      pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-009          cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25ud18          cgdo=cgop_25ud18
+ cgbo=0                    cgdl=cglp_25ud18          cgsl=cglp_25ud18
+ clc=1e-007                cle=0.6                   cf=cfp_25ud18
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.31329133
+ wkt1=1.019218e-008        kt1l=0                    kt2=-0.04275746
+ wkt2=-1.9682218e-009      ute=-1                    ua1=2.76e-009
+ ub1=-3.7018275e-018       wub1=2.0324029e-025       uc1=-3.2000006e-011
+ wuc1=1.5281225e-024       prt=0                     at=200000.13
+ wat=-7.6406125e-008       fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   la0=0+dla0p_25ud18        pa0=0+dpa0p_25ud18
+ lvth0=0+dlvthp_25ud18     pvth0=0+dpvthp_25ud18     lu0=0+dlu0p_25ud18
+ pu0=0+dpu0p_25ud18        lcit=0+dlcitp_25ud18      pcit=0+dpcitp_25ud18
+ lnfactor=0+dlnfactorp_25ud18                        wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        lvsat=0+dlvsatp_25ud18
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    leta0=0+dleta0p_25ud18
+ peta0=0+dpeta0p_25ud18    lkt1=0+dlkt1p_25ud18      saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     14: type=p 
+ lmin=1.2e-006-dxlp_25ud18 lmax=1e-005-dxlp_25ud18   wmin=6e-007-dxwp_25ud18
+ wmax=1e-006-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63550938+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=1.798431e-008+dlvthp_25ud18
+ wvth0=-1.2665878e-008+dwvthp_25ud18                 pvth0=2.8765369e-015+dpvthp_25ud18
+ k1=0.7812                 k2=-0.083913235+dk2_25ud18
+ lk2=1.0572418e-009        wk2=5.766717e-009         pk2=-1.872116e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=2.4223978e-006+dcitp_25ud18                     lcit=3.0544586e-012+dlcitp_25ud18
+ wcit=2.5956454e-012+dwcitp_25ud18                   pcit=-3.0758398e-018+dpcitp_25ud18
+ voff=-0.1554477           lvoff=5.4394991e-008      wvoff=6.1750015e-011
+ pvoff=-6.1642132e-016     nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.556015             weta0=-8.8631105e-008     etab=-0.0224125
+ wetab=-7.6406125e-009     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.014502885+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=-2.0403865e-010+dlu0p_25ud18
+ wu0=-2.3451471e-010+dwu0p_25ud18                    pu0=2.0546692e-016+dpu0p_25ud18
+ ua=1.9712038e-009         lua=-5.8830415e-016       wua=-4.7431284e-016
+ pua=1.280061e-022         ub=1.9071776e-019         lub=6.593355e-025
+ wub=2.2733095e-025        pub=-8.1736797e-032       uc=-2.3913899e-011
+ luc=8.5403539e-017        wuc=4.6440561e-018        puc=-8.2556589e-024
+ vsat=110000+dvsatp_25ud18 a0=1.1242391              la0=-2.4202273e-007+dla0p_25ud18
+ kvsat=1                   wa0=-3.056245e-013+dwa0p_25ud18
+ pa0=3.8667671e-027+dpa0p_25ud18                     ags=0.24285855
+ lags=2.600713e-007        wags=1.4720595e-008       pags=-2.0341225e-014
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.011585479         lketa=-4.4713926e-008
+ wketa=4.1855402e-009      pketa=3.1888481e-015      dwg=0
+ dwb=0                     pclm=0.20303766           lpclm=2.8262379e-007
+ wpclm=1.900038e-008       ppclm=-5.2394065e-014     pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.30942294           lkt1=-3.8625854e-008+dlkt1p_25ud18
+ wkt1=9.9349068e-009       pkt1=2.5688708e-015       kt1l=0
+ kt2=-0.042561598          lkt2=-1.9556786e-009      wkt2=-1.4332053e-009
+ pkt2=-5.34214e-015        ute=-1                    ua1=2.76e-009
+ ub1=-3.6012577e-018       lub1=-1.0041895e-024      wub1=1.8739557e-025
+ pub1=1.5820953e-031       uc1=-2.8229551e-011       luc1=-3.7647992e-017
+ wuc1=1.3223469e-024       puc1=2.0546692e-030       prt=0
+ at=201597.18              lat=-0.015946612          wat=0.0016461283
+ pat=-1.6437354e-008       fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     15: type=p 
+ lmin=7e-007-dxlp_25ud18   lmax=1.2e-006-dxlp_25ud18 wmin=6e-007-dxwp_25ud18
+ wmax=1e-006-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.6213996+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=1.2642224e-009+dlvthp_25ud18
+ wvth0=-1.1087702e-008+dwvthp_25ud18                 pvth0=1.0063985e-015+dpvthp_25ud18
+ k1=0.7812                 k2=-0.081830405+dk2_25ud18
+ lk2=-1.4109117e-009       wk2=2.0634593e-009        pk2=2.5162443e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=5.0000155e-006+dcitp_25ud18                     lcit=-1.8391659e-017+dlcitp_25ud18
+ wcit=-9.4208753e-018+dwcitp_25ud18                  pcit=1.1163737e-023+dpcitp_25ud18
+ voff=-0.1222769           lvoff=1.5087594e-008      wvoff=-2.4263738e-009
+ pvoff=2.3320055e-015      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.556015             weta0=-8.8631105e-008     etab=-0.0224125
+ wetab=-7.6406125e-009     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.012931964+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.6575019e-009+dlu0p_25ud18
+ wu0=-5.426363e-010+dwu0p_25ud18                     pu0=5.7059101e-016+dpu0p_25ud18
+ ua=1.3312299e-009         lua=1.7006491e-016        wua=-4.4940387e-016
+ pua=9.848897e-023         ub=5.038742e-019          lub=2.8824513e-025
+ wub=2.1619264e-025        pub=-6.8537904e-032       uc=8.0693696e-012
+ luc=4.7503366e-017        wuc=-2.1373848e-017       puc=2.2575557e-023
+ vsat=110000+dvsatp_25ud18 a0=1.5001826              la0=-6.875157e-007+dla0p_25ud18
+ kvsat=1                   wa0=-3.6173403e-007+dwa0p_25ud18
+ pa0=4.2865446e-013+dpa0p_25ud18                     ags=0.1842465
+ lags=3.2952658e-007       wags=2.5811768e-008       pags=-3.3484265e-014
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.02921996          lketa=-2.3817067e-008
+ wketa=1.27803e-008        pketa=-6.9959419e-015     dwg=0
+ dwb=0                     pclm=0.40254684           lpclm=4.6205416e-008
+ wpclm=-5.975723e-008      ppclm=4.0933703e-014      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.35848408           lkt1=1.9511596e-008+dlkt1p_25ud18
+ wkt1=2.8683471e-008       pkt1=-1.9648177e-014      kt1l=0
+ kt2=-0.041762347          lkt2=-2.9027911e-009      wkt2=-1.4080974e-008
+ pkt2=9.6454664e-015       ute=-1                    ua1=3.0354226e-009
+ lua1=-3.2637579e-016      wua1=-2.7735057e-016      pua1=3.2866042e-022
+ ub1=-4.9811598e-018       lub1=6.3099443e-025       wub1=7.6054657e-025
+ pub1=-5.209744e-031       uc1=-8.5139513e-011       luc1=2.9790313e-017
+ wuc1=4.1870562e-017       puc1=-4.9616612e-023      prt=0
+ at=294904.47              lat=-0.12651575           wat=-0.0038511042
+ pat=-9.9231334e-009       fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     16: type=p 
+ lmin=3.8e-007-dxlp_25ud18 lmax=7e-007-dxlp_25ud18   wmin=6e-007-dxwp_25ud18
+ wmax=1e-006-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.68556018+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=4.5214218e-008+dlvthp_25ud18
+ wvth0=2.4479044e-008+dwvthp_25ud18                  pvth0=-2.3356823e-014+dpvthp_25ud18
+ k1=0.7812                 k2=-0.092633649+dk2_25ud18
+ lk2=5.9893103e-009        wk2=1.0240771e-008        pk2=-3.0852141e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0010061471+dcitp_25ud18                      lcit=6.9263573e-010+dlcitp_25ud18
+ wcit=1.2253721e-010+dwcitp_25ud18                   pcit=-8.3937984e-017+dpcitp_25ud18
+ voff=-0.19417461          lvoff=6.4337524e-008      wvoff=3.1236756e-008
+ pvoff=-2.0727239e-014     nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.556015             weta0=-8.8631105e-008     etab=-0.0224125
+ wetab=-7.6406125e-009     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.020204236+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=-3.3240042e-009+dlu0p_25ud18
+ wu0=-3.1259656e-009+dwu0p_25ud18                    pu0=2.3401716e-015+dpu0p_25ud18
+ ua=3.4743079e-009         lua=-1.2979435e-015       wua=-1.3416719e-015
+ pua=7.0969254e-022        ub=-4.5604259e-019        lub=9.4578812e-025
+ wub=6.3782162e-025        pub=-3.5735375e-031       uc=1.1906653e-010
+ luc=-2.8529688e-017       wuc=-2.4706395e-017       puc=2.4858352e-023
+ vsat=110000+dvsatp_25ud18 a0=-0.18593706            la0=4.6747625e-007+dla0p_25ud18
+ kvsat=1                   wa0=7.9127731e-007+dwa0p_25ud18
+ pa0=-3.6115831e-013+dpa0p_25ud18                    ags=0.47416524
+ lags=1.3093224e-007       wags=-1.8486333e-007      pags=1.1082817e-013
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.036825303         lketa=-1.8607406e-008
+ wketa=-2.4832944e-008     pketa=1.876913e-014       dwg=0
+ dwb=0                     pclm=0.72441347           lpclm=-1.7427322e-007
+ wpclm=-3.0342472e-007     ppclm=2.0784593e-013      pdiblc1=0
+ pdiblc2=9.9598756e-006    lpdiblc2=2.7485184e-014   wpdiblc2=1.743189e-014
+ ppdiblc2=-1.1940845e-020  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.31220625           lkt1=-1.2188719e-008+dlkt1p_25ud18
+ kt1l=0                    kt2=-0.036252786          lkt2=-6.6768407e-009
+ wkt2=-4.5318416e-009      pkt2=3.1043104e-015       ute=-1
+ ua1=2.6585229e-009        lua1=-6.8199476e-017      wua1=1.0218746e-016
+ pua1=6.8676872e-023       ub1=-3.740625e-018        lub1=-2.1877188e-025
+ uc1=4.8045879e-011        luc1=-6.144168e-017       wuc1=-1.4385838e-016
+ puc1=7.7607712e-023       prt=0                     at=222230.64
+ lat=-0.076734175          wat=-0.039253546          pat=1.4327539e-008
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lnfactor=0+dlnfactorp_25ud18                        wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        lvsat=0+dlvsatp_25ud18
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    leta0=0+dleta0p_25ud18
+ peta0=0+dpeta0p_25ud18    saref=4.6e-7              sbref=4.6e-7
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=5.0e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=-0.57e-2
+ pkvth0we=-0.0e-17         wkvth0we=-2.2e-10         lkvth0we=-2.48e-9
+ ku0we=-0.0150             pku0we=-0e-17             wku0we=-1.2e-9
+ lku0we=-1.0e-10           k2we=0.0125               pk2we=-6e-16
+ lk2we=-6e-10              wk2we=-0.1e-9             minr=1e-3
 
 
     17: type=p 
+ lmin=2.8e-007-dxlp_25ud18 lmax=3.8e-007-dxlp_25ud18 wmin=6e-007-dxwp_25ud18
+ wmax=1e-006-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.47747622+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-3.0736427e-008+dlvthp_25ud18
+ wvth0=-9.5099023e-008+dwvthp_25ud18                 pvth0=2.0289172e-014+dpvthp_25ud18
+ k1=0.7812                 k2=0.0079225332+dk2_25ud18
+ lk2=-3.0713696e-008       wk2=-3.112177e-008        pk2=1.2012113e-014
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0029740973+dcitp_25ud18                       lcit=-7.6015345e-010+dlcitp_25ud18
+ wcit=-5.4397652e-010+dwcitp_25ud18                  pcit=1.5933953e-016+dpcitp_25ud18
+ voff=0.036632331          lvoff=-1.9907008e-008     wvoff=-7.8550365e-008
+ pvoff=1.9345061e-014      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.26581349           leta0=1.0592355e-007+dleta0p_25ud18
+ weta0=-2.0201775e-007     peta0=4.1386127e-014+dpeta0p_25ud18
+ etab=-0.089126238         letab=2.4350514e-008      wetab=3.2854622e-008
+ petab=-1.478076e-014      ud=0                      lud=0
+ wud=0                     pud=0                     u0=-0.0017480098+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=4.6885654e-009+dlu0p_25ud18
+ wu0=1.3077214e-008+dwu0p_25ud18                     pu0=-3.573989e-015+dpu0p_25ud18
+ ua=-2.4049188e-009        lua=8.4797423e-016        wua=2.4339189e-015
+ pua=-6.6839807e-022       ub=6.9356968e-019         lub=5.2617965e-025
+ wub=2.3623246e-025        pub=-2.1077371e-031       uc=-3.9503268e-011
+ luc=2.9348288e-017        wuc=2.1509849e-016        puc=-6.2670431e-023
+ vsat=110000+dvsatp_25ud18 a0=0.9346789              la0=5.8451423e-008+dla0p_25ud18
+ kvsat=1                   wa0=4.9143703e-007+dwa0p_25ud18
+ pa0=-2.517166e-013+dpa0p_25ud18                     ags=-0.53283762
+ lags=4.9848829e-007       wags=2.8578541e-008       pags=3.2921892e-014
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.24052271          lketa=5.5742147e-008
+ wketa=5.6555841e-008      pketa=-1.0937776e-014     dwg=0
+ dwb=0                     pclm=-0.85447445          lpclm=4.0202087e-007
+ wpclm=5.4875558e-007      ppclm=-1.0319988e-013     pdiblc1=0
+ pdiblc2=1.0101898e-005    lpdiblc2=-2.4352954e-014  wpdiblc2=-5.5782049e-014
+ ppdiblc2=1.4782243e-020   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.37644805           lkt1=1.1259539e-008+dlkt1p_25ud18
+ wkt1=-9.0709757e-009      pkt1=3.3109061e-015       kt1l=0
+ kt2=-0.17021934           lkt2=4.2220952e-008       wkt2=3.8799047e-008
+ pkt2=-1.2711464e-014      ute=-1                    ua1=4.7143645e-010
+ lua1=7.3008707e-016       wua1=1.263849e-015        pua1=-3.5532959e-022
+ ub1=-1.743e-018           lub1=-9.47905e-025        uc1=-4.3247079e-010
+ luc1=1.139469e-016        wuc1=2.5504364e-016       puc1=-6.7991524e-023
+ prt=0                     at=38500.076              lat=-0.0096725193
+ wat=-4.5744347e-008       pat=1.1676804e-014        fnoimod=1
+ tnoimod=0                 noia=noiap_25ud18         noib=noibp_25ud18
+ noic=noicp_25ud18         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25ud18            cjd=cjp_25ud18            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25ud18        cjswd=cjswp_25ud18        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-6.56e-09
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
 
     18: type=p 
+ lmin=2.6e-07              lmax=2.8e-007-dxlp_25ud18 wmin=6e-007-dxwp_25ud18
+ wmax=1e-006-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.50918599+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-2.2333339e-008+dlvthp_25ud18
+ wvth0=-7.7127773e-008+dwvthp_25ud18                 pvth0=1.5526791e-014+dpvthp_25ud18
+ k1=0.7812                 k2=-0.2009252+dk2_25ud18  lk2=2.4630953e-008
+ wk2=1.0780448e-007        pk2=-2.4803343e-014       k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00010559294+dcitp_25ud18
+ lcit=1.9931975e-016+dlcitp_25ud18                   wcit=5.7306214e-011+dwcitp_25ud18
+ pcit=-3.968534e-022+dpcitp_25ud18                   voff=0.11485071
+ lvoff=-4.0634877e-008     wvoff=-2.4269581e-008     pvoff=4.9606528e-015
+ nfactor=0.83302375+dnfactorp_25ud18                 lnfactor=-5.3795994e-008+dlnfactorp_25ud18
+ wnfactor=-4.5113978e-007+dwnfactorp_25ud18          pnfactor=1.1955204e-013+dpnfactorp_25ud18
+ eta0=-1.1022852           leta0=4.6846972e-007+dleta0p_25ud18
+ weta0=5.007661e-007       peta0=-1.448516e-013+dpeta0p_25ud18
+ etab=0.0027624397         letab=1.4778554e-014      wetab=-2.2921777e-008
+ petab=-1.4882004e-020     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.052844581+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=-9.7784711e-009+dlu0p_25ud18
+ wu0=-3.7567727e-008+dwu0p_25ud18                    pu0=9.8469204e-015+dpu0p_25ud18
+ ua=3.3301678e-009         lua=-6.7182372e-016       wua=-2.6412689e-015
+ pua=6.7652668e-022        ub=2.0216381e-017         lub=-4.6473653e-024
+ wub=-1.8219128e-023       pub=4.6798969e-030        uc=7.1244821e-011
+ luc=4.4335658e-023        wuc=-2.1393534e-017       puc=-4.4646008e-029
+ vsat=29150+dvsatp_25ud18  lvsat=0.02142525+dlvsatp_25ud18
+ kvsat=1                   a0=14.716007              la0=-3.5936004e-006+dla0p_25ud18
+ wa0=-7.9462428e-006+dwa0p_25ud18                    pa0=1.9842686e-012+dpa0p_25ud18
+ ags=1.3482533             lags=-8.1724331e-013      wags=1.5281023e-007
+ pags=4.9606675e-019       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.030174567
+ lketa=-1.1078883e-013     wketa=1.5280915e-008      pketa=7.8874617e-020
+ dwg=0                     dwb=0                     pclm=-1.0571164
+ lpclm=4.5572097e-007      wpclm=1.8910618e-006      ppclm=-4.5891102e-013
+ pdiblc1=0                 pdiblc2=1.001e-005        pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-009
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25ud18          cgdo=cgop_25ud18          cgbo=0
+ cgdl=cglp_25ud18          cgsl=cglp_25ud18          clc=1e-007
+ cle=0.6                   cf=cfp_25ud18             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.33395923           wkt1=3.4230097e-009
+ kt1l=0                    kt2=-0.010895025          lkt2=8.1724355e-015
+ wkt2=-9.1687224e-009      pkt2=-4.9606665e-021      ute=-1
+ ua1=3.226482e-009         wua1=-7.7017374e-017      ub1=-5.32e-018
+ uc1=-2.4825462e-012       luc1=1.9468573e-023       wuc1=-1.5281008e-018
+ puc1=-1.3393803e-029      prt=0                     at=1999.9693
+ lat=8.8330464e-009        wat=2.0782466e-008        pat=-5.9528012e-015
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    lkt1=0+dlkt1p_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
 
     19: type=p 
+ lmin=1e-005-dxlp_25ud18   lmax=0.000901             wmin=4e-07
+ wmax=6e-007-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.6319185+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            wvth0=-1.3464171e-008+dwvthp_25ud18
+ k1=0.7812                 k2=-0.085679553+dk2_25ud18
+ wk2=6.7156503e-009        k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00086225061+dcitp_25ud18
+ wcit=5.273298e-010+dwcitp_25ud18                    voff=-0.15
+ nfactor=0.63002+dnfactorp_25ud18                    eta0=0.4507
+ weta0=-2.47049e-008       etab=-0.035               ud=0
+ lud=0                     wud=0                     pud=0
+ u0=0.0141707+du0p_25ud18  wu0=-2.47049e-011+dwu0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              ua=1.678658e-009          wua=-3.1968142e-016
+ ub=4.3173214e-019         wub=1.1293105e-025        uc=-2.475575e-011
+ wuc=9.5200359e-018        vsat=110000+dvsatp_25ud18 a0=1.195645
+ wa0=-5.8056515e-008+dwa0p_25ud18                    kvsat=1
+ ags=0.2898                a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.013511757
+ wketa=2.9559419e-009      dwg=0                     dwb=0
+ pclm=0.22958              wpclm=1.482294e-008       pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.32319445           wkt1=1.6203376e-008       kt1l=0
+ kt2=-0.046                ute=-1                    ua1=2.7599996e-009
+ wua1=2.47049e-022         ub1=-3.5588598e-018       wub1=1.164589e-025
+ uc1=-3.2000005e-011       wuc1=1.235245e-024        prt=0
+ at=200000                 fnoimod=1                 tnoimod=0
+ noia=noiap_25ud18         noib=noibp_25ud18         noic=noicp_25ud18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25ud18
+ cjd=cjp_25ud18            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25ud18
+ cjswd=cjswp_25ud18        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25ud18
+ cjswgd=cjswgp_25ud18      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   la0=0+dla0p_25ud18        pa0=0+dpa0p_25ud18
+ lvth0=0+dlvthp_25ud18     pvth0=0+dpvthp_25ud18     lu0=0+dlu0p_25ud18
+ pu0=0+dpu0p_25ud18        lcit=0+dlcitp_25ud18      pcit=0+dpcitp_25ud18
+ lnfactor=0+dlnfactorp_25ud18                        wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        lvsat=0+dlvsatp_25ud18
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    leta0=0+dleta0p_25ud18
+ peta0=0+dpeta0p_25ud18    lkt1=0+dlkt1p_25ud18      saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     20: type=p 
+ lmin=1.2e-006-dxlp_25ud18 lmax=1e-005-dxlp_25ud18   wmin=4e-07
+ wmax=6e-007-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.6338106+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=1.8892567e-008+dlvthp_25ud18
+ wvth0=-1.3697042e-008+dwvthp_25ud18                 pvth0=2.3252245e-015+dpvthp_25ud18
+ k1=0.7812                 k2=-0.085460584+dk2_25ud18
+ lk2=-2.1864048e-009       wk2=6.705958e-009         pk2=9.6777504e-017
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00097903379+dcitp_25ud18                     lcit=1.1660801e-009+dlcitp_25ud18
+ wcit=5.9833955e-010+dwcitp_25ud18                   pcit=-7.0903239e-016+dpcitp_25ud18
+ voff=-0.15493492          lvoff=4.9275167e-008      wvoff=-2.4950545e-010
+ pvoff=2.491312e-015       nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.4507               weta0=-2.47049e-008       etab=-0.035
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.014154494+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.6181912e-010+dlu0p_25ud18
+ wu0=-2.304153e-011+dwu0p_25ud18                     pu0=-1.6608746e-017+dpu0p_25ud18
+ ua=1.7235268e-009         lua=-4.4801469e-016       wua=-3.239729e-016
+ pua=4.2850399e-023        ub=3.7276656e-019         lub=5.8877133e-025
+ wub=1.1682733e-025        pub=-3.8904344e-032       uc=-3.5278213e-011
+ luc=1.0506679e-016        wuc=1.1542195e-017        puc=-2.0191255e-023
+ vsat=110000+dvsatp_25ud18 a0=1.2327631              la0=-3.7062398e-007+dla0p_25ud18
+ kvsat=1                   wa0=-6.5874338e-008+dwa0p_25ud18
+ pa0=7.8060958e-014+dpa0p_25ud18                     ags=0.26620564
+ lags=2.3558968e-007       wags=5.48912e-010         pags=-5.4808863e-015
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.0089796578        lketa=-4.5253008e-008
+ wketa=2.6038066e-009      pketa=3.5160708e-015      dwg=0
+ dwb=0                     pclm=0.20942652           lpclm=2.0123253e-007
+ wpclm=1.5122347e-008      ppclm=-2.9895743e-015     pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.32334453           lkt1=1.4984624e-009+dlkt1p_25ud18
+ wkt1=1.8385308e-008       pkt1=-2.1786589e-014      kt1l=0
+ kt2=-0.044922727          lkt2=-1.0756568e-008      ute=-1
+ ua1=2.7902526e-009        lua1=-3.020767e-016       wua1=-1.8363354e-017
+ pua1=1.8336056e-022       ub1=-3.510229e-018        lub1=-4.8557865e-025
+ wub1=1.3214115e-025       pub1=-1.5658726e-031      uc1=-2.8229551e-011
+ luc1=-3.7647986e-017      wuc1=1.401582e-024        puc1=-1.6608747e-030
+ prt=0                     at=202116.84              lat=-0.021136657
+ wat=0.0013306958          pat=-1.3286997e-008       fnoimod=1
+ tnoimod=0                 noia=noiap_25ud18         noib=noibp_25ud18
+ noic=noicp_25ud18         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25ud18            cjd=cjp_25ud18            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25ud18        cjswd=cjswp_25ud18        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-6.56e-09
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     21: type=p 
+ lmin=7e-007-dxlp_25ud18   lmax=1.2e-006-dxlp_25ud18 wmin=4e-07
+ wmax=6e-007-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.61535313+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-2.9795237e-009+dlvthp_25ud18
+ wvth0=-1.475791e-008+dwvthp_25ud18                  pvth0=3.5823524e-015+dpvthp_25ud18
+ k1=0.7812                 k2=-0.094121919+dk2_25ud18
+ lk2=8.0772764e-009        wk2=9.5244081e-009        pk2=-3.2430858e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=5.0000709e-006+dcitp_25ud18                     lcit=-4.8564695e-017+dlcitp_25ud18
+ wcit=-4.3034701e-017+dwcitp_25ud18                  pcit=2.947877e-023+dpcitp_25ud18
+ voff=-0.13320196          lvoff=2.352161e-008       wvoff=4.2051395e-009
+ pvoff=-2.7874423e-015     nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.4507               weta0=-2.47049e-008       etab=-0.035
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.01223845+du0p_25ud18 ku0=3.9e-9
+ pku0=2.0e-15              wku0=1.1e-06              lku0=+1.5e-8
+ lu0=2.4323307e-009+dlu0p_25ud18                     wu0=-1.2167333e-010+dwu0p_25ud18
+ pu0=1.0026993e-016+dpu0p_25ud18                     ua=1.2933495e-009
+ lua=6.1745453e-017        wua=-4.2641043e-016       pua=1.6423888e-022
+ ub=5.153517e-019          lub=4.1980794e-025        wub=2.092258e-025
+ pub=-1.4839653e-031       uc=-3.4006347e-011        luc=1.0355963e-016
+ wuc=4.1661121e-018        puc=-1.1450597e-023       vsat=110000+dvsatp_25ud18
+ a0=0.67363422             la0=2.9194371e-007+dla0p_25ud18
+ kvsat=1                   wa0=1.3998082e-007+dwa0p_25ud18
+ pa0=-1.658774e-013+dpa0p_25ud18                     ags=0.31315619
+ lags=1.7995328e-007       wags=-5.2436417e-008      pags=5.7306729e-014
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.014415603         lketa=-3.8811413e-008
+ wketa=3.794055e-009       pketa=2.1056264e-015      dwg=0
+ dwb=0                     pclm=0.19914691           lpclm=2.1341387e-007
+ wpclm=6.3706526e-008      ppclm=-6.0561827e-014     pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.3112296            lkt1=-1.2857724e-008+dlkt1p_25ud18
+ kt1l=0                    kt2=-0.064959996          lkt2=1.2987595e-008
+ wkt2=-1.6922853e-015      pkt2=2.0053585e-021       ute=-1
+ ua1=2.3041004e-009        lua1=2.740137e-016        wua1=1.6656201e-016
+ pua1=-3.5775997e-023      ub1=-3.7282e-018          lub1=-2.27283e-025
+ uc1=-1.6159999e-011       luc1=-5.1950405e-017      wuc1=-3.3845715e-024
+ puc1=4.0107169e-030       prt=0                     at=304839.97
+ lat=-0.14286357           wat=-0.0098819515         pat=-1.0026794e-014
+ fnoimod=1                 tnoimod=0                 noia=noiap_25ud18
+ noib=noibp_25ud18         noic=noicp_25ud18         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25ud18            cjd=cjp_25ud18
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25ud18        cjswd=cjswp_25ud18
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-6.56e-09             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lnfactor=0+dlnfactorp_25ud18                        wnfactor=0+dwnfactorp_25ud18
+ pnfactor=0+dpnfactorp_25ud18                        lvsat=0+dlvsatp_25ud18
+ wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18    leta0=0+dleta0p_25ud18
+ peta0=0+dpeta0p_25ud18    saref=4.6e-7              sbref=4.6e-7
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=5.0e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=-0.57e-2
+ pkvth0we=-0.0e-17         wkvth0we=-2.2e-10         lkvth0we=-2.48e-9
+ ku0we=-0.0150             pku0we=-0e-17             wku0we=-1.2e-9
+ lku0we=-1.0e-10           k2we=0.0125               pk2we=-6e-16
+ lk2we=-6e-10              wk2we=-0.1e-9             minr=1e-3
 
 
     22: type=p 
+ lmin=3.8e-007-dxlp_25ud18 lmax=7e-007-dxlp_25ud18   wmin=4e-07
+ wmax=6e-007-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.67470707+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=3.7677924e-008+dlvthp_25ud18
+ wvth0=1.7891206e-008+dwvthp_25ud18                  pvth0=-1.8782292e-014+dpvthp_25ud18
+ k1=0.7812                 k2=-0.087227646+dk2_25ud18
+ lk2=3.3546997e-009        wk2=6.9593273e-009        pk2=-1.4860055e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0016812125+dcitp_25ud18                      lcit=1.1550556e-009+dlcitp_25ud18
+ wcit=5.3230194e-010+dwcitp_25ud18                   pcit=-3.6462683e-016+dpcitp_25ud18
+ voff=-0.21282806          lvoff=7.8065485e-008      wvoff=4.2559401e-008
+ pvoff=-2.9060111e-014     nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.4507               weta0=-2.47049e-008       etab=-0.035
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.020282731+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=-3.0780015e-009+dlu0p_25ud18
+ wu0=-3.173612e-009+dwu0p_25ud18                     pu0=2.1908479e-015+dpu0p_25ud18
+ ua=2.7318185e-009         lua=-9.2360586e-016       wua=-8.9098078e-016
+ pua=4.8246957e-022        ub=3.0054969e-019         lub=5.6694731e-025
+ wub=1.7857011e-025        pub=-1.2739738e-031       uc=1.0544612e-010
+ luc=8.0346938e-018        wuc=-1.6438806e-017       puc=2.6637721e-024
+ vsat=110000+dvsatp_25ud18 a0=0.7461148              la0=2.4229451e-007+dla0p_25ud18
+ kvsat=1                   wa0=2.2552183e-007+dwa0p_25ud18
+ pa0=-2.24473e-013+dpa0p_25ud18                      ags=0.5758242
+ lags=2.5696319e-011       wags=-2.4657031e-007      pags=1.9028845e-013
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.0741025           lketa=2.0741113e-009
+ wketa=-2.2056858e-009     pketa=6.2154489e-015      dwg=0
+ dwb=0                     pclm=0.36110189           lpclm=1.0247471e-007
+ wpclm=-8.289459e-008      ppclm=3.9859938e-014      pdiblc1=0
+ pdiblc2=9.965382e-006     lpdiblc2=2.3713309e-014   wpdiblc2=1.4089513e-014
+ ppdiblc2=-9.6513166e-021  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.26729155           lkt1=-4.2955288e-008+dlkt1p_25ud18
+ wkt1=-2.7263222e-008      pkt1=1.8675307e-014       kt1l=0
+ kt2=-0.043718759          lkt2=-1.5626523e-009      wkt2=4.0531478e-015
+ pkt2=-1.9302633e-021      ute=-1                    ua1=2.8878986e-009
+ lua1=-1.2588806e-016      wua1=-3.7043594e-017      pua1=1.0369384e-022
+ ub1=-3.740625e-018        lub1=-2.1877188e-025      uc1=-1.8895306e-010
+ luc1=6.6412841e-017       wuc1=-2.3031529e-023      puc1=1.7468883e-029
+ prt=0                     at=173842.55              lat=-0.053130329
+ wat=-0.0098819734         pat=4.9221714e-015        fnoimod=1
+ tnoimod=0                 noia=noiap_25ud18         noib=noibp_25ud18
+ noic=noicp_25ud18         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25ud18            cjd=cjp_25ud18            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25ud18        cjswd=cjswp_25ud18        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-6.56e-09
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ leta0=0+dleta0p_25ud18    peta0=0+dpeta0p_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ minr=1e-3
 
 
     23: type=p 
+ lmin=2.8e-007-dxlp_25ud18 lmax=3.8e-007-dxlp_25ud18 wmin=4e-07
+ wmax=6e-007-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.46455041+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-3.9029259e-008+dlvthp_25ud18
+ wvth0=-1.0294499e-007+dwvthp_25ud18                 pvth0=2.532292e-014+dpvthp_25ud18
+ k1=0.7812                 k2=-0.007036023+dk2_25ud18
+ lk2=-2.5915243e-008       wk2=-2.2041926e-008       pk2=9.0994521e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0043448539+dcitp_25ud18                       lcit=-1.0444587e-009+dlcitp_25ud18
+ wcit=-1.3760258e-009+dwcitp_25ud18                  pcit=3.319128e-016+dpcitp_25ud18
+ voff=0.16560617           lvoff=-6.0063007e-008     wvoff=-1.5683749e-007
+ pvoff=4.3719752e-014      nfactor=0.63002+dnfactorp_25ud18
+ eta0=0.10851902           leta0=1.2489606e-007+dleta0p_25ud18
+ weta0=-1.0654001e-007     peta0=2.9869816e-014+dpeta0p_25ud18
+ etab=-0.035000024         letab=8.8068113e-015      wetab=9.820197e-015
+ petab=-3.5843721e-021     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.01513585+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=-1.19939e-009+dlu0p_25ud18
+ wu0=2.8287111e-009+dwu0p_25ud18                     pu0=1.9810887e-029+dpu0p_25ud18
+ ua=1.0338766e-009         lua=-3.0385707e-016       wua=3.4657001e-016
+ pua=3.0763531e-023        ub=1.6547885e-018         lub=7.2650148e-026
+ wub=-3.4722737e-025       pub=6.4518699e-032        uc=3.6982524e-010
+ luc=-8.8463684e-017       wuc=-3.3363913e-017       puc=8.8414358e-024
+ vsat=110000+dvsatp_25ud18 a0=5.4279819              la0=-1.466587e-006+dla0p_25ud18
+ kvsat=1                   wa0=-2.2359979e-006+dwa0p_25ud18
+ pa0=6.7398171e-013+dpa0p_25ud18                     ags=-3.3675323
+ lags=1.4393508e-006       wags=1.7492382e-006       pags=-5.3818165e-013
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.22030473          lketa=5.5437926e-008
+ wketa=4.4283528e-008      pketa=-1.0753114e-014     dwg=0
+ dwb=0                     pclm=-0.8580162           lpclm=5.4745281e-007
+ wpclm=5.5090542e-007      ppclm=-1.9147707e-013     pdiblc1=0
+ pdiblc2=1.0084278e-005    lpdiblc2=-1.9683538e-014  wpdiblc2=-4.5086443e-014
+ ppdiblc2=1.1947907e-020   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.49025136           lkt1=3.8425042e-008+dlkt1p_25ud18
+ wkt1=6.000763e-008        pkt1=-1.3178554e-014      kt1l=0
+ kt2=-0.11708548           lkt2=2.5216202e-008       wkt2=6.546794e-009
+ pkt2=-2.3895803e-015      ute=-1                    ua1=1.8790789e-009
+ lua1=2.4233114e-016       wua1=4.0941005e-016       pua1=-5.926174e-023
+ ub1=-1.743e-018           lub1=-9.47905e-025        uc1=-1.2300093e-011
+ luc1=1.9345084e-018       wuc1=2.4828425e-023       puc1=-9.2251633e-039
+ prt=0                     at=97921.991              lat=-0.025419327
+ wat=-0.036069148          pat=9.5583238e-009        fnoimod=1
+ tnoimod=0                 noia=noiap_25ud18         noib=noibp_25ud18
+ noic=noicp_25ud18         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25ud18            cjd=cjp_25ud18            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25ud18        cjswd=cjswp_25ud18        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-6.56e-09
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lnfactor=0+dlnfactorp_25ud18
+ wnfactor=0+dwnfactorp_25ud18                        pnfactor=0+dpnfactorp_25ud18
+ lvsat=0+dlvsatp_25ud18    wvsat=0+dwvsatp_25ud18    pvsat=0+dpvsatp_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
 
     24: type=p 
+ lmin=2.6e-07              lmax=2.8e-007-dxlp_25ud18 wmin=4e-07
+ wmax=6e-007-dxwp_25ud18   version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25ud18  permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_25ud18          toxm=5.9e-009             dtox=3.946e-010
+ epsrox=3.9                wint=0                    lint=0
+ ll=0                      wl=0                      lln=1
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.5e-08+dxlp_25ud18   xw=7e-09+dxwp_25ud18
+ dlc=0                     dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.49195738+dvthp_25ud18
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-3.176641e-008+dlvthp_25ud18
+ wvth0=-8.7585538e-008+dwvthp_25ud18                 pvth0=2.1252665e-014+dpvthp_25ud18
+ k1=0.7812                 k2=-0.043579652+dk2_25ud18
+ lk2=-1.6231181e-008       wk2=1.2295735e-008        pk2=-2.8069403e-020
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00040350563+dcitp_25ud18                      lcit=-1.3793317e-015+dlcitp_25ud18
+ wcit=-1.2352679e-010+dwcitp_25ud18                  pcit=5.6138798e-022+dpcitp_25ud18
+ voff=0.31074117           lvoff=-9.8523781e-008     wvoff=-1.4317509e-007
+ pvoff=4.0099217e-014      nfactor=-1.009563+dnfactorp_25ud18
+ lnfactor=4.344895e-007+dlnfactorp_25ud18            wnfactor=6.6731038e-007+dwnfactorp_25ud18
+ pnfactor=-1.7683725e-013+dpnfactorp_25ud18          eta0=0.32078627
+ leta0=6.8645236e-008+dleta0p_25ud18                 weta0=-3.6303831e-007
+ peta0=9.7841864e-014+dpeta0p_25ud18                 etab=-0.034999879
+ letab=-2.9557101e-014     wetab=-4.9100999e-014     petab=1.2029745e-020
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=-0.050052555+du0p_25ud18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.6075537e-008+dlu0p_25ud18
+ wu0=2.4890835e-008+dwu0p_25ud18                     pu0=-5.8464628e-015+dpu0p_25ud18
+ ua=-5.1831277e-009        lua=1.3436491e-015        wua=2.5263015e-015
+ pua=-5.4686531e-022       ub=-2.6885896e-017        lub=7.6359315e-024
+ wub=1.0371954e-023        pub=-2.7760643e-030       uc=3.6000224e-011
+ luc=-5.5640734e-023       wuc=-6.4232733e-023       puc=1.603966e-029
+ vsat=-25693.25+dvsatp_25ud18                        kvsat=1
+ lvsat=0.035958711+dlvsatp_25ud18                    wvsat=0.033289853+dwvsatp_25ud18
+ pvsat=-8.821811e-009+dpvsatp_25ud18                 a0=3.6115509
+ la0=-9.8523276e-007+dla0p_25ud18                    wa0=-1.2058383e-006+dwa0p_25ud18
+ pa0=4.009894e-013+dpa0p_25ud18                      ags=2.0639827
+ lags=-6.6061198e-013      wags=-2.816375e-007       pags=4.0099149e-019
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.011105168         lketa=4.1613679e-014
+ wketa=3.7057903e-009      pketa=-1.3633708e-020     dwg=0
+ dwb=0                     pclm=0.336066             lpclm=2.3102103e-007
+ wpclm=1.0454001e-006      ppclm=-3.2251815e-013     pdiblc1=0
+ pdiblc2=1.001e-005        pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-009          cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25ud18
+ cgdo=cgop_25ud18          cgbo=0                    cgdl=cglp_25ud18
+ cgsl=cglp_25ud18          clc=1e-007                cle=0.6
+ cf=cfp_25ud18             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.3452512            wkt1=1.0277238e-008       kt1l=0
+ kt2=-0.021929929          lkt2=-1.9818351e-014      wkt2=-2.4705354e-009
+ pkt2=1.2029742e-020       ute=-1                    ua1=2.793536e-009
+ wua1=1.8578085e-016       ub1=-5.32e-018            uc1=-5.000024e-012
+ luc1=-9.8637304e-024      wuc1=8.1834967e-024       puc1=4.4109058e-030
+ prt=0                     at=2000.0218              lat=-4.9375466e-009
+ wat=-1.1055443e-008       pat=2.4059483e-015        fnoimod=1
+ tnoimod=0                 noia=noiap_25ud18         noib=noibp_25ud18
+ noic=noicp_25ud18         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25ud18            cjd=cjp_25ud18            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25ud18        cjswd=cjswp_25ud18        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25ud18      cjswgd=cjswgp_25ud18      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-6.56e-09
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lkt1=0+dlkt1p_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             minr=1e-3
 
     } 
endsection mos_25ud18
 
// **************************************************************
//                                                              *
//                      3.3V IO DEVICE MODELS                   *
//                                                              *
// **************************************************************

section mos_25od33
 
// *********************************************************************************************
//                                                                            
//                   *
//                             OVERDRIVE 3.3V IO NMOS DEVICE MODELS           
//                   *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt nch_25od33_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=9.25e-008 xw= + 7e-09 
+ + dxwn_25od33 ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg / factor 
+ * (w / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) ps=4 
+ * dmcg / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf + xw 
+ / factor) nrs=dmcg / factor / (w / nf + xw / factor) sa=4.6e-007 / factor sb=4.6e-007 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parn1_25od33 temp2=parn2_25od33 fac1=0.308877 * temp1 * sigma 
+ + 0.951102 * temp2 * sigma fac2=0.308877 * temp1 * sigma - 0.951102 * temp2 * 
+ sigma lef=l * factor - 1.5e-08 wef=w / nf * factor + 7e-09 geo_fac=1 / sqrt(multi 
+ * nf * lef * wef * 1e12) vthmisn_25od33=0.00762502 * geo_fac * fac1 * mismatchflag 
+ dlmisn_25od33=0.00261377 * geo_fac * lef * fac2 * mismatchflag dwmisn_25od33= 
+ - 0.00261377 * geo_fac * wef * fac2 * mismatchflag toxmisn_25od33=0.00261377 * 
+ geo_fac * toxn_25od33 * fac2 * mismatchflag tnoiax=1.273e5 / (l * 1e6) + 8.395e6 
+ rnoiax=0.0353 / (l * 1e6) + 0.4701 
nch_25od33_mac ( n1 n2 n3 n4 ) nch_25od33 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs 
+ m=multi nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nch_25od33 bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln_25od33+dlmisn_25od33)             lmax=0.000901
+ wmin=1e-005-(dxwn_25od33+dwmisn_25od33)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.555+(dvthn_25od33+vthmisn_25od33)
+ k1=0.3969                 k2=0.0788+dk2n_25od33     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=0.015             lkvth0we=5.8299997e-009   wkvth0we=-3.0000899e-010
+ pkvth0we=-1.099397e-016   k2we=0.004                lk2we=-2.0738864e-017
+ wk2we=4.0000022e-010      pk2we=-1.9995539e-017     xj=8.1e-008
+ ngate=4.282e+020          ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.000143+dcitn_25od33 lcit=1.1340027e-018+dlcitn_25od33
+ wcit=2.0352184e-016+dwcitn_25od33                   pcit=-1.0217445e-021+dpcitn_25od33
+ voff=-0.106               nfactor=0.55              eta0=0.35079
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.002
+ lku0we=-2.0000039e-010    wku0we=-9.0000056e-010    pku0we=-4.9993956e-017
+ u0=0.0311+du0n_25od33     ua=-1.31e-009             ub=3.01e-018
+ uc=1.25e-010              vsat=98400                a0=1.72
+ la0=1.0210297e-012        wa0=1.1340304e-014        pa0=-1.0217444e-017
+ ags=0.45                  a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.058
+ dwg=0                     dwb=0                     pclm=0.52
+ pdiblc1=0                 pdiblc2=0.000935          lpdiblc2=-5.6700123e-018
+ wpdiblc2=-2.0805797e-016  ppdiblc2=5.1087223e-021   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25od33          cgdo=cgon_25od33          cgbo=0
+ cgdl=cgln_25od33          cgsl=cgln_25od33          clc=1e-007
+ cle=0.6                   cf=cfn_25od33             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.338
+ lkt1=-1.134003e-015       wkt1=-1.1340304e-015      pkt1=1.0217445e-018
+ kt1l=0                    kt2=-0.064155             ute=-1.65
+ ua1=1.0998e-009           ub1=-4.3212e-19           lub1=1.1340027e-32
+ wub1=1.0232794e-30        pub1=-1.0217445e-35       uc1=1.2194e-010
+ prt=0                     at=158518.8               lat=-1.1340027e-009
+ wat=-1.1340305e-009       pat=1.0217444e-012        fnoimod=1
+ tnoimod=1                 noia=noian_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25od33         rnoib=0
+ noic=noicn_25od33         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25od33            cjd=cjn_25od33            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25od33        cjswd=cjswn_25od33        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163u                     rshg=15.953                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=1e-006
+ kvth0=-3.5e-008           lkvth0=2.5e-006           wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-009             lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-008             lku0=7e-007               wku0=2.08e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-009           tku0=0
+ lvth0=0+dlvthn_25od33     wvth0=0+dwvthn_25od33     pvth0=0+dpvthn_25od33
+ lu0=0+dlu0n_25od33        wu0=0+dwu0n_25od33        pu0=0+dpu0n_25od33
+ lk2=0+dlk2n_25od33        wk2=0+dwk2n_25od33        pk2=0+dpk2n_25od33
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.2e-006-(dxln_25od33+dlmisn_25od33)           lmax=1e-005-(dxln_25od33+dlmisn_25od33)
+ wmin=1e-005-(dxwn_25od33+dwmisn_25od33)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.55634659+(dvthn_25od33+vthmisn_25od33)
+ lvth0=-1.344571e-008+dlvthn_25od33                  k1=0.3969
+ k2=0.079742614+dk2n_25od33                          lk2=-9.4119972e-009+dlk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8300005e-009
+ wkvth0we=-3.000023e-010   pkvth0we=-1.1000645e-016  k2we=0.004
+ lk2we=1.3264623e-017      wk2we=4.0000078e-010      pk2we=-2.0001172e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000143+dcitn_25od33
+ wcit=1.0119391e-016+dwcitn_25od33                   voff=-0.106
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-1.9999987e-010
+ wku0we=-8.9999979e-010    pku0we=-5.0001569e-017    u0=0.031073068+du0n_25od33
+ lu0=2.6891421e-010+dlu0n_25od33                     ua=-1.31e-009
+ ub=3.0073068e-018         lub=2.6891421e-026        uc=1.25e-010
+ vsat=98400                a0=1.7873297              la0=-6.7228551e-007
+ wa0=-1.0119391e-012       pa0=5.1885623e-027        ags=0.45
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.058               dwg=0
+ dwb=0                     pclm=0.52                 pdiblc1=0
+ pdiblc2=0.000935          wpdiblc2=3.0358172e-016   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25od33          cgdo=cgon_25od33          cgbo=0
+ cgdl=cgln_25od33          cgsl=cgln_25od33          clc=1e-007
+ cle=0.6                   cf=cfn_25od33             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.33665341
+ lkt1=-1.344571e-008       wkt1=1.1482059e-013       pkt1=-1.360624e-019
+ kt1l=0                    kt2=-0.064155             ute=-1.6769318
+ lute=2.6891421e-007       ua1=1.0998e-009           ub1=-3.6479043e-19
+ lub1=-6.7228541e-25       wub1=1.362668e-31         pub1=-1.3606239e-36
+ uc1=1.2194e-010           prt=0                     at=178717.66
+ lat=-0.20168565           wat=1.1059632e-007        pat=-9.3883052e-014
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    lcit=0+dlcitn_25od33      pcit=0+dpcitn_25od33
+ wvth0=0+dwvthn_25od33     pvth0=0+dpvthn_25od33     wu0=0+dwu0n_25od33
+ pu0=0+dpu0n_25od33        wk2=0+dwk2n_25od33        pk2=0+dpk2n_25od33
+ minr=1e-3
 
 
     3: type=n 
+ lmin=7e-007-(dxln_25od33+dlmisn_25od33)             lmax=1.2e-006-(dxln_25od33+dlmisn_25od33)
+ wmin=1e-005-(dxwn_25od33+dwmisn_25od33)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.53952+(dvthn_25od33+vthmisn_25od33)
+ lvth0=6.4938e-009+dlvthn_25od33                     k1=0.3969
+ k2=0.071526+dk2n_25od33   lk2=3.2469e-010+dlk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8299992e-009
+ wkvth0we=-3.0001818e-010  pkvth0we=-1.0998763e-016  k2we=0.004
+ lk2we=-4.5877313e-017     wk2we=3.9999827e-010      pk2we=-1.99982e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=9.505e-005+dcitn_25od33
+ lcit=5.682075e-011+dlcitn_25od33                    wcit=1.0119391e-016+dwcitn_25od33
+ pcit=3.3433569e-030+dpcitn_25od33                   voff=-0.11422
+ lvoff=9.7407e-009         nfactor=0.55              eta0=0.35079
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.0019999998
+ lku0we=-2.0000014e-010    wku0we=-9.0000284e-010    pku0we=-4.9997963e-017
+ u0=0.0313+du0n_25od33     ua=-1.31e-009             ub=2.9478e-018
+ lub=9.7407e-026           uc=1.1404e-010            luc=1.29876e-017
+ vsat=98400                a0=1.2337002              la0=-1.6234664e-008
+ wa0=-2.3982956e-012       pa0=1.6428325e-018        ags=0.5185
+ lags=-8.11725e-008        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.058
+ dwg=0                     dwb=0                     pclm=0.52
+ pdiblc1=0                 pdiblc2=0.001072          lpdiblc2=-1.62345e-010
+ wpdiblc2=7.1948867e-016   ppdiblc2=-4.9284974e-022  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25od33          cgdo=cgon_25od33          cgbo=0
+ cgdl=cgln_25od33          cgsl=cgln_25od33          clc=1e-007
+ cle=0.6                   cf=cfn_25od33             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.33841
+ lkt1=-1.136415e-008       kt1l=0                    kt2=-0.05940384
+ lkt2=-5.6301246e-009      wkt2=1.3863566e-014       pkt2=-1.6428325e-020
+ ute=-1.313                lute=-1.62345e-007        ua1=1.3184931e-009
+ lua1=-2.5915129e-016      wua1=2.772713e-022        pua1=-3.2856649e-028
+ ub1=-3.6099426e-019       lub1=-6.7678394e-025      wub1=-2.3982956e-030
+ pub1=1.6428325e-036       uc1=1.661636e-010         luc1=-5.2404966e-017
+ wuc1=-2.7727132e-023      puc1=3.285665e-029        prt=0
+ at=8518.7983              lat=1.1947615e-009        wat=7.573352e-008
+ pat=-5.2570639e-014       fnoimod=1                 tnoimod=1
+ noia=noian_25od33         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_25od33         rnoib=0                   noic=noicn_25od33
+ em=1.12e+008              ef=1                      jss=1.32e-07
+ jsd=1.32e-07              jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25od33
+ cjd=cjn_25od33            mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25od33
+ cjswd=cjswn_25od33        mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25od33
+ cjswgd=cjswgn_25od33      mjswgs=0.56               mjswgd=0.56
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.0025             tcjswg=0.00168
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163u
+ rshg=15.953                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-007
+ sbref=4.6e-007            wlod=1e-006               kvth0=-3.5e-008
+ lkvth0=2.5e-006           wkvth0=6.8e-006           pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=1.5e-009
+ lodk2=0.5                 lodeta0=1                 ku0=-6.6e-008
+ lku0=7e-007               wku0=2.08e-006            pku0=2e-015
+ llodku0=1                 wlodku0=1                 kvsat=0
+ steta0=8.5e-009           tku0=0                    wvth0=0+dwvthn_25od33
+ pvth0=0+dpvthn_25od33     lu0=0+dlu0n_25od33        wu0=0+dwu0n_25od33
+ pu0=0+dpu0n_25od33        wk2=0+dwk2n_25od33        pk2=0+dpk2n_25od33
+ minr=1e-3
 
 
     4: type=n 
+ lmin=5e-07                lmax=7e-007-(dxln_25od33+dlmisn_25od33)
+ wmin=1e-005-(dxwn_25od33+dwmisn_25od33)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.53987499+(dvthn_25od33+vthmisn_25od33)
+ lvth0=6.2506307e-009+dlvthn_25od33                  k1=0.3969
+ k2=0.076904689+dk2n_25od33                          lk2=-3.3597117e-009+dlk2n_25od33
+ wk2=-2.4539522e-014+dwk2n_25od33                    pk2=1.6809574e-020+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8299997e-009
+ wkvth0we=-2.9999743e-010  pkvth0we=-1.1000184e-016  k2we=0.0039999998
+ lk2we=1.0632188e-016      wk2we=4.000034e-010       pk2we=-2.0001711e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00019726565+dcitn_25od33
+ lcit=2.5705697e-010+dlcitn_25od33                   wcit=1.0119391e-016+dwcitn_25od33
+ pcit=5.4150471e-030+dpcitn_25od33                   voff=-0.1
+ lvoff=-1.8656456e-017     wvoff=-2.4539523e-014     pvoff=1.6809571e-020
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000001       lku0we=-1.9999994e-010
+ wku0we=-8.999973e-010     pku0we=-5.0001755e-017    u0=0.025026561+du0n_25od33
+ lu0=4.2973055e-009+dlu0n_25od33                     wu0=2.4539523e-014+dwu0n_25od33
+ pu0=-1.6809572e-020+dpu0n_25od33                    ua=-1.3784376e-009
+ lua=4.6879771e-017        ub=2.5995311e-018         lub=3.3597117e-025
+ wub=2.4539522e-030        pub=-1.6809572e-036       uc=1.0220313e-010
+ luc=2.1095855e-017        wuc=-2.4539522e-022       puc=1.6809573e-028
+ vsat=98400                a0=1.3582812              la0=-1.0157264e-007
+ ags=0.50265624            lags=-7.0319524e-008      wags=2.4539522e-013
+ pags=-1.6809572e-019      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.058
+ lketa=-1.865645e-017      wketa=-2.4539524e-014     pketa=1.6809572e-020
+ dwg=0                     dwb=0                     pclm=0.61125001
+ lpclm=-6.2506257e-008     wpclm=-2.4539523e-013     ppclm=1.6809574e-019
+ pdiblc1=0                 pdiblc2=0.0011771876      lpdiblc2=-2.3439848e-010
+ wpdiblc2=-1.2269761e-015  ppdiblc2=8.4047864e-022   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25od33          cgdo=cgon_25od33          cgbo=0
+ cgdl=cgln_25od33          cgsl=cgln_25od33          clc=1e-007
+ cle=0.6                   cf=cfn_25od33             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.37439064
+ lkt1=1.3282588e-008       wkt1=4.9079045e-013       pkt1=-3.3619145e-019
+ kt1l=0                    kt2=-0.066634078          lkt2=-6.7741178e-010
+ wkt2=-3.4658913e-014      pkt2=1.6809571e-020       ute=-1.7439062
+ lute=1.3282571e-007       wute=-2.4539522e-012      pute=1.6809573e-018
+ ua1=8.3896238e-010        lua1=6.9327234e-017       wua1=-4.4778304e-022
+ pua1=1.6809572e-028       ub1=-7.979641e-019        lub1=-3.7745959e-025
+ uc1=1.6329305e-010        luc1=-5.0438642e-017      wuc1=-2.8840265e-023
+ puc1=3.3619148e-029       prt=0                     at=-14293.699
+ lat=0.015626562           wat=-2.8005414e-008       pat=1.849053e-014
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    wvth0=0+dwvthn_25od33     pvth0=0+dpvthn_25od33
+ minr=1e-3
 
 
     5: type=n 
+ lmin=1e-005-(dxln_25od33+dlmisn_25od33)             lmax=0.000901
+ wmin=1e-006-(dxwn_25od33+dwmisn_25od33)             wmax=1e-005-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.555+(dvthn_25od33+vthmisn_25od33)
+ k1=0.3969                 k2=0.077904889+dk2n_25od33
+ wk2=8.9573769e-009+dwk2n_25od33                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=0.014999999       lkvth0we=5.8300068e-009   wkvth0we=-2.9999929e-010
+ pkvth0we=-1.1001104e-016  k2we=0.004                lk2we=4.3046437e-016
+ wk2we=3.9999998e-010      pk2we=-2.0000054e-017     xj=8.1e-008
+ ngate=4.282e+020          ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=3.74888e-005+dcitn_25od33
+ lcit=-1.1226628e-016+dlcitn_25od33                  wcit=1.0558508e-009+dwcitn_25od33
+ pcit=1.1305214e-022+dpcitn_25od33                   voff=-0.10577622
+ wvoff=-2.2393442e-009     nfactor=0.55              eta0=0.35079
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.002
+ lku0we=-1.9999983e-010    wku0we=-8.9999999e-010    pku0we=-4.999957e-017
+ u0=0.031223078+du0n_25od33                          wu0=-1.2316393e-009+dwu0n_25od33
+ ua=-1.3189511e-009        wua=8.9573769e-017        ub=3.0267833e-018
+ wub=-1.6795082e-025       uc=1.2880422e-010         luc=-4.5189224e-024
+ wuc=-3.8068856e-017       puc=4.5220856e-029        vsat=98400
+ a0=1.7267133              wa0=-6.7180327e-008       ags=0.45671333
+ wags=-6.7180327e-008      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.059790222
+ wketa=1.7914754e-008      dwg=0                     dwb=0
+ pclm=0.50769222           lpclm=-2.2594612e-014     wpclm=1.2316393e-007
+ ppclm=2.2610428e-019      pdiblc1=0                 pdiblc2=0.0010133222
+ lpdiblc2=5.1614216e-016   wpdiblc2=-7.8377048e-010  ppdiblc2=-1.1305214e-022
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.33744056           lkt1=1.0096897e-013       wkt1=-5.5983606e-009
+ pkt1=-9.6998694e-029      kt1l=0                    kt2=-0.066289057
+ lkt2=-1.1297307e-015      wkt2=2.1355506e-008       pkt2=1.1305214e-020
+ ute=-1.6734967            wute=2.3513114e-007       ua1=1.0521577e-009
+ wua1=4.7675639e-016       ub1=-3.817386e-19         lub1=-1.0096897e-30
+ wub1=-5.0416601e-25       pub1=1.8929915e-45        uc1=1.1933187e-010
+ luc1=1.1297306e-023       wuc1=2.6099557e-017       puc1=-1.1305214e-028
+ prt=0                     at=158518.8               lat=1.0096897e-007
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    lvth0=0+dlvthn_25od33     wvth0=0+dwvthn_25od33
+ pvth0=0+dpvthn_25od33     lu0=0+dlu0n_25od33        pu0=0+dpu0n_25od33
+ lk2=0+dlk2n_25od33        pk2=0+dpk2n_25od33        minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-006-(dxln_25od33+dlmisn_25od33)           lmax=1e-005-(dxln_25od33+dlmisn_25od33)
+ wmin=1e-006-(dxwn_25od33+dwmisn_25od33)             wmax=1e-005-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.55634659+(dvthn_25od33+vthmisn_25od33)
+ lvth0=-1.344571e-008+dlvthn_25od33                  k1=0.3969
+ k2=0.078696834+dk2n_25od33                          lk2=-7.9075717e-009+dlk2n_25od33
+ wk2=1.0465117e-008+dwk2n_25od33                     pk2=-1.5054785e-014+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8299998e-009
+ wkvth0we=-3.0000047e-010  pkvth0we=-1.0999931e-016  k2we=0.0040000001
+ lk2we=-1.0553389e-016     wk2we=3.9999997e-010      pk2we=-1.9999983e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=3.8754405e-005+dcitn_25od33
+ lcit=-1.2637175e-011+dlcitn_25od33                  wcit=1.0431858e-009+dwcitn_25od33
+ pcit=1.2646021e-016+dpcitn_25od33                   voff=-0.10595702
+ lvoff=1.8053107e-009      wvoff=-4.3005588e-010     pvoff=-1.8065744e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-2.0000001e-010
+ wku0we=-8.9999993e-010    pku0we=-5.0000108e-017    u0=0.031175052+du0n_25od33
+ lu0=4.7953379e-010+dlu0n_25od33                     wu0=-1.0205557e-009+dwu0n_25od33
+ pu0=-2.1076702e-015+dpu0n_25od33                    ua=-1.3189511e-009
+ wua=8.9573769e-017        ub=3.0224328e-018         lub=4.3440102e-026
+ wub=-1.5136567e-025       pub=-1.6560265e-031       uc=1.2886449e-010
+ luc=-6.0177023e-019       wuc=-3.8671948e-017       puc=6.0219147e-024
+ vsat=98400                a0=1.7938922              la0=-6.7078109e-007
+ wa0=-6.5672586e-008       pa0=-1.5054787e-014       ags=0.45791868
+ lags=-1.2035403e-008      wags=-7.9242247e-008      pags=1.2043828e-013
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.059940891         lketa=1.5044256e-009
+ wketa=1.9422494e-008      pketa=-1.5054787e-014     dwg=0
+ dwb=0                     pclm=0.50603487           lpclm=1.6548681e-008
+ wpclm=1.397491e-007       ppclm=-1.6560265e-013     pdiblc1=0
+ pdiblc2=0.001019349       lpdiblc2=-6.0177023e-011  wpdiblc2=-8.440801e-010
+ ppdiblc2=6.0219147e-016   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25od33
+ cgdo=cgon_25od33          cgbo=0                    cgdl=cgln_25od33
+ cgsl=cgln_25od33          clc=1e-007                cle=0.6
+ cf=cfn_25od33             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.33613915           lkt1=-1.2994398e-008
+ wkt1=-5.14604e-009        pkt1=-4.516421e-015       kt1l=0
+ kt2=-0.066406624          lkt2=1.1739033e-009       wkt2=2.2531997e-008
+ pkt2=-1.174725e-014       ute=-1.7028392            lute=2.9298501e-007
+ wute=2.5925499e-007       pute=-2.4087659e-013      ua1=1.0508213e-009
+ lua1=1.3344255e-017       wua1=4.9013004e-016       pua1=-1.3353596e-022
+ ub1=-3.176726e-19         lub1=-6.3969974e-25       wub1=-4.715083e-25
+ pub1=-3.2608662e-31       uc1=1.1827816e-010        luc1=1.0521349e-017
+ wuc1=3.6644077e-017       puc1=-1.0528714e-022      prt=0
+ at=178717.68              lat=-0.20168566           fnoimod=1
+ tnoimod=1                 noia=noian_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25od33         rnoib=0
+ noic=noicn_25od33         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25od33            cjd=cjn_25od33            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25od33        cjswd=cjswn_25od33        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163u                     rshg=15.953                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=1e-006
+ kvth0=-3.5e-008           lkvth0=2.5e-006           wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-009             lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-008             lku0=7e-007               wku0=2.08e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-009           tku0=0
+ wvth0=0+dwvthn_25od33     pvth0=0+dpvthn_25od33     minr=1e-3
 
 
     7: type=n 
+ lmin=7e-007-(dxln_25od33+dlmisn_25od33)             lmax=1.2e-006-(dxln_25od33+dlmisn_25od33)
+ wmin=1e-006-(dxwn_25od33+dwmisn_25od33)             wmax=1e-005-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.53614767+(dvthn_25od33+vthmisn_25od33)
+ lvth0=1.0490012e-008+dlvthn_25od33                  wvth0=3.3746917e-008+dwvthn_25od33
+ pvth0=-3.9990097e-014+dpvthn_25od33                 k1=0.3969
+ k2=0.071013996+dk2n_25od33                          lk2=1.1965911e-009+dlk2n_25od33
+ wk2=5.1236222e-009+dwk2n_25od33                     pk2=-8.7251139e-015+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8300005e-009
+ wkvth0we=-2.9999985e-010  pkvth0we=-1.1000003e-016  k2we=0.0039999998
+ lk2we=1.4784218e-016      wk2we=4.000001e-010       pk2we=-2.0000138e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-2.78615e-005+dcitn_25od33
+ lcit=6.6302672e-011+dlcitn_25od33                   wcit=1.2299755e-009+dwcitn_25od33
+ pcit=-9.4885594e-017+dpcitn_25od33                  voff=-0.11357328
+ lvoff=1.0830576e-008      wvoff=-6.4717048e-009     pvoff=-1.090639e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000001       lku0we=-1.9999994e-010
+ wku0we=-9.0000004e-010    pku0we=-4.9999982e-017    u0=0.031717681+du0n_25od33
+ lu0=-1.6348142e-010+dlu0n_25od33                    wu0=-4.179736e-009+dwu0n_25od33
+ pu0=1.6359585e-015+dpu0n_25od33                     ua=-1.3189511e-009
+ wua=8.9573769e-017        ub=2.9845555e-018         lub=8.8324699e-026
+ wub=-3.6781229e-025       pub=9.0886584e-032        uc=1.1617036e-010
+ luc=1.444077e-017         wuc=-2.1318543e-017       puc=-1.454187e-023
+ vsat=98400                a0=1.2016774              la0=3.0993464e-008
+ wa0=3.2045016e-007        pa0=-4.7261024e-013       ags=0.51166359
+ lags=-7.5723121e-008      wags=6.841194e-008        pags=-5.4531933e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.058671333         wketa=6.7180327e-009
+ dwg=0                     dwb=0                     pclm=0.51693424
+ lpclm=3.632924e-009       wpclm=3.0679069e-008      ppclm=-3.635467e-014
+ pdiblc1=0                 pdiblc2=0.0011055667      lpdiblc2=-1.6234505e-010
+ wpdiblc2=-3.3590168e-010  ppdiblc2=3.6354633e-023   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25od33          cgdo=cgon_25od33          cgbo=0
+ cgdl=cgln_25od33          cgsl=cgln_25od33          clc=1e-007
+ cle=0.6                   cf=cfn_25od33             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.33628859
+ lkt1=-1.2817315e-008      wkt1=-2.1228941e-008      pkt1=1.4541817e-014
+ kt1l=0                    kt2=-0.059202921          lkt2=-7.3624841e-009
+ wkt2=-2.0105814e-009      pkt2=1.7335705e-014       ute=-1.2875843
+ lute=-1.9909199e-007      wute=-2.5433464e-007      pute=3.6772712e-013
+ ua1=1.3133996e-009        lua1=-2.9781105e-016      wua1=5.0970722e-017
+ pua1=3.8686784e-022       ub1=-2.633113e-019        lub1=-7.0411786e-025
+ wub1=-9.7751575e-025      pub1=2.7353219e-031       uc1=1.6313472e-010
+ luc1=-4.2633679e-017      wuc1=3.0309982e-017       puc1=-9.7781241e-023
+ prt=0                     at=10051.684              lat=-0.0018164642
+ wat=-0.015339508          pat=1.8177317e-008        fnoimod=1
+ tnoimod=1                 noia=noian_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25od33         rnoib=0
+ noic=noicn_25od33         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25od33            cjd=cjn_25od33            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25od33        cjswd=cjswn_25od33        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163u                     rshg=15.953                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=1e-006
+ kvth0=-3.5e-008           lkvth0=2.5e-006           wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-009             lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-008             lku0=7e-007               wku0=2.08e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-009           tku0=0
+ minr=1e-3
 
 
     8: type=n 
+ lmin=5e-07                lmax=7e-007-(dxln_25od33+dlmisn_25od33)
+ wmin=1e-006-(dxwn_25od33+dwmisn_25od33)             wmax=1e-005-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.54080507+(dvthn_25od33+vthmisn_25od33)
+ lvth0=7.2996939e-009+dlvthn_25od33                  wvth0=-9.3072741e-009+dwvthn_25od33
+ pvth0=-1.0497976e-014+dpvthn_25od33                 k1=0.3969
+ k2=0.079107673+dk2n_25od33                          lk2=-4.3475778e-009+dlk2n_25od33
+ wk2=-2.2045293e-008+dwk2n_25od33                    pk2=9.8855932e-015+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8299995e-009
+ wkvth0we=-3.000012e-010   pkvth0we=-1.0999911e-016  k2we=0.0040000002
+ lk2we=-7.9051091e-017     wk2we=3.9999969e-010      pk2we=-1.9999856e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00030758563+dcitn_25od33
+ lcit=2.579137e-010+dlcitn_25od33                    wcit=1.1039722e-009+dwcitn_25od33
+ pcit=-8.5733169e-018+dpcitn_25od33                  voff=-0.096741238
+ lvoff=-6.9937427e-010     wvoff=-3.2610457e-008     pvoff=6.998655e-015
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0019999998       lku0we=-2.0000012e-010
+ wku0we=-9.0000013e-010    pku0we=-4.9999918e-017    u0=0.024873766+du0n_25od33
+ lu0=4.5246006e-009+dlu0n_25od33                     wu0=1.5290491e-009+dwu0n_25od33
+ pu0=-2.2745593e-015+dpu0n_25od33                    ua=-1.3950461e-009
+ lua=5.2125097e-017        wua=1.6620147e-016        pua=-5.2489973e-023
+ ub=2.6000559e-018         lub=3.5170694e-025        wub=-5.2485946e-027
+ pub=-1.5746955e-031       uc=1.0300906e-010         luc=2.3456265e-017
+ wuc=-8.0651463e-018       puc=-2.3620447e-023       vsat=98400
+ a0=1.3964808              la0=-1.0244687e-007       wa0=-3.8226314e-007
+ pa0=8.7483722e-015        ags=0.47186934            lags=-4.8464056e-008
+ wags=3.0808479e-007       pags=-2.1870784e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.056756987         lketa=-1.3113275e-009     wketa=-1.2438859e-008
+ pketa=1.3122471e-014      dwg=0                     dwb=0
+ pclm=0.61731646           lpclm=-6.5128895e-008     wpclm=-6.0707182e-008
+ ppclm=2.6244912e-014      pdiblc1=0                 pdiblc2=0.0012490411
+ lpdiblc2=-2.6062497e-010  wpdiblc2=-7.1903932e-010  ppdiblc2=2.6244932e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.37847453           lkt1=1.6080054e-008       wkt1=4.0867976e-008
+ pkt1=-2.7994572e-014      kt1l=0                    kt2=-0.067191636
+ lkt2=-1.8902147e-009      wkt2=5.5794478e-009       pkt2=1.2136535e-014
+ ute=-1.8068878            lute=1.5663088e-007       wute=6.3025481e-007
+ pute=-2.3821665e-013      ua1=7.4572584e-010        lua1=9.1045479e-017
+ wua1=9.3301764e-016       pua1=-2.1733431e-022      ub1=-6.7428e-019
+ lub1=-4.2260429e-025      wub1=-1.2377067e-024      pub1=4.5176302e-031
+ uc1=1.8276754e-010        luc1=-5.6082163e-017      wuc1=-1.9488124e-016
+ puc1=5.6474748e-023       prt=0                     at=-19241.288
+ lat=0.018249222           wat=0.0495105             pat=-2.6244938e-008
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    minr=1e-3
 
 
     9: type=n 
+ lmin=1e-005-(dxln_25od33+dlmisn_25od33)             lmax=0.000901
+ wmin=6e-007-(dxwn_25od33+dwmisn_25od33)             wmax=1e-006-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.5474125+(dvthn_25od33+vthmisn_25od33)
+ wvth0=7.6406125e-009+dwvthn_25od33                  k1=0.3969
+ k2=0.083765+dk2n_25od33   wk2=3.056245e-009+dwk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8299913e-009
+ wkvth0we=-2.9999965e-010  pkvth0we=-1.0999545e-016  k2we=0.0039999998
+ lk2we=2.8978094e-015      wk2we=4.0000017e-010      pk2we=-2.0002539e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0009039+dcitn_25od33
+ wcit=1.833747e-010+dwcitn_25od33                    voff=-0.0973775
+ wvoff=-1.0696858e-008     nfactor=0.55              eta0=0.35079
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.0019999999
+ lku0we=-1.9999923e-010    wku0we=-9.000001e-010     pku0we=-5.0000175e-017
+ u0=0.03+du0n_25od33       ua=-1.23e-009             ub=2.814475e-018
+ wub=4.5843675e-026        uc=1.1983249e-010         luc=5.5709628e-023
+ wuc=-2.9034326e-017       puc=-1.5429296e-029       vsat=98400
+ a0=1.66                   ags=0.405175              wags=-1.5281225e-008
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.042               dwg=0
+ dwb=0                     pclm=0.84245              lpclm=2.0193794e-013
+ wpclm=-2.1393715e-007     ppclm=1.9874362e-027      pdiblc1=0
+ pdiblc2=0.00038674995     lpdiblc2=7.103167e-016    wpdiblc2=-1.5281222e-010
+ ppdiblc2=-3.0858591e-022  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25od33
+ cgdo=cgon_25od33          cgbo=0                    cgdl=cgln_25od33
+ cgsl=cgln_25od33          clc=1e-007                cle=0.6
+ cf=cfn_25od33             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.339965             lkt1=2.5418938e-013
+ wkt1=-3.0562448e-009      pkt1=-1.5429295e-019      kt1l=0
+ kt2=-0.046397671          lkt2=1.0096897e-014       wkt2=1.3248807e-009
+ pkt2=-4.3878461e-028      ute=-1.273075             wute=-1.6809348e-007
+ ua1=1.4987404e-009        lua1=-1.5322041e-021      wua1=2.7047614e-017
+ pua1=1.5429296e-027       ub1=-3.011971e-19         lub1=-2.5418938e-30
+ wub1=-5.852712e-25        pub1=1.5429296e-36        uc1=3.058015e-010
+ luc1=-3.3079959e-022      wuc1=-1.6167536e-016      puc1=2.3143943e-028
+ prt=0                     at=219218.8               lat=1.0096897e-007
+ wat=-0.0611249            pat=-6.3601922e-022       fnoimod=1
+ tnoimod=1                 noia=noian_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25od33         rnoib=0
+ noic=noicn_25od33         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25od33            cjd=cjn_25od33            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25od33        cjswd=cjswn_25od33        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163u                     rshg=15.953                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=1e-006
+ kvth0=-3.5e-008           lkvth0=2.5e-006           wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-009             lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-008             lku0=7e-007               wku0=2.08e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-009           tku0=0
+ lcit=0+dlcitn_25od33      pcit=0+dpcitn_25od33      lvth0=0+dlvthn_25od33
+ pvth0=0+dpvthn_25od33     lu0=0+dlu0n_25od33        wu0=0+dwu0n_25od33
+ pu0=0+dpu0n_25od33        lk2=0+dlk2n_25od33        pk2=0+dpk2n_25od33
+ minr=1e-3
 
 
     10: type=n 
+ lmin=1.2e-006-(dxln_25od33+dlmisn_25od33)           lmax=1e-005-(dxln_25od33+dlmisn_25od33)
+ wmin=6e-007-(dxwn_25od33+dwmisn_25od33)             wmax=1e-006-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.54651129+(dvthn_25od33+vthmisn_25od33)
+ lvth0=8.9985416e-009+dlvthn_25od33                  wvth0=9.904144e-009+dwvthn_25od33
+ pvth0=-2.2601362e-014+dpvthn_25od33                 k1=0.3969
+ k2=0.086401591+dk2n_25od33                          lk2=-2.6326361e-008+dlk2n_25od33
+ wk2=2.7064267e-009+dwk2n_25od33                     pk2=3.4929356e-015+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.014999999       lkvth0we=5.8300013e-009
+ wkvth0we=-2.9999911e-010  pkvth0we=-1.1000083e-016  k2we=0.0040000001
+ lk2we=-3.4757162e-016     wk2we=3.9999989e-010      pk2we=-1.9999739e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00088237138+dcitn_25od33
+ lcit=2.1496329e-010+dlcitn_25od33                   wcit=1.9366348e-010+dwcitn_25od33
+ pcit=-1.0273346e-016+dpcitn_25od33                  voff=-0.09412683
+ lvoff=-3.2457945e-008     wvoff=-1.2343062e-008     pvoff=1.6437354e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0019999998       lku0we=-2.0000036e-010
+ wku0we=-9.0000014e-010    pku0we=-4.9999759e-017    u0=0.030406805+du0n_25od33
+ lu0=-4.0619491e-009+dlu0n_25od33                    wu0=-2.469307e-010+dwu0n_25od33
+ pu0=2.4656031e-015+dpu0n_25od33                     ua=-1.23e-009
+ ub=2.8490723e-018         lub=-3.4545391e-025       wub=2.3208361e-026
+ pub=2.2601362e-031        uc=1.1964125e-010         luc=1.909627e-018
+ wuc=-2.9384146e-017       puc=3.4929377e-024        vsat=98400
+ a0=1.6898506              la0=-2.9805797e-007       wa0=3.9097343e-008
+ pa0=-3.9038697e-013       ags=0.38111984            lags=2.4019075e-007
+ wags=-1.905816e-009       pags=-1.3355346e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.040653409         lketa=-1.344571e-008      dwg=0
+ dwb=0                     pclm=0.90017501           lpclm=-5.7638398e-007
+ wpclm=-2.5715002e-007     ppclm=4.3148054e-013      pdiblc1=0
+ pdiblc2=0.00031245187     lpdiblc2=7.4186706e-010   wpdiblc2=-1.3223469e-010
+ ppdiblc2=-2.0546692e-016  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25od33
+ cgdo=cgon_25od33          cgbo=0                    cgdl=cgln_25od33
+ cgsl=cgln_25od33          clc=1e-007                cle=0.6
+ cf=cfn_25od33             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.33695155           lkt1=-3.0089012e-008
+ wkt1=-4.3279534e-009      pkt1=1.2697856e-014       kt1l=0
+ kt2=-0.04375242           lkt2=-2.6412824e-008      wkt2=-2.8078622e-010
+ pkt2=1.6032584e-014       ute=-1.2478096            lute=-2.5227514e-007
+ wute=-1.9895981e-007      pute=3.0820039e-013       ua1=1.5070676e-009
+ lua1=-8.3148608e-017      wua1=3.0689996e-017       pua1=-3.6367645e-023
+ ub1=-1.128066e-19         lub1=-1.8810812e-24       wub1=-6.778083e-25
+ pub1=9.239846e-31         uc1=3.2584575e-010        luc1=-2.0014217e-016
+ wuc1=-1.7237649e-016      puc1=1.0685102e-022       prt=0
+ at=253721.84              lat=-0.34451274           wat=-0.075529193
+ pat=1.4382687e-007        fnoimod=1                 tnoimod=1
+ noia=noian_25od33         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_25od33         rnoib=0                   noic=noicn_25od33
+ em=1.12e+008              ef=1                      jss=1.32e-07
+ jsd=1.32e-07              jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25od33
+ cjd=cjn_25od33            mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25od33
+ cjswd=cjswn_25od33        mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25od33
+ cjswgd=cjswgn_25od33      mjswgs=0.56               mjswgd=0.56
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.0025             tcjswg=0.00168
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.01163u
+ rshg=15.953                    gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-007
+ sbref=4.6e-007            wlod=1e-006               kvth0=-3.5e-008
+ lkvth0=2.5e-006           wkvth0=6.8e-006           pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=1.5e-009
+ lodk2=0.5                 lodeta0=1                 ku0=-6.6e-008
+ lku0=7e-007               wku0=2.08e-006            pku0=2e-015
+ llodku0=1                 wlodku0=1                 kvsat=0
+ steta0=8.5e-009           tku0=0                    minr=1e-3
 
 
     11: type=n 
+ lmin=7e-007-(dxln_25od33+dlmisn_25od33)             lmax=1.2e-006-(dxln_25od33+dlmisn_25od33)
+ wmin=6e-007-(dxwn_25od33+dwmisn_25od33)             wmax=1e-006-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.5974758+(dvthn_25od33+vthmisn_25od33)
+ lvth0=-5.1394393e-008+dlvthn_25od33                 wvth0=-2.8010506e-008+dwvthn_25od33
+ pvth0=2.2327499e-014+dpvthn_25od33                  k1=0.3969
+ k2=0.066745101+dk2n_25od33                          lk2=-3.0334204e-009+dlk2n_25od33
+ wk2=9.4223997e-009+dwk2n_25od33                     pk2=-4.4654924e-015+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8300004e-009
+ wkvth0we=-2.9999979e-010  pkvth0we=-1.1000002e-016  k2we=0.0039999999
+ lk2we=-3.0033828e-017     wk2we=4.0000007e-010      pk2we=-1.9999959e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0010835971+dcitn_25od33
+ lcit=-2.3489133e-011+dlcitn_25od33                  wcit=1.1073672e-010+dwcitn_25od33
+ pcit=-4.4652468e-018+dpcitn_25od33                  voff=-0.13607033
+ lvoff=1.7245098e-008      wvoff=1.6182817e-008      pvoff=-1.7365813e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000003       lku0we=-1.9999978e-010
+ wku0we=-8.9999982e-010    pku0we=-5.0000146e-017    u0=0.024498615+du0n_25od33
+ lu0=2.9392562e-009+dlu0n_25od33                     wu0=3.0898637e-009+dwu0n_25od33
+ pu0=-1.4884983e-015+dpu0n_25od33                    ua=-1.23e-009
+ ub=2.157373e-018          lub=4.7420975e-025        wub=4.6516049e-025
+ pub=-2.9769966e-031       uc=1.3164764e-010         luc=-1.2317946e-017
+ wuc=-3.6904163e-017       puc=1.2404157e-023        vsat=98400
+ a0=1.8705941              la0=-5.1223904e-007       wa0=-3.5314895e-007
+ pa0=7.4424889e-014        ags=0.87012528            lags=-3.3928069e-007
+ wags=-2.9255898e-007      pags=2.1087054e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.066552817         lketa=1.7245088e-008      wketa=1.4654686e-008
+ pketa=-1.7365803e-014     dwg=0                     dwb=0
+ pclm=0.10853903           lpclm=3.6170465e-007      wpclm=4.4193305e-007
+ ppclm=-3.969329e-013      pdiblc1=0                 pdiblc2=0.0014912949
+ lpdiblc2=-6.5506187e-010  wpdiblc2=-7.2432988e-010  ppdiblc2=4.9616587e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.38034488           lkt1=2.1332076e-008       wkt1=2.3135738e-008
+ pkt1=-1.9846619e-014      kt1l=0                    kt2=-0.070749222
+ lkt2=5.5783868e-009       wkt2=9.6165435e-009       pkt2=4.3042483e-015
+ ute=-1.8966891            lute=5.1664713e-007       wute=3.5903391e-007
+ pute=-3.5302218e-013      ua1=1.2902124e-009        lua1=1.7382482e-016
+ wua1=7.4320238e-017       pua1=-8.8069482e-023      ub1=-1.6818137e-018
+ lub1=-2.1807891e-026      wub1=4.5091614e-025       pub1=-4.1355394e-031
+ uc1=4.2398967e-010        luc1=-3.1644271e-016      wuc1=-2.3237095e-016
+ puc1=1.7794446e-022       prt=0                     at=-113075.49
+ lat=0.090142088           wat=0.10864955            pat=-7.4424945e-008
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    minr=1e-3
 
 
     12: type=n 
+ lmin=5e-07                lmax=7e-007-(dxln_25od33+dlmisn_25od33)
+ wmin=6e-007-(dxwn_25od33+dwmisn_25od33)             wmax=1e-006-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.51835546+(dvthn_25od33+vthmisn_25od33)
+ lvth0=2.8030349e-009+dlvthn_25od33                  wvth0=1.3299478e-008+dwvthn_25od33
+ pvth0=-5.9698404e-015+dpvthn_25od33                 k1=0.3969
+ k2=0.053813106+dk2n_25od33                          lk2=5.8249963e-009+dlk2n_25od33
+ wk2=3.4263363e-009+dwk2n_25od33                     pk2=-3.581889e-016+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.014999997       lkvth0we=5.830002e-009
+ wkvth0we=-2.9999738e-010  pkvth0we=-1.1000167e-016  k2we=0.0039999993
+ lk2we=3.8911854e-016      wk2we=4.0000061e-010      pk2we=-2.0000327e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00017598793+dcitn_25od33
+ lcit=5.9822311e-010+dlcitn_25od33                   wcit=6.1701358e-010+dwcitn_25od33
+ pcit=-3.512649e-016+dpcitn_25od33                   voff=-0.12867452
+ lvoff=1.2178973e-008      wvoff=-4.5363959e-010     pvoff=-5.9698404e-015
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0019999998       lku0we=-2.0000011e-010
+ wku0we=-9.0000013e-010    pku0we=-4.9999929e-017    u0=0.022366067+du0n_25od33
+ lu0=4.4000517e-009+dlu0n_25od33                     wu0=4.0543019e-009+dwu0n_25od33
+ pu0=-2.1491385e-015+dpu0n_25od33                    ua=-1.23e-009
+ ub=2.2702412e-018         lub=3.9689504e-025        wub=3.2687481e-025
+ pub=-2.0297396e-031       uc=1.1366521e-010         luc=1.9190146e-023
+ wuc=-1.8795893e-017       puc=-7.6152066e-030       vsat=98400
+ a0=1.0519669              la0=4.852062e-008         wa0=-3.5337596e-008
+ pa0=-1.4327589e-013       ags=0.38184035            lags=-4.8055152e-009
+ wags=3.9874398e-007       pags=-2.6267199e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.032523443         lketa=-6.0650332e-009     wketa=-3.6842038e-008
+ pketa=1.7909453e-014      dwg=0                     dwb=0
+ pclm=0.79746027           lpclm=-1.102064e-007      wpclm=-2.42112e-007
+ ppclm=7.1637957e-014      pdiblc1=0                 pdiblc2=0.00053500043
+ lpdiblc2=-1.9306425e-016  wpdiblc2=-3.9692982e-016  ppdiblc2=1.7768818e-022
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.3081728            lkt1=-2.8105798e-008      wkt1=-2.9925867e-008
+ pkt1=1.6500581e-014       kt1l=0                    kt2=-0.1044547
+ lkt2=2.8666642e-008       wkt2=4.3103358e-008       pkt2=-1.863422e-014
+ ute=-0.67163211           lute=-3.2251693e-007      wute=-5.1294765e-007
+ pute=2.4428519e-013       ua1=1.8796597e-009        lua1=-2.2994657e-016
+ wua1=-2.0885374e-016      pua1=1.0590469e-022       ub1=-1.7803663e-018
+ lub1=4.5700691e-026       wub1=-1.238778e-025       pub1=-1.9820101e-032
+ uc1=-1.4350137e-010       luc1=7.2288646e-017       wuc1=1.3367155e-016
+ puc1=-7.2794656e-023      prt=0                     at=47234.039
+ lat=-0.019669935          wat=-0.017430155          pat=1.1939653e-008
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    minr=1e-3
 
 
     13: type=n 
+ lmin=1e-005-(dxln_25od33+dlmisn_25od33)             lmax=0.000901
+ wmin=4e-07                wmax=6e-007-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.566105+(dvthn_25od33+vthmisn_25od33)
+ lvth0=2.0547185e-013+dlvthn_25od33                  wvth0=-3.7057349e-009+dwvthn_25od33
+ pvth0=-1.2472142e-019+dpvthn_25od33                 k1=0.3969
+ k2=0.082695+dk2n_25od33   wk2=3.705735e-009+dwk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8300059e-009
+ wkvth0we=-3.0000044e-010  pkvth0we=-1.1000429e-016  k2we=0.0040000002
+ lk2we=-2.801889e-015      wk2we=3.9999996e-010      pk2we=-1.9999079e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00109611+dcitn_25od33
+ wcit=6.670323e-011+dwcitn_25od33                    voff=-0.112965
+ wvoff=-1.235245e-009      nfactor=0.55              eta0=0.35079
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.0020000003
+ lku0we=-1.9999818e-010    wku0we=-8.9999984e-010    pku0we=-5.0000815e-017
+ u0=0.031628+du0n_25od33   wu0=-9.88196e-010+dwu0n_25od33
+ ua=-1.23e-009             ub=2.89e-018              uc=8.0139991e-011
+ luc=9.1932248e-023        wuc=-4.9409763e-018       puc=-3.7416424e-029
+ vsat=98400                a0=1.66                   ags=0.35965
+ wags=1.235245e-008        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.03386
+ wketa=-4.94098e-009       dwg=0                     dwb=0
+ pclm=0.46965              lpclm=6.1288164e-013      wpclm=1.235245e-008
+ ppclm=-2.4944282e-019     pdiblc1=0                 pdiblc2=0.000135
+ lpdiblc2=6.1288165e-016   wpdiblc2=2.7685578e-019   ppdiblc2=-2.4944283e-022
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.355175             wkt1=6.176225e-009        kt1l=0
+ kt2=-0.037157623          lkt2=1.0096897e-014       wkt2=-4.2838284e-009
+ pkt2=3.0357419e-028       ute=-1.69245              wute=8.646715e-008
+ ua1=1.7598237e-009        lua1=3.0644082e-021       wua1=-1.3142994e-016
+ pua1=-1.2472142e-027      ub1=-9.933208e-19         lub1=-2.0547185e-30
+ wub1=-1.6515213e-25       pub1=1.2472142e-36        uc1=-6.6376106e-011
+ luc1=2.1486197e-022       wuc1=6.4236447e-017       puc1=-9.9777132e-029
+ prt=0                     at=118518.8               lat=3.0644083e-007
+ wat=1.3842778e-010        pat=-1.2472141e-013       fnoimod=1
+ tnoimod=1                 noia=noian_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25od33         rnoib=0
+ noic=noicn_25od33         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25od33            cjd=cjn_25od33            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25od33        cjswd=cjswn_25od33        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.01163u                     rshg=15.953                    gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=1e-006
+ kvth0=-3.5e-008           lkvth0=2.5e-006           wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-009             lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-008             lku0=7e-007               wku0=2.08e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-009           tku0=0
+ lcit=0+dlcitn_25od33      pcit=0+dpcitn_25od33      lu0=0+dlu0n_25od33
+ pu0=0+dpu0n_25od33        lk2=0+dlk2n_25od33        pk2=0+dpk2n_25od33
+ minr=1e-3
 
 
     14: type=n 
+ lmin=1.2e-006-(dxln_25od33+dlmisn_25od33)           lmax=1e-005-(dxln_25od33+dlmisn_25od33)
+ wmin=4e-07                wmax=6e-007-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.57660574+(dvthn_25od33+vthmisn_25od33)
+ lvth0=-1.0484965e-007+dlvthn_25od33                 wvth0=-8.3631825e-009+dwvthn_25od33
+ pvth0=4.650449e-014+dpvthn_25od33                   k1=0.3969
+ k2=0.086481681+dk2n_25od33                          lk2=-3.7810009e-008+dlk2n_25od33
+ wk2=2.6578121e-009+dwk2n_25od33                     pk2=1.046351e-014+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000002       lkvth0we=5.8299995e-009
+ wkvth0we=-3.000009e-010   pkvth0we=-1.0999973e-016  k2we=0.0039999999
+ lk2we=2.2387108e-016      wk2we=4.0000006e-010      pk2we=-2.0000086e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00095341983+dcitn_25od33
+ lcit=1.4247613e-009+dlcitn_25od33                   wcit=1.5053707e-010+dwcitn_25od33
+ pcit=-8.3708087e-016+dpcitn_25od33                  voff=-0.12475777
+ lvoff=1.1775081e-007      wvoff=6.2499186e-009      pvoff=-7.4739359e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000002       lku0we=-1.9999974e-010
+ wku0we=-8.9999991e-010    pku0we=-5.0000133e-017    u0=0.031847225+du0n_25od33
+ lu0=-2.1889616e-009+dlu0n_25od33                    wu0=-1.1212656e-009+dwu0n_25od33
+ pu0=1.3286997e-015+dpu0n_25od33                     ua=-1.23e-009
+ ub=2.8653843e-018         lub=2.4578758e-025        wub=1.3306958e-026
+ pub=-1.3286997e-031       uc=8.0550778e-011         luc=-4.1016139e-018
+ wuc=-5.656229e-018        puc=7.1417609e-024        vsat=98400
+ a0=1.7570017              la0=-9.6856153e-007       wa0=-1.6633647e-009
+ pa0=1.6608697e-014        ags=0.37818246            lags=-1.850466e-007
+ wags=-1.2282432e-010      pags=1.2456561e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.032239378         lketa=-1.6181912e-008     wketa=-5.107317e-009
+ pketa=1.6608746e-015      dwg=0                     dwb=0
+ pclm=0.45070353           lpclm=1.8918114e-007      wpclm=1.5679165e-008
+ ppclm=-3.3217493e-014     pdiblc1=0                 pdiblc2=0.00012200546
+ lpdiblc2=1.297511e-010    wpdiblc2=-1.6633722e-011  ppdiblc2=1.6608746e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.34730171           lkt1=-7.8614782e-008      wkt1=1.9545927e-009
+ pkt1=4.2152998e-014       kt1l=0                    kt2=-0.033355987
+ lkt2=-3.7959331e-008      wkt2=-6.5914212e-009      pkt2=2.3041314e-014
+ ute=-1.7344771            lute=4.1964062e-007       wute=9.6447368e-008
+ pute=-9.9652478e-014      ua1=1.8421937e-009        lua1=-8.2246132e-016
+ wua1=-1.7273154e-016      pua1=4.1239517e-022       ub1=-1.0303824e-18
+ lub1=3.7005811e-25        wub1=-1.2083987e-25       pub1=-4.4245699e-31
+ uc1=-8.2142861e-011       luc1=1.5743126e-016       wuc1=7.5272597e-017
+ puc1=-1.1019605e-022      prt=0                     at=121070.62
+ lat=-0.025479588          wat=0.0049900986          pat=-4.9826257e-008
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    minr=1e-3
 
 
     15: type=n 
+ lmin=7e-007-(dxln_25od33+dlmisn_25od33)             lmax=1.2e-006-(dxln_25od33+dlmisn_25od33)
+ wmin=4e-07                wmax=6e-007-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.35826947+(dvthn_25od33+vthmisn_25od33)
+ lvth0=1.5387882e-007+dlvthn_25od33                  wvth0=1.1718773e-007+dwvthn_25od33
+ pvth0=-1.0227334e-013+dpvthn_25od33                 k1=0.3969
+ k2=0.065294057+dk2n_25od33                          lk2=-1.2702675e-008+dlk2n_25od33
+ wk2=1.0303184e-008+dwk2n_25od33                     pk2=1.4037449e-015+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8300003e-009
+ wkvth0we=-3.0000073e-010  pkvth0we=-1.0999993e-016  k2we=0.0040000002
+ lk2we=-2.2403607e-016     wk2we=3.9999986e-010      pk2we=-1.9999841e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0034979715+dcitn_25od33
+ lcit=-1.5905324e-009+dlcitn_25od33                  wcit=-1.3547886e-009+dwcitn_25od33
+ pcit=9.4673001e-016+dpcitn_25od33                   voff=0.18493234
+ lvoff=-2.4923198e-007     wvoff=-1.786658e-007      pvoff=1.4438577e-013
+ nfactor=0.55              eta0=0.62958506           leta0=-3.3037214e-007
+ weta0=-1.692286e-007      peta0=2.0053589e-013      etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-2.0000001e-010
+ wku0we=-9.0000002e-010    pku0we=-5.0000004e-017    u0=0.032655745+du0n_25od33
+ lu0=-3.1470578e-009+dlu0n_25od33                    wu0=-1.8615142e-009+dwu0n_25od33
+ pu0=2.2058943e-015+dpu0n_25od33                     ua=-1.23e-009
+ ub=4.0065232e-018         lub=-1.106462e-024        wub=-6.572737e-025
+ pub=6.617681e-031         uc=8.4179279e-011         luc=-8.4013882e-018
+ wuc=-8.0908666e-018       puc=1.0026807e-023        vsat=131855.4
+ lvsat=-0.039644649        wvsat=-0.020307428        pvsat=2.4064302e-008
+ a0=0.59934205             la0=4.032651e-007         wa0=4.1850104e-007
+ pa0=-4.8128612e-013       ags=-1.6388117            lags=2.2050915e-006
+ wags=1.2303658e-006       pags=-1.3335634e-012      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.066849097          lketa=-1.3360176e-007     wketa=-6.6320275e-008
+ pketa=7.419823e-014       dwg=0                     dwb=0
+ pclm=0.6060348            lpclm=5.1135875e-009      wpclm=1.3995312e-007
+ ppclm=-1.8048212e-013     pdiblc1=0                 pdiblc2=0.00065209042
+ lpdiblc2=-4.9839958e-010  wpdiblc2=-2.1493279e-010  ppdiblc2=4.0107186e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.47818488           lkt1=7.6481769e-008       wkt1=8.2524619e-008
+ pkt1=-5.3322482e-014      kt1l=0                    kt2=-0.11234076
+ lkt2=5.5637621e-008       wkt2=3.4862605e-008       pkt2=-2.6081707e-014
+ ute=-1.158273             lute=-2.6316125e-007      wute=-8.9184689e-008
+ pute=1.2032151e-013       ua1=6.7892768e-010        lua1=5.560089e-016
+ wua1=4.4537006e-016       pua1=-3.2005522e-022      ub1=4.9858399e-18
+ lub1=-6.7591654e-24       wub1=-3.5963496e-24       pub1=3.6760221e-30
+ uc1=3.0368711e-011        luc1=2.4105048e-017       wuc1=6.5569701e-018
+ puc1=-2.8768035e-023      prt=0                     at=182727.95
+ lat=-0.098543521          wat=-0.070903131          pat=4.010722e-008
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    minr=1e-3
 
 
     16: type=n 
+ lmin=5e-07                lmax=7e-007-(dxln_25od33+dlmisn_25od33)
+ wmin=4e-07                wmax=6e-007-(dxwn_25od33+dwmisn_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxn_25od33+toxmisn_25od33)                   toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+(dxln_25od33+dlmisn_25od33)
+ xw=7e-09+(dxwn_25od33+dwmisn_25od33)                dlc=0
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.58156993+(dvthn_25od33+vthmisn_25od33)
+ lvth0=9.1800852e-010+dlvthn_25od33                  wvth0=-2.5071705e-008+dwvthn_25od33
+ pvth0=-4.8256293e-015+dpvthn_25od33                 k1=0.3969
+ k2=0.028198314+dk2n_25od33                          lk2=1.2707909e-008+dlk2n_25od33
+ wk2=1.8974515e-008+dwk2n_25od33                     pk2=-4.536117e-015+dpk2n_25od33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000007       lkvth0we=5.8299961e-009
+ wkvth0we=-3.0000346e-010  pkvth0we=-1.0999806e-016  k2we=0.004
+ lk2we=-8.5547994e-017     wk2we=4.0000015e-010      pk2we=-2.0000039e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0008573646+dcitn_25od33
+ lcit=2.1828333e-010+dlcitn_25od33                   wcit=2.0341795e-010+dwcitn_25od33
+ pcit=-1.2064145e-016+dpcitn_25od33                  voff=-0.18929528
+ lvoff=7.1139463e-009      wvoff=3.6343162e-008      pvoff=-2.8953694e-015
+ nfactor=0.55              eta0=-0.084827364         leta0=1.5900037e-007
+ weta0=2.6441974e-007      peta0=-9.6513223e-014     etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-2e-010
+ wku0we=-9.0000004e-010    pku0we=-4.9999995e-017    u0=0.024021406+du0n_25od33
+ lu0=2.7674644e-009+dlu0n_25od33                     wu0=3.0495111e-009+dwu0n_25od33
+ pu0=-1.158158e-015+dpu0n_25od33                     ua=-1.23e-009
+ ub=1.8821894e-018         lub=3.4870664e-025        wub=5.6242222e-025
+ pub=-1.737236e-031        uc=7.1914444e-011         luc=2.3546447e-023
+ wuc=6.5468221e-018        puc=-1.0259482e-029       vsat=46125.937
+ lvsat=0.019080033         wvsat=0.031730356         pvsat=-1.158158e-008
+ a0=2.0188815              la0=-5.6911943e-007       wa0=-6.2225479e-007
+ pa0=2.3163162e-013        ags=3.5189061             lags=-1.3279452e-006
+ wags=-1.5054549e-006      pags=5.4047379e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.23204379          lketa=7.1139873e-008      wketa=8.4266814e-008
+ pketa=-2.8953926e-014     dwg=0                     dwb=0
+ pclm=0.57888164           lpclm=2.3713503e-008      wpclm=-1.0943477e-007
+ ppclm=-9.6514228e-015     pdiblc1=0                 pdiblc2=-0.00077185232
+ lpdiblc2=4.770012e-010    wpdiblc2=7.9325922e-010   ppdiblc2=-2.8953967e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25od33          cgdo=cgon_25od33
+ cgbo=0                    cgdl=cgln_25od33          cgsl=cgln_25od33
+ clc=1e-007                cle=0.6                   cf=cfn_25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.38565944           lkt1=1.3101842e-008       wkt1=1.7108522e-008
+ pkt1=-8.5124562e-015      kt1l=0                    kt2=-0.022113782
+ lkt2=-6.167856e-009       wkt2=-6.8775815e-009      pkt2=2.5103208e-015
+ ute=-1.8965917            lute=2.4258709e-007       wute=2.3060283e-007
+ pute=-9.8732943e-014      ua1=1.7364069e-009        lua1=-1.683644e-016
+ wua1=-1.2189933e-016      pua1=6.852431e-023        ub1=-6.913316e-18
+ lub1=1.3917565e-24        wub1=2.9918228e-24        pub1=-8.368759e-31
+ uc1=2.7662016e-010        luc1=-1.445772e-016       wuc1=-1.2134222e-016
+ puc1=5.8842911e-023       prt=0                     at=38868.776
+ lat=9.4069507e-009        wat=-0.01235244           pat=-3.6934133e-015
+ fnoimod=1                 tnoimod=1                 noia=noian_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25od33
+ rnoib=0                   noic=noicn_25od33         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25od33            cjd=cjn_25od33
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25od33        cjswd=cjswn_25od33
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25od33      cjswgd=cjswgn_25od33
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u                     rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    minr=1e-3
 
     } 
ends nch_25od33_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                    3.3V PMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt pch_25od33_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=9.25e-08 xw= + 7e-09 
+ + dxwp_25od33 ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg / factor 
+ * (w / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) ps=4 
+ * dmcg / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf + xw 
+ / factor) nrs=dmcg / factor / (w / nf + xw / factor) sa=4.6e-07 / factor sb=4.6e-07 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parp1_25od33 temp2=parp2_25od33 fac1=0.955472 * temp1 * sigma 
+ + 0.295081 * temp2 * sigma fac2=0.955472 * temp1 * sigma - 0.295081 * temp2 * 
+ sigma lef=l * factor - 1.5e-08 wef=w / nf * factor + 7e-09 geo_fac=1 / sqrt(multi 
+ * nf * lef * wef * 1e12) vthmisp_25od33=0.00615610 * geo_fac * fac1 * mismatchflag 
+ dlmisp_25od33=0.00242520 * geo_fac * lef * fac2 * mismatchflag dwmisp_25od33= 
+ - 0.00242520 * geo_fac * wef * fac2 * mismatchflag toxmisp_25od33=0.00242520 * 
+ geo_fac * toxp_25od33 * fac2 * mismatchflag tnoiax=1.91e6 / (l * 1e6) + 2.818e7 
+ rnoiax=0.0064 / (l * 1e6) + 0.4993 
pch_25od33_mac ( n1 n2 n3 n4 ) pch_25od33 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs 
+ m=multi nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model pch_25od33 bsim4  { 
     1: type=p 
+ lmin=1e-005-(dxlp_25od33+dlmisp_25od33)             lmax=0.000901
+ wmin=1e-005-(dxwp_25od33+dwmisp_25od33)             wmax=0.000901
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.6329+(dvthp_25od33+vthmisp_25od33)
+ lvth0=0+dlvthp_25od33     wvth0=0+dwvthp_25od33     pvth0=0+dpvthp_25od33
+ k1=0.7812                 k2=-0.082342292+dk2_25od33
+ lk2=0+dlk2_25od33         wk2=0+dwk2_25od33         pk2=0+dpk2_25od33
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-09
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-21          web=-250                  wec=-3500
+ scref=1e-06               kvth0we=-0.0059703572     lkvth0we=1.1340025e-17
+ wkvth0we=1.1340302e-17    pkvth0we=-1.0217444e-20   k2we=0.012423912
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=9.5e-08                ngate=1.842e+20           ndep=7.81e+17
+ nsd=1e+20                 phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5e-06+dcitp_25od33
+ lcit=0+dlcitp_25od33      wcit=0+dwcitp_25od33      pcit=0+dpcitp_25od33
+ voff=-0.15000001          nfactor=0.63002+dnfactorp_25od33
+ lnfactor=0+dlnfactorp_25od33                        wnfactor=0+dwnfactorp_25od33
+ pnfactor=0+dpnfactorp_25od33                        eta0=0.4
+ leta0=0+dleta0p_25od33    peta0=0+dpeta0p_25od33    etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015129931        lku0we=0
+ wku0we=0                  pku0we=0                  u0=0.01425+du0p_25od33
+ lu0=0+dlu0p_25od33        wu0=0+dwu0p_25od33        pu0=0+dpu0p_25od33
+ ua=1.997e-09              ub=1.95678e-19            uc=-1.025e-12
+ vsat=110000+dvsatp_25od33 lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33
+ pvsat=0+dpvsatp_25od33    a0=1.1                    la0=-1.134003e-14+dla0p_25od33
+ wa0=-1.1340306e-14+dwa0p_25od33                     pa0=1.0217444e-17+dpa0p_25od33
+ ags=0.28435               a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.02109
+ dwg=0                     dwb=0                     pclm=0.27
+ pdiblc1=0                 pdiblc2=1e-05             pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+08          pscbe2=1e-20              fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-07           alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-09
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25od33          cgdo=cgop_25od33          cgbo=0
+ cgdl=cglp_25od33          cgsl=cglp_25od33          clc=1e-07
+ cle=0.6                   cf=cfp_25od33             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.30317              kt1l=0
+ kt2=-0.03                 ute=-1                    ua1=2.76e-09
+ ub1=-3.99e-18             uc1=-1.2e-10              prt=0
+ at=200000.01              lat=-2.2680055e-09        wat=-2.2680611e-09
+ pat=2.0434889e-12         fnoimod=1                 tnoimod=1
+ noia=noiap_25od33         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_25od33         rnoib=0                   noic=noicp_25od33
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25od33
+ cjd=cjp_25od33            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25od33
+ cjswd=cjswp_25od33        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25od33
+ cjswgd=cjswgp_25od33      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-08
+ jtsswgd=2.148e-08         njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-08             dmci=9.25e-08
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.00656u                     rshg=15.882
+ gbmin=1e-12               rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-07             sbref=4.6e-07
+ wlod=0                    kvth0=1.1e-09             lkvth0=-1.5e-07
+ wkvth0=3e-07              pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-09               lku0=1.5e-08
+ wku0=1.1e-06              pku0=2e-15                llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-09
+ tku0=0                    minr=1e-3
 
 
     2: type=p 
+ lmin=1.2e-006-(dxlp_25od33+dlmisp_25od33)           lmax=1e-005-(dxlp_25od33+dlmisp_25od33)
+ wmin=1e-005-(dxwp_25od33+dwmisp_25od33)             wmax=0.000901
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.63447551+(dvthp_25od33+vthmisp_25od33)
+ lvth0=1.5731481e-08+dlvthp_25od33                   wvth0=0+dwvthp_25od33
+ pvth0=0+dpvthp_25od33     k1=0.7812                 k2=-0.082398628+dk2_25od33
+ lk2=5.6251473e-10+dlk2_25od33                       wk2=0+dwk2_25od33
+ pk2=0+dpk2_25od33         k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-09           dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-21          web=-250
+ wec=-3500                 scref=1e-06               kvth0we=-0.0057219847
+ lkvth0we=-2.4799999e-09   wkvth0we=-1.2844727e-15   pkvth0we=2.7212479e-21
+ k2we=0.012490007          lk2we=-6.5995848e-10      wk2we=0
+ pk2we=0                   xj=9.5e-08                ngate=1.842e+20
+ ndep=7.81e+17             nsd=1e+20                 phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=5e-06+dcitp_25od33    lcit=0+dlcitp_25od33      wcit=0+dwcitp_25od33
+ pcit=0+dpcitp_25od33      voff=-0.15518439          lvoff=5.1765998e-08
+ nfactor=0.63002+dnfactorp_25od33                    lnfactor=0+dlnfactorp_25od33
+ wnfactor=0+dwnfactorp_25od33                        pnfactor=0+dpnfactorp_25od33
+ eta0=0.4                  leta0=0+dleta0p_25od33    peta0=0+dpeta0p_25od33
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015119916
+ lku0we=-9.9999781e-11     wku0we=0                  pku0we=0
+ u0=0.014244614+du0p_25od33                          lu0=5.3782841e-11+dlu0p_25od33
+ wu0=0+dwu0p_25od33        pu0=0+dpu0p_25od33        ua=2.0512676e-09
+ lua=-5.4186212e-16        ub=1.3040133e-19          lub=6.5178753e-25
+ uc=-9.2802756e-12         luc=8.2428927e-17         vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=1.1269318              la0=-2.6891418e-07+dla0p_25od33
+ wa0=9.9831238e-13+dwa0p_25od33                      pa0=1.360624e-19+dpa0p_25od33
+ ags=0.26194946            lags=2.2366939e-07        a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.016910182         lketa=-4.1735486e-08      wketa=-1.362668e-15
+ pketa=1.3606239e-20       dwg=0                     dwb=0
+ pclm=0.2533696            lpclm=1.6605452e-07       pdiblc1=0
+ pdiblc2=1e-05             pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+08
+ pscbe2=1e-20              fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-07           alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-09           cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25od33
+ cgdo=cgop_25od33          cgbo=0                    cgdl=cglp_25od33
+ cgsl=cglp_25od33          clc=1e-07                 cle=0.6
+ cf=cfp_25od33             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.2995571            lkt1=-3.6074841e-08       kt1l=0
+ kt2=-0.03                 ute=-1                    ua1=2.76e-09
+ ub1=-3.9051648e-18        lub1=-8.4707974e-25       uc1=-1.2e-10
+ prt=0                     at=202019.9               lat=-0.020168565
+ wat=2.0238781e-07         pat=-2.4401152e-22        fnoimod=1
+ tnoimod=1                 noia=noiap_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_25od33         rnoib=0
+ noic=noicp_25od33         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25od33            cjd=cjp_25od33            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25od33        cjswd=cjswp_25od33        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25od33      cjswgd=cjswgp_25od33      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-08         jtsswgd=2.148e-08         njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-08
+ dmci=9.25e-08             dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.00656u
+ rshg=15.882                    gbmin=1e-12               rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-07
+ sbref=4.6e-07             wlod=0                    kvth0=1.1e-09
+ lkvth0=-1.5e-07           wkvth0=3e-07              pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 lodeta0=1                 ku0=3.9e-09
+ lku0=1.5e-08              wku0=1.1e-06              pku0=2e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=5e-09              tku0=0                    minr=1e-3
 
 
     3: type=p 
+ lmin=7e-007-(dxlp_25od33+dlmisp_25od33)             lmax=1.2e-006-(dxlp_25od33+dlmisp_25od33)
+ wmin=1e-005-(dxwp_25od33+dwmisp_25od33)             wmax=0.000901
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.627776+(dvthp_25od33+vthmisp_25od33)
+ lvth0=7.79256e-09+dlvthp_25od33                     wvth0=0+dwvthp_25od33
+ pvth0=0+dpvthp_25od33     k1=0.7812                 k2=-0.085934212+dk2_25od33
+ lk2=4.7521823e-09+dlk2_25od33                       wk2=0+dwk2_25od33
+ pk2=0+dpk2_25od33         k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-09           dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-21          web=-250
+ wec=-3500                 scref=1e-06               kvth0we=-0.0057219845
+ lkvth0we=-2.4800001e-09   wkvth0we=2.3982957e-15    pkvth0we=-1.6428325e-21
+ k2we=0.012490006          lk2we=-6.5995678e-10      wk2we=0
+ pk2we=0                   xj=9.5e-08                ngate=1.842e+20
+ ndep=7.81e+17             nsd=1e+20                 phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00021324101+dcitp_25od33                     lcit=2.586156e-10+dlcitp_25od33
+ wcit=0+dwcitp_25od33      pcit=0+dpcitp_25od33      voff=-0.13147461
+ lvoff=2.3669907e-08       wvoff=-5.5454261e-14      pvoff=6.5713298e-20
+ nfactor=0.63002+dnfactorp_25od33                    lnfactor=0+dlnfactorp_25od33
+ wnfactor=0+dwnfactorp_25od33                        pnfactor=0+dpnfactorp_25od33
+ eta0=0.4                  leta0=0+dleta0p_25od33    peta0=0+dpeta0p_25od33
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015119916
+ lku0we=-9.999965e-11      wku0we=0                  pku0we=0
+ u0=0.012509+du0p_25od33   lu0=2.110485e-09+dlu0p_25od33
+ wu0=0+dwu0p_25od33        pu0=0+dpu0p_25od33        ua=1.41864e-09
+ lua=2.078016e-16          ub=4.5322534e-19          lub=2.6924108e-25
+ uc=-9.2064e-12            luc=8.2341384e-17         vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=0.89087583             la0=1.0812163e-08+dla0p_25od33
+ wa0=2.7767608e-12+dwa0p_25od33                      pa0=-1.971399e-18+dpa0p_25od33
+ ags=0.193688              lags=3.0455922e-07        a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.0260863           lketa=-3.0861786e-08      wketa=-3.7441751e-15
+ pketa=1.6428325e-20       dwg=0                     dwb=0
+ pclm=0.28869499           lpclm=1.2419394e-07       wpclm=1.3863566e-13
+ ppclm=-1.6428324e-19      pdiblc1=0                 pdiblc2=1e-05
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+08          pscbe2=1e-20
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-07
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-09           cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25od33          cgdo=cgop_25od33
+ cgbo=0                    cgdl=cglp_25od33          cgsl=cglp_25od33
+ clc=1e-07                 cle=0.6                   cf=cfp_25od33
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.33
+ kt1l=0                    kt2=-0.03                 ute=-1
+ ua1=2.76e-09              ub1=-4.62e-18             uc1=-1.2e-10
+ prt=0                     at=285010.02              lat=-0.11851187
+ wat=6.1829477e-07         pat=-4.9284974e-13        fnoimod=1
+ tnoimod=1                 noia=noiap_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_25od33         rnoib=0
+ noic=noicp_25od33         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25od33            cjd=cjp_25od33            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25od33        cjswd=cjswp_25od33        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25od33      cjswgd=cjswgp_25od33      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-08         jtsswgd=2.148e-08         njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-08
+ dmci=9.25e-08             dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.00656u
+ rshg=15.882                    gbmin=1e-12               rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-07
+ sbref=4.6e-07             wlod=0                    kvth0=1.1e-09
+ lkvth0=-1.5e-07           wkvth0=3e-07              pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 lodeta0=1                 ku0=3.9e-09
+ lku0=1.5e-08              wku0=1.1e-06              pku0=2e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=5e-09              tku0=0                    minr=1e-3
 
 
     4: type=p 
+ lmin=4e-07                lmax=7e-007-(dxlp_25od33+dlmisp_25od33)
+ wmin=1e-005-(dxwp_25od33+dwmisp_25od33)             wmax=0.000901
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.63932657+(dvthp_25od33+vthmisp_25od33)
+ lvth0=1.5704701e-08+dlvthp_25od33                   wvth0=1.2986551e-13+dwvthp_25od33
+ pvth0=-8.8957879e-20+dpvthp_25od33                  k1=0.7812
+ k2=-0.07198665+dk2_25od33 lk2=-4.8018978e-09+dlk2_25od33
+ wk2=0+dwk2_25od33         pk2=0+dpk2_25od33         k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-09           dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-21
+ web=-250                  wec=-3500                 scref=1e-06
+ kvth0we=-0.0057219848     lkvth0we=-2.4799999e-09   wkvth0we=0
+ pkvth0we=0                k2we=0.012490007          lk2we=-6.5995775e-10
+ wk2we=0                   pk2we=0                   xj=9.5e-08
+ ngate=1.842e+20           ndep=7.81e+17             nsd=1e+20
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00016157653+dcitp_25od33
+ lcit=2.2322543e-10+dlcitp_25od33                    wcit=0+dwcitp_25od33
+ pcit=0+dpcitp_25od33      voff=-0.15750999          lvoff=4.1504144e-08
+ wvoff=9.2423767e-14       pvoff=-3.5583151e-20      nfactor=0.63002+dnfactorp_25od33
+ lnfactor=0+dlnfactorp_25od33                        wnfactor=0+dwnfactorp_25od33
+ pnfactor=0+dpnfactorp_25od33                        eta0=0.4
+ leta0=0+dleta0p_25od33    peta0=0+dpeta0p_25od33    etab=-0.01
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015119914        lku0we=-1.0000101e-10
+ wku0we=-1.2986551e-14     pku0we=8.8957877e-21      u0=0.017107032+du0p_25od33
+ lu0=-1.0391671e-09+dlu0p_25od33                     wu0=-1.2986551e-14+dwu0p_25od33
+ pu0=8.8957876e-21+dpu0p_25od33                      ua=2.6060985e-09
+ lua=-6.0560745e-16        ub=-2.0279849e-20         lub=5.9359213e-25
+ uc=1.0153281e-10          luc=6.4850241e-18         vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=1.073944               la0=-1.1458953e-07+dla0p_25od33
+ wa0=1.0675957e-12+dwa0p_25od33                      pa0=-8.0062089e-19+dpa0p_25od33
+ ags=0.079165655           lags=3.8300703e-07        a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.10054287          lketa=2.0140964e-08       wketa=4.6211884e-14
+ pketa=-1.7791575e-20      dwg=0                     dwb=0
+ pclm=0.31873298           lpclm=1.0361791e-07       wpclm=-2.3105941e-13
+ ppclm=8.8957882e-20       pdiblc1=0                 pdiblc2=9.9999987e-06
+ lpdiblc2=8.7908334e-19    pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+08
+ pscbe2=1e-20              fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-07           alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-09           cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25od33
+ cgdo=cgop_25od33          cgbo=0                    cgdl=cglp_25od33
+ cgsl=cglp_25od33          clc=1e-07                 cle=0.6
+ cf=cfp_25od33             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.29578124           lkt1=-2.3439852e-08       kt1l=0
+ kt2=-0.01175              lkt2=-1.250125e-08        ute=-1
+ ua1=2.76e-09              ub1=-4.4619094e-18        lub1=-1.0829208e-25
+ uc1=-2.158125e-10         luc1=6.5631564e-17        wuc1=1.2986551e-22
+ puc1=-8.8957876e-29       prt=0                     at=194125.01
+ lat=-0.056255634          wat=-3.8689803e-07        pat=1.9570733e-13
+ fnoimod=1                 tnoimod=1                 noia=noiap_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp_25od33
+ rnoib=0                   noic=noicp_25od33         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25od33            cjd=cjp_25od33
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25od33        cjswd=cjswp_25od33
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25od33      cjswgd=cjswgp_25od33
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-08         jtsswgd=2.148e-08
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-08             dmci=9.25e-08             dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.00656u                     rshg=15.882                    gbmin=1e-12
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-07             sbref=4.6e-07             wlod=0
+ kvth0=1.1e-09             lkvth0=-1.5e-07           wkvth0=3e-07
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-09               lku0=1.5e-08              wku0=1.1e-06
+ pku0=2e-15                llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-09              tku0=0
+ minr=1e-3
 
 
     5: type=p 
+ lmin=1e-005-(dxlp_25od33+dlmisp_25od33)             lmax=0.000901
+ wmin=1e-006-(dxwp_25od33+dwmisp_25od33)             wmax=1e-005-(dxwp_25od33+dwmisp_25od33)
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.63143426+(dvthp_25od33+vthmisp_25od33)
+ lvth0=0+dlvthp_25od33     wvth0=-1.4667705e-08+dwvthp_25od33
+ pvth0=0+dpvthp_25od33     k1=0.7812                 k2=-0.082798282+dk2_25od33
+ lk2=0+dlk2_25od33         wk2=4.5630905e-09+dwk2_25od33
+ pk2=0+dpk2_25od33         k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-09           dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-21          web=-250
+ wec=-3500                 scref=1e-06               kvth0we=-0.0059483726
+ lkvth0we=-1.0096897e-15   wkvth0we=-2.2000001e-10   pkvth0we=-2.8052217e-29
+ k2we=0.01243991           lk2we=0                   wk2we=-1.600896e-10
+ pk2we=0                   xj=9.5e-08                ngate=1.842e+20
+ ndep=7.81e+17             nsd=1e+20                 phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=5e-06+dcitp_25od33    lcit=0+dlcitp_25od33      wcit=0+dwcitp_25od33
+ pcit=0+dpcitp_25od33      voff=-0.15000001          nfactor=0.63002+dnfactorp_25od33
+ lnfactor=0+dlnfactorp_25od33                        wnfactor=0+dwnfactorp_25od33
+ pnfactor=0+dpnfactorp_25od33                        eta0=0.39239156
+ leta0=0+dleta0p_25od33    weta0=7.6137704e-08       peta0=0+dpeta0p_25od33
+ etab=-0.0077622222        wetab=-2.2393442e-08      ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015010015        lku0we=0                  wku0we=-1.1999996e-09
+ pku0we=0                  u0=0.014247762+du0p_25od33
+ lu0=0+dlu0p_25od33        wu0=2.2393442e-11+dwu0p_25od33
+ pu0=0+dpu0p_25od33        ua=2.0577557e-09          wua=-6.0798196e-16
+ ub=1.6449524e-19          wub=3.120459e-25          uc=1.5486833e-13
+ wuc=-1.1806942e-17        vsat=110000+dvsatp_25od33 lvsat=0+dlvsatp_25od33
+ wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33    a0=1.1
+ la0=1.0096897e-12+dla0p_25od33                      wa0=0+dwa0p_25od33
+ pa0=0+dpa0p_25od33        ags=0.28466888            wags=-3.1910655e-09
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.022152944         wketa=1.0636885e-08
+ dwg=0                     dwb=0                     pclm=0.27279722
+ wpclm=-2.7991803e-08      pdiblc1=0                 pdiblc2=1e-05
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+08          pscbe2=1e-20
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-07
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-09           cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25od33          cgdo=cgop_25od33
+ cgbo=0                    cgdl=cglp_25od33          cgsl=cglp_25od33
+ clc=1e-07                 cle=0.6                   cf=cfp_25od33
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.30317
+ kt1l=0                    kt2=-0.028353891          wkt2=-1.6472616e-08
+ ute=-1                    ua1=2.76e-09              ub1=-4.0448256e-18
+ wub1=5.4863933e-25        uc1=-1.2984622e-10        luc1=7.9081139e-24
+ wuc1=9.8531159e-17        puc1=-7.9136498e-29       prt=0
+ at=200000.01              lat=2.0193794e-07         fnoimod=1
+ tnoimod=1                 noia=noiap_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_25od33         rnoib=0
+ noic=noicp_25od33         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25od33            cjd=cjp_25od33            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25od33        cjswd=cjswp_25od33        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25od33      cjswgd=cjswgp_25od33      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-08         jtsswgd=2.148e-08         njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-08
+ dmci=9.25e-08             dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.00656u
+ rshg=15.882                    gbmin=1e-12               rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-07
+ sbref=4.6e-07             wlod=0                    kvth0=1.1e-09
+ lkvth0=-1.5e-07           wkvth0=3e-07              pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 lodeta0=1                 ku0=3.9e-09
+ lku0=1.5e-08              wku0=1.1e-06              pku0=2e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=5e-09              tku0=0                    minr=1e-3
 
 
     6: type=p 
+ lmin=1.2e-006-(dxlp_25od33+dlmisp_25od33)           lmax=1e-005-(dxlp_25od33+dlmisp_25od33)
+ wmin=1e-006-(dxwp_25od33+dwmisp_25od33)             wmax=1e-005-(dxwp_25od33+dwmisp_25od33)
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.63295251+(dvthp_25od33+vthmisp_25od33)
+ lvth0=1.5159799e-08+dlvthp_25od33                   wvth0=-1.5240646e-08+dwvthp_25od33
+ pvth0=5.720819e-15+dpvthp_25od33                    k1=0.7812
+ k2=-0.082869907+dk2_25od33                          lk2=7.1517316e-10+dlk2_25od33
+ wk2=4.7160852e-09+dwk2_25od33                       pk2=-1.5276529e-15+dpk2_25od33
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-09
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-21          web=-250                  wec=-3500
+ scref=1e-06               kvth0we=-0.0057000002     lkvth0we=-2.4799997e-09
+ wkvth0we=-2.1999999e-10   pkvth0we=-1.5054787e-22   k2we=0.0125
+ lk2we=-6.0000051e-10      wk2we=-9.9999514e-11      pk2we=-5.9999949e-16
+ xj=9.5e-08                ngate=1.842e+20           ndep=7.81e+17
+ nsd=1e+20                 phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5e-06+dcitp_25od33
+ lcit=0+dlcitp_25od33      wcit=0+dwcitp_25od33      pcit=0+dpcitp_25od33
+ voff=-0.15516179          lvoff=5.1540334e-08       wvoff=-2.2616104e-10
+ pvoff=2.258218e-15        nfactor=0.63002+dnfactorp_25od33
+ lnfactor=0+dlnfactorp_25od33                        wnfactor=0+dwnfactorp_25od33
+ pnfactor=0+dpnfactorp_25od33                        eta0=0.39239156
+ leta0=0+dleta0p_25od33    weta0=7.6137704e-08       peta0=0+dpeta0p_25od33
+ etab=-0.0077622222        wetab=-2.2393442e-08      ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015              lku0we=-9.999963e-11      wku0we=-1.1999995e-09
+ pku0we=-1.5054787e-21     u0=0.014241773+du0p_25od33
+ lu0=5.9800543e-11+dlu0p_25od33                      wu0=2.8424403e-11+dwu0p_25od33
+ pu0=-6.0219147e-17+dpu0p_25od33                     ua=2.1129273e-09
+ lua=-5.5088868e-16        wua=-6.170284e-16         pua=9.0328721e-23
+ ub=9.83936e-20            lub=6.6002486e-25         wub=3.2030138e-25
+ pub=-8.2430979e-32        uc=-8.158942e-12          luc=8.3013396e-17
+ wuc=-1.1221185e-17        puc=-5.8487847e-24        vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=1.1272333              la0=-2.7192302e-07+dla0p_25od33
+ wa0=-3.0154806e-09+dwa0p_25od33                     pa0=3.0109574e-14+dpa0p_25od33
+ ags=0.2624499             lags=2.2185656e-07        wags=-5.0078926e-09
+ pags=1.8141018e-14        a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.017971017
+ lketa=-4.1756547e-08      wketa=1.0615777e-08       pketa=2.1076702e-16
+ dwg=0                     dwb=0                     pclm=0.25689003
+ lpclm=1.5883328e-07       wpclm=-3.5228956e-08      ppclm=7.2262976e-14
+ pdiblc1=0                 pdiblc2=1e-05             pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+08          pscbe2=1e-20              fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-07           alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-09
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25od33          cgdo=cgop_25od33          cgbo=0
+ cgdl=cglp_25od33          cgsl=cglp_25od33          clc=1e-07
+ cle=0.6                   cf=cfp_25od33             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.2995571            lkt1=-3.6074841e-08
+ kt1l=0                    kt2=-0.028435252          lkt2=8.1238981e-10
+ wkt2=-1.5658436e-08       pkt2=-8.1295849e-15       ute=-1
+ ua1=2.76e-09              ub1=-3.9599903e-18        lub1=-8.4707974e-25
+ wub1=5.4863933e-25        pub1=-2.1825274e-46       uc1=-1.302681e-10
+ luc1=4.2123916e-18        wuc1=1.0275282e-16        puc1=-4.2153403e-23
+ prt=0                     at=201884.32              lat=-0.018814582
+ wat=0.0013569663          pat=-1.3549308e-08        fnoimod=1
+ tnoimod=1                 noia=noiap_25od33         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_25od33         rnoib=0
+ noic=noicp_25od33         em=3e+7                ef=1.15
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25od33            cjd=cjp_25od33            mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25od33        cjswd=cjswp_25od33        mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25od33      cjswgd=cjswgp_25od33      mjswgs=0.5
+ mjswgd=0.5                tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.00134
+ tcjswg=0.00155            xtis=3                    xtid=3
+ jtsswgs=2.148e-08         jtsswgd=2.148e-08         njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-08
+ dmci=9.25e-08             dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.00656u
+ rshg=15.882                    gbmin=1e-12               rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-07
+ sbref=4.6e-07             wlod=0                    kvth0=1.1e-09
+ lkvth0=-1.5e-07           wkvth0=3e-07              pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 lodeta0=1                 ku0=3.9e-09
+ lku0=1.5e-08              wku0=1.1e-06              pku0=2e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=5e-09              tku0=0                    minr=1e-3
 
 
     7: type=p 
+ lmin=7e-007-(dxlp_25od33+dlmisp_25od33)             lmax=1.2e-006-(dxlp_25od33+dlmisp_25od33)
+ wmin=1e-006-(dxwp_25od33+dwmisp_25od33)             wmax=1e-005-(dxwp_25od33+dwmisp_25od33)
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.62725748+(dvthp_25od33+vthmisp_25od33)
+ lvth0=8.4111864e-09+dlvthp_25od33                   wvth0=-5.1888204e-09+dwvthp_25od33
+ pvth0=-6.1905943e-15+dpvthp_25od33                  k1=0.7812
+ k2=-0.086622656+dk2_25od33                          lk2=5.1621814e-09+dlk2_25od33
+ wk2=6.8892561e-09+dwk2_25od33                       pk2=-4.1028604e-15+dpk2_25od33
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-09
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-21          web=-250                  wec=-3500
+ scref=1e-06               kvth0we=-0.0056999997     lkvth0we=-2.4800003e-09
+ wkvth0we=-2.2000027e-10   pkvth0we=1.8177316e-22    k2we=0.012499998
+ lk2we=-5.9999852e-10      wk2we=-9.9997121e-11      pk2we=-6.0000233e-16
+ xj=9.5e-08                ngate=1.842e+20           ndep=7.81e+17
+ nsd=1e+20                 phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00023765976+dcitp_25od33
+ lcit=2.8755181e-10+dlcitp_25od33                    wcit=2.4435838e-10+dwcitp_25od33
+ pcit=-2.8956467e-16+dpcitp_25od33                   voff=-0.13223414
+ lvoff=2.4371068e-08       wvoff=7.6005582e-09       pvoff=-7.0164443e-15
+ nfactor=0.63002+dnfactorp_25od33                    lnfactor=0+dlnfactorp_25od33
+ wnfactor=0+dwnfactorp_25od33                        pnfactor=0+dpnfactorp_25od33
+ eta0=0.39239156           leta0=0+dleta0p_25od33    weta0=7.6137704e-08
+ peta0=0+dpeta0p_25od33    etab=-0.0077622222        wetab=-2.2393442e-08
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015              lku0we=-9.999965e-11
+ wku0we=-1.2000008e-09     pku0we=-1.8628298e-29     u0=0.012521968+du0p_25od33
+ lu0=2.0977698e-09+dlu0p_25od33                      wu0=-1.2977e-10+dwu0p_25od33
+ pu0=1.2724122e-16+dpu0p_25od33                      ua=1.478354e-09
+ lua=2.010807e-16          wua=-5.9755781e-16        pua=6.7256073e-23
+ ub=4.2353689e-19          lub=2.7473006e-25         wub=2.9709231e-25
+ pub=-5.4928234e-32        uc=-8.7644947e-12         luc=8.3730976e-17
+ wuc=-4.4221465e-18        puc=-1.3905646e-23        vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=0.86289418             la0=4.1318781e-08+dla0p_25od33
+ wa0=2.8001512e-07+dwa0p_25od33                      pa0=-3.0528169e-13+dpa0p_25od33
+ ags=0.19187643            lags=3.0548612e-07        wags=1.8128428e-08
+ pags=-9.2755213e-15       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.027155712
+ lketa=-3.0872683e-08      wketa=1.0701602e-08       pketa=1.090639e-16
+ dwg=0                     dwb=0                     pclm=0.28259594
+ lpclm=1.2837178e-07       wpclm=6.1033327e-08       ppclm=-4.1807829e-14
+ pdiblc1=0                 pdiblc2=1e-05             pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+08          pscbe2=1e-20              fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-07           alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-09
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25od33          cgdo=cgop_25od33          cgbo=0
+ cgdl=cglp_25od33          cgsl=cglp_25od33          clc=1e-07
+ cle=0.6                   cf=cfp_25od33             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.33                 kt1l=0
+ kt2=-0.027119371          lkt2=-7.4692842e-10       wkt2=-2.8826451e-08
+ pkt2=7.4745127e-15        ute=-1                    ua1=2.76e-09
+ ub1=-4.6640954e-18        lub1=-1.2715221e-26       wub1=4.4126278e-25
+ pub1=1.2724122e-31        uc1=-1.2855279e-10        luc1=2.1797542e-18
+ wuc1=8.5587759e-17        puc1=-2.18128e-23         prt=0
+ at=284330.92              lat=-0.11651381           wat=0.0067964036
+ pat=-1.9995041e-08        fnoimod=1                 tnoimod=1
+ noia=noiap_25od33         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_25od33         rnoib=0                   noic=noicp_25od33
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25od33
+ cjd=cjp_25od33            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25od33
+ cjswd=cjswp_25od33        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25od33
+ cjswgd=cjswgp_25od33      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-08
+ jtsswgd=2.148e-08         njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-08             dmci=9.25e-08
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.00656u                     rshg=15.882
+ gbmin=1e-12               rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-07             sbref=4.6e-07
+ wlod=0                    kvth0=1.1e-09             lkvth0=-1.5e-07
+ wkvth0=3e-07              pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-09               lku0=1.5e-08
+ wku0=1.1e-06              pku0=2e-15                llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-09
+ tku0=0                    minr=1e-3
 
 
     8: type=p 
+ lmin=4e-07                lmax=7e-007-(dxlp_25od33+dlmisp_25od33)
+ wmin=1e-006-(dxwp_25od33+dwmisp_25od33)             wmax=1e-005-(dxwp_25od33+dwmisp_25od33)
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.63687342+(dvthp_25od33+vthmisp_25od33)
+ lvth0=1.4998107e-08+dlvthp_25od33                   wvth0=-2.4548519e-08+dwvthp_25od33
+ pvth0=7.070799e-15+dpvthp_25od33                    k1=0.7812
+ k2=-0.070814344+dk2_25od33                          lk2=-5.6665125e-09+dlk2_25od33
+ wk2=-1.1731269e-08+dwk2_25od33                      pk2=8.6521996e-15+dpk2_25od33
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-09
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-21          web=-250                  wec=-3500
+ scref=1e-06               kvth0we=-0.0057000001     lkvth0we=-2.4799999e-09
+ wkvth0we=-2.2000015e-10   pkvth0we=9.8428508e-23    k2we=0.0125
+ lk2we=-5.9999972e-10      wk2we=-1.000005e-10       pk2we=-6.0000001e-16
+ xj=9.5e-08                ngate=1.842e+20           ndep=7.81e+17
+ nsd=1e+20                 phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-8.0693713e-05+dcitp_25od33
+ lcit=1.8003007e-10+dlcitp_25od33                    wcit=-8.0939434e-10+dwcitp_25od33
+ pcit=4.3225593e-16+dpcitp_25od33                    voff=-0.15687837
+ lvoff=4.1252365e-08       wvoff=-6.3205544e-09      pvoff=2.5195179e-15
+ nfactor=0.63002+dnfactorp_25od33                    lnfactor=0+dlnfactorp_25od33
+ wnfactor=0+dwnfactorp_25od33                        pnfactor=0+dpnfactorp_25od33
+ eta0=0.39239156           leta0=0+dleta0p_25od33    weta0=7.6137704e-08
+ peta0=0+dpeta0p_25od33    etab=-0.0077622222        wetab=-2.2393442e-08
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.014999999        lku0we=-1.0000013e-10
+ wku0we=-1.2000008e-09     pku0we=-8.8233067e-30     u0=0.017107818+du0p_25od33
+ lu0=-1.0435373e-09+dlu0p_25od33                     wu0=-7.8727878e-12+dwu0p_25od33
+ pu0=4.374163e-17+dpu0p_25od33                       ua=2.6580301e-09
+ lua=-6.0699746e-16        wua=-5.1967997e-16        pua=1.390975e-23
+ ub=-4.2391903e-20         lub=5.9389128e-25         wub=2.2127532e-25
+ pub=-2.9935948e-33        uc=1.0231614e-10          luc=7.6407424e-18
+ wuc=-7.8387488e-18        puc=-1.1565273e-23        vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=1.1269911              la0=-1.3958761e-07+dla0p_25od33
+ wa0=-5.3084138e-07+dwa0p_25od33                     pa0=2.5015501e-13+dpa0p_25od33
+ ags=0.055509963           lags=3.9889715e-07        wags=2.3672251e-07
+ pags=-1.5901247e-13       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.10132317
+ lketa=1.9932024e-08       wketa=7.808488e-09        pketa=2.090847e-15
+ dwg=0                     dwb=0                     pclm=0.30705568
+ lpclm=1.1161686e-07       wpclm=1.1685456e-07       ppclm=-8.0045371e-14
+ pdiblc1=0                 pdiblc2=1.0002551e-05     lpdiblc2=-1.7475622e-15
+ wpdiblc2=-2.5542557e-14   ppdiblc2=1.7496652e-20    pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+08          pscbe2=1e-20              fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-07           alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-09
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25od33          cgdo=cgop_25od33          cgbo=0
+ cgdl=cglp_25od33          cgsl=cglp_25od33          clc=1e-07
+ cle=0.6                   cf=cfp_25od33             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.29394346           lkt1=-2.4698728e-08
+ wkt1=-1.8390627e-08       pkt1=1.2597579e-14        kt1l=0
+ kt2=-0.0085048729         lkt2=-1.349786e-08        wkt2=-3.247399e-08
+ pkt2=9.9730768e-15        ute=-1                    ua1=2.76e-09
+ ub1=-4.5426131e-18        lub1=-9.593062e-26        wub1=8.0760195e-25
+ pub1=-1.2370111e-31       uc1=-2.2935104e-10        luc1=7.1226558e-17
+ wuc1=1.3548031e-16        puc1=-5.5989195e-23       prt=0
+ at=195341.77              lat=-0.055556239          wat=-0.012176429
+ pat=-6.9986509e-09        fnoimod=1                 tnoimod=1
+ noia=noiap_25od33         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_25od33         rnoib=0                   noic=noicp_25od33
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25od33
+ cjd=cjp_25od33            mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25od33
+ cjswd=cjswp_25od33        mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25od33
+ cjswgd=cjswgp_25od33      mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-08
+ jtsswgd=2.148e-08         njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-08             dmci=9.25e-08
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.00656u                     rshg=15.882
+ gbmin=1e-12               rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-07             sbref=4.6e-07
+ wlod=0                    kvth0=1.1e-09             lkvth0=-1.5e-07
+ wkvth0=3e-07              pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-09               lku0=1.5e-08
+ wku0=1.1e-06              pku0=2e-15                llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-09
+ tku0=0                    minr=1e-3
 
 
     9: type=p 
+ lmin=1e-005-(dxlp_25od33+dlmisp_25od33)             lmax=0.000901
+ wmin=6e-007-(dxwp_25od33+dwmisp_25od33)             wmax=1e-006-(dxwp_25od33+dwmisp_25od33)
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.63370825+(dvthp_25od33+vthmisp_25od33)
+ lvth0=0+dlvthp_25od33     wvth0=-1.2377792e-08+dwvthp_25od33
+ pvth0=0+dpvthp_25od33     k1=0.7812                 k2=-0.083807352+dk2_25od33
+ lk2=0+dlk2_25od33         wk2=5.5792242e-09+dwk2_25od33
+ pk2=0+dpk2_25od33         k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-09           dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-21          web=-250
+ wec=-3500                 scref=1e-06               kvth0we=-0.0059483726
+ lkvth0we=-2.5418938e-15   wkvth0we=-2.1999998e-10   pkvth0we=1.5429296e-21
+ k2we=0.012439911          lk2we=0                   wk2we=-1.600907e-10
+ pk2we=0                   xj=9.5e-08                ngate=1.842e+20
+ ndep=7.81e+17             nsd=1e+20                 phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=2.7283025e-06+dcitp_25od33                      lcit=0+dlcitp_25od33
+ wcit=2.2875994e-12+dwcitp_25od33                    pcit=0+dpcitp_25od33
+ voff=-0.15000003          wvoff=1.5281225e-14       nfactor=0.63002+dnfactorp_25od33
+ lnfactor=0+dlnfactorp_25od33                        wnfactor=0+dwnfactorp_25od33
+ pnfactor=0+dpnfactorp_25od33                        eta0=0.556015
+ leta0=0+dleta0p_25od33    weta0=-8.8631105e-08      peta0=0+dpeta0p_25od33
+ etab=-0.0224125           wetab=-7.6406125e-09      ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015010014        lku0we=0                  wku0we=-1.200001e-09
+ pku0we=0                  u0=0.01448245+du0p_25od33 lu0=0+dlu0p_25od33
+ wu0=-2.1393715e-10+dwu0p_25od33                     pu0=0+dpu0p_25od33
+ ua=1.912285e-09           wua=-4.61493e-16          ub=2.5675036e-19
+ wub=2.1914499e-25         uc=-1.5360714e-11         luc=-3.0644082e-24
+ wuc=3.8172492e-18         puc=3.0858592e-30         vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=1.1                    la0=2.5418938e-12+dla0p_25od33
+ wa0=1.7124918e-15+dwa0p_25od33                      pa0=-1.5429295e-18+dpa0p_25od33
+ ags=0.26890475            wags=1.2683417e-08        a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.016063589         lketa=-3.0644082e-15      wketa=4.5049044e-09
+ pketa=3.0858592e-21       dwg=0                     dwb=0
+ pclm=0.2313425            wpclm=1.3753103e-08       pdiblc1=0
+ pdiblc2=1e-05             pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+08
+ pscbe2=1e-20              fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-07           alpha1=0.296              beta0=26.3
+ agidl=0                   bgidl=2.041e-09           cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25od33
+ cgdo=cgop_25od33          cgbo=0                    cgdl=cglp_25od33
+ cgsl=cglp_25od33          clc=1e-07                 cle=0.6
+ cf=cfp_25od33             ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.31329133           wkt1=1.019218e-08         kt1l=0
+ kt2=-0.04275746           wkt2=-1.9682218e-09       ute=-1
+ ua1=2.76e-09              ub1=-3.7018275e-18        wub1=2.0324029e-25
+ uc1=-3.1999968e-11        luc1=-1.6261053e-22       wuc1=-1.9968342e-23
+ puc1=9.2575773e-29        prt=0                     at=200000.01
+ lat=6.6159918e-07         wat=5.1374754e-10         pat=-4.6287886e-13
+ fnoimod=1                 tnoimod=1                 noia=noiap_25od33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp_25od33
+ rnoib=0                   noic=noicp_25od33         em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25od33            cjd=cjp_25od33
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25od33        cjswd=cjswp_25od33
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25od33      cjswgd=cjswgp_25od33
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-08         jtsswgd=2.148e-08
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-08             dmci=9.25e-08             dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.00656u                     rshg=15.882                    gbmin=1e-12
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-07             sbref=4.6e-07             wlod=0
+ kvth0=1.1e-09             lkvth0=-1.5e-07           wkvth0=3e-07
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-09               lku0=1.5e-08              wku0=1.1e-06
+ pku0=2e-15                llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-09              tku0=0
+ minr=1e-3
 
 
     10: type=p 
+ lmin=1.2e-006-(dxlp_25od33+dlmisp_25od33)           lmax=1e-005-(dxlp_25od33+dlmisp_25od33)
+ wmin=6e-007-(dxwp_25od33+dwmisp_25od33)             wmax=1e-006-(dxwp_25od33+dwmisp_25od33)
+ xl=-1.5e-08+(dxlp_25od33+dlmisp_25od33)             xw=7e-09+(dxwp_25od33+dwmisp_25od33)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25od33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 wpemod=1                  tnom=25
+ toxe=(toxp_25od33+toxmisp_25od33)                   toxm=5.9e-09
+ dtox=3.946e-10            epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    dlc=0
+ dwc=0                     xpart=1                   toxref=3e-09
+ dlcig=2.5e-09             vth0=-0.63550938+(dvthp_25od33+vthmisp_25od33)
+ lvth0=1.798431e-08+dlvthp_25od33                    wvth0=-1.2665878e-08+dwvthp_25od33
+ pvth0=2.8765369e-15+dpvthp_25od33                   k1=0.7812
+ k2=-0.083913235+dk2_25od33                          lk2=1.0572418e-09+dlk2_25od33
+ wk2=5.766717e-09+dwk2_25od33                        pk2=-1.872116e-15+dpk2_25od33
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-09
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-21          web=-250                  wec=-3500
+ scref=1e-06               kvth0we=-0.0057000004     lkvth0we=-2.4799996e-09
+ wkvth0we=-2.199998e-10    pkvth0we=-2.0546693e-22   k2we=0.012500001
+ lk2we=-5.9999961e-10      wk2we=-1.0000052e-10      pk2we=-6.000004e-16
+ xj=9.5e-08                ngate=1.842e+20           ndep=7.81e+17
+ nsd=1e+20                 phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=2.4223978e-06+dcitp_25od33
+ lcit=3.0544586e-12+dlcitp_25od33                    wcit=2.5956454e-12+dwcitp_25od33
+ pcit=-3.0758398e-18+dpcitp_25od33                   voff=-0.1554477
+ lvoff=5.4394991e-08       wvoff=6.1750015e-11       pvoff=-6.1642132e-16
+ nfactor=0.63002+dnfactorp_25od33                    lnfactor=0+dlnfactorp_25od33
+ wnfactor=0+dwnfactorp_25od33                        pnfactor=0+dpnfactorp_25od33
+ eta0=0.556015             leta0=0+dleta0p_25od33    weta0=-8.8631105e-08
+ peta0=0+dpeta0p_25od33    etab=-0.0224125           wetab=-7.6406125e-09
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.014999998        lku0we=-1.0000317e-10
+ wku0we=-1.2000012e-09     pku0we=2.0546693e-21      u0=0.014502885+du0p_25od33
+ lu0=-2.0403865e-10+dlu0p_25od33                     wu0=-2.3451471e-10+dwu0p_25od33
+ pu0=2.0546692e-16+dpu0p_25od33                      ua=1.9712038e-09
+ lua=-5.8830411e-16        wua=-4.7431283e-16        pua=1.2800606e-22
+ ub=1.9071776e-19          lub=6.593355e-25          wub=2.2733095e-25
+ pub=-8.1736797e-32        uc=-2.3913898e-11         luc=8.5403541e-17
+ wuc=4.6440558e-18         puc=-8.2556604e-24        vsat=110000+dvsatp_25od33
+ lvsat=0+dlvsatp_25od33    wvsat=0+dwvsatp_25od33    pvsat=0+dpvsatp_25od33
+ a0=1.1242389              la0=-2.4202262e-07+dla0p_25od33
+ wa0=-1.4046571e-13+dwa0p_25od33                     pa0=-1.2328015e-19+dpa0p_25od33
+ ags=0.24285855            lags=2.600713e-07         wags=1.4720595e-08
+ pags=-2.0341225e-14       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.01158548
+ lketa=-4.4713925e-08      wketa=4.1855409e-09       pketa=3.1888473e-15
+ dwg=0                     dwb=0                     pclm=0.20303766
+ lpclm=2.8262379e-07       wpclm=1.900038e-08        ppclm=-5.2394065e-14
+ pdiblc1=0                 pdiblc2=1e-05             pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+08          pscbe2=1e-20              fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-07           alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-09
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25od33          cgdo=cgop_25od33          cgbo=0
+ cgdl=cglp_25od33          cgsl=cglp_25od33          clc=1e-07
+ cle=0.6                   cf=cfp_25od33             ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.30942294           lkt1=-3.8625854e-08
+ wkt1=9.9349068e-09        pkt1=2.5688708e-15        kt1l=0
+ kt2=-0.042561598          lkt2=-1.9556786e-09       wkt2=-1.4332053e-09
+ pkt2=-5.34214e-15         ute=-1                    ua1=2.76e-09
+ ub1=-3.6012577e-18        lub1=-1.0041895e-24       wub1=1.8739557e-25
+ pub1=1.5820953e-31        uc1=-2.822953e-11         luc1=-3.7647991e-17

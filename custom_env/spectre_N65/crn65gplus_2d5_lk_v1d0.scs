//
simulator lang=spectre insensitive=yes  
library tsmclib 
//   **********************************************
//   *             TSMC SPICE MODEL               *
//   **********************************************
//   
//     PROCESS :  65nm Mixed Signal RF SALICIDE Low-K IMD (1.0/2.5/over-drive 3.3V) (CRN65GPLUS) 
//     MODEL   :  BSIM4 ( V4.5 )
//     DOC. NO.:  T-N65-CM-SP-018  
//     VERSION :  V1.0
//     DATE    :  Nov. 22, 2007
//     SPECTRE VERSION : 6.0.2.247 
// 
// ***********************************************************************************
//      Updated history:	
// 
//  1. crn65gplus_2d5_lk_v1d0p1 (10/05/2007) :  
//        1. Add the RF MOS model based on Si & CLN65G+ 1.0V/2.5V model v1.2
//           Si SVT     ---> N9K007 #2(NMOS), N9K007 #3(PMOS)
//	     Si IO 2.5V ---> N9K007 #21 (NMOS), N9K007 #23(PMOS)
//        2. Add the T-noise model for xxx_MAC devices based on Si SVT
//        3. Add RF MOSVAR model (SVT & 2.5V)
//        4. Add RF Resistor model 
//        5. Add RF Junction varactor model 
//        6. Add RF MIM model 
//        7. Add RF MOM model 
//        8. Add RF INDUCTOR model
// 
//  2. crn65gplus_2d5_lk_v1d0p2 (10/12/2007) : 
//        1. Update the BB RTMOM Model Corner from +/- 20% to +/- 15% 
//        2. Add the BB UDC MIMCAP Model
//        3. Update nch_25 xj & tnoimod
//                  pch_25 xj
//                  nch_33 rshg & xgl
//                  pch_33 rshg & xgl
//        4. Updated the flicker noise corner parameters: 
//                  a. modified the flicker noise corner model of Core and IO MOS
//                  b. fixed the flicker noise parameters of resistor      
//
//  3. crn65gplus_2d5_lk_v1d0 (11/22/2007) :
//        1. Clone model card code from crn65gplus_2d5_lk_v1d0p2 and named as crn65gplus_2d5_lk_v1d0 
//        2. Update noiseflag definition of flicker noise model
//
// *****************************************************************************
//       THIS MODEL LIB CONTAINS :                                            *
//                                                                            *
//   A RF models                                                              *
//                                                                            *
//       1.LIB TT_RFMOS                                                       *
//             SS_RFMOS                                                       *
//             FF_RFMOS                                                       *
//             FS_RFMOS                                                       *
//             MC_RFMOS                                                       *
//   ( 1.0V Standard-Vt devices with different geometric and corner models)   *
//									      *
//       2.LIB TT_RFMOS_18                                                    *
//             SS_RFMOS_18                                                    *
//             FF_RFMOS_18                                                    *
//             SF_RFMOS_18                                                    *
//             FS_RFMOS_18                                                    *
//             MC_RFMOS_18                                                    *
//   ( 2.5V under-drive 1.8V devices with different geometric and corner models)  *
//									      *
//       3.LIB TT_RFMOS_25                                                    *
//             SS_RFMOS_25                                                    *
//             FF_RFMOS_25                                                    *
//             SF_RFMOS_25                                                    *
//             FS_RFMOS_25                                                    *
//             MC_RFMOS_25                                                    *
//   ( 2.5V devices with different geometric and corner models)               *
//									      *
//       4.LIB TT_RFMOS_33                                                    *
//             SS_RFMOS_33                                                    *
//             FF_RFMOS_33                                                    *
//             SF_RFMOS_33                                                    *
//             FS_RFMOS_33                                                    *
//             MC_RFMOS_33                                                    *
//   ( 2.5V over-drive 3.3V devices with different geometric and corner models) *
//                                                                            *
//       5. MIM capacitor corner model                                        *
//                                                                            *
//          a.LIB TT_RFMIM:Typical model                                      *
//          b.LIB FF_RFMIM:Fast corner model                                  *
//          c.LIB SS_RFMIM:Slow corner model                                  *
//          d.LIB MC_RFMIM:Statistical model                                  *
//                                                                            *
//       6. Inductor corner model                                             *
//                                                                            *
//          a.LIB TT_RFIND:Typical model                                      *
//          b.LIB FF_RFIND:Fast corner model                                  *
//          c.LIB SS_RFIND:Slow corner model                                  *
//          d.LIB MC_RFIND:Statistical model                                  *
//                                                                            *
//       7. 1.0V MOS varactor corner model                                    *
//                                                                            *
//          a.LIB TT_RFMVAR:Typical model                                     *
//          b.LIB FF_RFMVAR:Fast corner model                                 *
//          c.LIB SS_RFMVAR:Slow corner model                                 *
//          d.LIB MC_RFMVAR:Statistical model                                 *
//                                                                            *
//       8. 2.5V MOS varactor corner model                                    *
//                                                                            *
//          a.LIB TT_RFMVAR_25:Typical model                                  *
//          b.LIB FF_RFMVAR_25:Fast corner model                              *
//          c.LIB SS_RFMVAR_25:Slow corner model                              *
//          d.LIB MC_RFMVAR_25:Statistical model                              *
//                                                                            *
//       9. P+/NW Junction varactor corner model                              *
//                                                                            *
//          a.LIB TT_RFJVAR:Typical model                                     *
//          b.LIB FF_RFJVAR:Fast corner model                                 *
//          c.LIB SS_RFJVAR:Slow corner model                                 *
//          d.LIB MC_RFJVAR:Statistical model                                 *
//                                                                            *
//       10. Resistor corner model                                            *
//                                                                            *
//          i). Salicided poly resistor                                       *
//                                                                            *
//             (a).LIB TT_RFRES_SA:Typical model                              *
//             (b).LIB FF_RFRES_SA:Fast corner model                          *
//             (c).LIB SS_RFRES_SA:Slow corner model                          *
//             (d).LIB MC_RFRES_SA:Statistical model                          *
//                                                                            *
//          ii). Non-salicided P+ poly resistor                               *
//                                                                            *
//             (a).LIB TT_RFRES_RPO:Typical model                             *
//             (b).LIB FF_RFRES_RPO:Fast corner model                         *
//             (c).LIB SS_RFRES_RPO:Slow corner model                         *
//             (d).LIB MC_RFRES_RPO:Statistical model                         *
//                                                                            *
//       11. RTMOM corner model                                               *
//                                                                            *
//          a.LIB TT_RFRTMOM:Typical model                                    *
//          b.LIB FF_RFRTMOM:Fast corner model                                *
//          c.LIB SS_RFRTMOM:Slow corner model                                *
//          d.LIB MC_RFRTMOM:Statistical model                                *
//                                                                            *
//*****************************************************************************
//   B: BASEBAND MODELS    
//
//       THIS MODEL LIB CONTAINS :                                            *
//                                                                            *
//       1.LIB stat                                                           *
//   ( Common statistical library )                                           *
//                                                                            *
//       2.LIB MC                                                             *
//   ( 1.0V Standard-Vt statistical models with different device geometries)  *
//                                                                            *
//       3.LIB MC_hvt                                                         *
//   ( 1.0V High-Vt statistical models with different device geometries)      *
//                                                                            *
//       4.LIB MC_lvt                                                         *
//   ( 1.0V Low-Vt statistical models with different device geometries)       *
//                                                                            *
//       5.LIB MC_18                                                          *
//   ( 2.5V under-drive 1.8V I/O statistical models with different device     *
//     geometries)                                                            *
//                                                                            *
//       6.LIB MC_25                                                          *
//   ( 2.5V I/O statistical models with different device                      *
//     geometries)                                                            *
//                                                                            *
//       7.LIB MC_25ud18                                                      *
//   ( 2.5V under-drive 1.8V I/O statistical models with different device     *
//     geometries)                                                            *
//                                                                            *
//       8.LIB MC_25od33                                                      *
//   ( 2.5V over-drive 3.3V I/O statistical models with different device      *
//     geometries)                                                            *
//                                                                            *
//       9.LIB MC_33                                                          *
//   ( 2.5V over-drive 3.3V I/O statistical models with different device      *
//     geometries)                                                            *
//                                                                            *
//       10.LIB MC_na                                                         *
//   ( 1.0V Native statistical models with different device geometries)       *
//                                                                            *
//       11.LIB MC_na25                                                       *
//   ( 2.5V Native I/O statistical models with different device geometries)   *
//                                                                            *
//       12.LIB MC_na25od33                                                   *
//   ( 2.5V over-drive 3.3V Native I/O statistical models with different      *
//      device geometries)                                                    *
//                                                                            *
//       13.LIB MC_na33                                                       *
//   ( 2.5V over-drive 3.3V Native I/O statistical models with different      *
//      device geometries)                                                    *
//                                                                            *									
//       14.LIB TT                                                            *									
//             SS                                                             *									
//             FF                                                             *									
//             SF                                                             *									
//             FS                                                             *									
//   ( 1.0V Standard-Vt devices with different geometric,mismatch and         *
//     corner models)							     *									  								
//									     *
//      15.LIB TT_hvt                                                         *									
//             SS_hvt                                                         *									
//             FF_hvt                                                         *									
//             SF_hvt                                                         *									
//             FS_hvt                                                         *									
//   ( 1.0V High-Vt devices with different geometric,mismatch and             *
//     corner models)							     *								
//									     *
//       16.LIB TT_lvt                                                        *									
//              SS_lvt                                                        *									
//              FF_lvt                                                        *									
//              SF_lvt                                                        *									
//              FS_lvt                                                        *									
//   ( 1.0V Low-Vt devices with different geometric,mismatch and              *
//     corner models)							     *									
//									     *
//       17.LIB TT_18                                                         *									
//              SS_18                                                         *									
//              FF_18                                                         *									
//              SF_18                                                         *									
//              FS_18                                                         *									
//   ( 2.5V under-drive 1.8V  IO devices with different geometric,mismatch    *
//     and corner models)                                                     *									
//									     *
//       18.LIB TT_25                                                         *									
//              SS_25                                                         *									
//              FF_25                                                         *									
//              SF_25                                                         *									
//              FS_25                                                         *									
//   ( 2.5V IO devices with different geometric,mismatch and corner models)   *									
//									     *
//       19.LIB TT_25ud18                                                     *									
//              SS_25ud18                                                     *									
//              FF_25ud18                                                     *									
//              SF_25ud18                                                     *									
//              FS_25ud18                                                     *									
//   ( 2.5V under-drive 1.8V IO devices with different geometric,mismatch     *
//     and corner models)                                                     *									
//									     *
//       20.LIB TT_25od33                                                     *									
//              SS_25od33                                                     *									
//              FF_25od33                                                     *									
//              SF_25od33                                                     *									
//              FS_25od33                                                     *									
//   ( 2.5V over-drive 3.3V IO devices with different geometric,mismatch      *
//     and corner models)                                                     *									
//									     *
//       21.LIB TT_33                                                         *
//              SS_33                                                         *
//              FF_33                                                         *
//              SF_33                                                         *
//              FS_33                                                         *
//									     *
//   ( 3.3V over-drive devices with different geometric,mismatch and corner   *
//      models)                                                               *
//									     *
//       22.LIB TT_na                                                         *									
//              SS_na                                                         *									
//              FF_na                                                         *									
//              SF_na                                                         *									
//              FS_na                                                         *									
//  ( 1.0V native devices with different geometric,mismatch and corner models)*									
//									     *
//       23.LIB TT_na25                                                       *									
//              SS_na25                                                       *									
//              FF_na25                                                       *									
//              SF_na25                                                       *									
//              FS_na25                                                       *									
// ( 2.5V native devices with different geometric,mismatch and corner models) *									
//									     *                                                                                 *                                                                            *
//       24.LIB TT_na25od33                                                   *									
//              SS_na25od33                                                   *									
//              FF_na25od33                                                   *									
//              SF_na25od33                                                   *									
//              FS_na25od33                                                   *									
// ( 2.5V over-drive 3.3V native devices with different geometric,mismatch    *
//   and corner models)   						     *			
//									     *                                                                                 *                                                                            *
//       25.LIB TT_na33                                                       *									
//              SS_na33                                                       *									
//              FF_na33                                                       *									
//              SF_na33                                                       *									
//              FS_na33                                                       *									
// ( 2.5V over-drive 3.3V native devices with different geometric,mismatch    *
//   and corner models)   						     *			
//									     *                                                                                 *                                                                            *
//       26.LIB stat_bip_dio                                                  *
//   ( Common BJT and diode statistical library )                             *
//                                                                            *
//       27.LIB mc_bip                                                        *
//   ( 1.0V P+/NW/PSUB 10x10, 5x5, and 2x2 vertical PNP bipolar statistical   *
//     model)                                                                 *
//                                                                            *
//       28.LIB  TT_BIP                                                       *									
//               SS_BIP                                                       *									
//               FF_BIP                                                       *									
//   ( 1.0V P+/NW/PSUB 10x10, 5x5, and 2x2 vertical PNP bipolar mismatch and  *
//     corner models)                                                         *
//		                                                             *
//       29.LIB mc_bip_npn                                                    *
//   ( 1.0V N+/PW/PSUB 10x10, 5x5, and 2x2 vertical NPN bipolar statistical   *
//     model)                                                                 *
//                                                                            *									
//       30.LIB  TT_BIP_NPN                                                   *									
//               SS_BIP_NPN                                                   *									
//               FF_BIP_NPN                                                   *									
//   ( 1.0V N+/PW/DNW 10x10, 5x5, and 2x2 vertical NPN bipolar mismtach and   *
//     corner models)                                                         *	
//									     *  									
//       31.LIB mc_dio                                                        *
//   ( 1.0V Standard-Vt P+/NW, N+/PW, and NW/PSUB diode statistical model)    *
//                                                                            *								
//       32.LIB  TT_DIO                                                       *									
//               SS_DIO                                                       *									
//               FF_DIO                                                       *		
//   ( 1.0V Standard-Vt P+/NW, N+/PW, NW/PSUB diode )		             *
//                                                                            *
//       33.LIB mc_dio_hvt                                                    *
//   ( 1.0V High-Vt P+/NW, and N+/PW diode statistical model)                 *
//                                                                            *	
//       34.LIB TT_DIO_hvt                                                    *		
//              SS_DIO_hvt                                                    *		
//              FF_DIO_hvt                                                    *		
//   ( 1.0V High-Vt P+/NW, and N+/PW diode )                                  *		
//                                                                            *
//       35.LIB mc_dio_lvt                                                    *
//   ( 1.0V Low-Vt P+/NW, and N+/PW diode statistical model)                  *
//                                                                            *		
//       36.LIB TT_DIO_lvt                                                    *		
//              SS_DIO_lvt                                                    *		
//              FF_DIO_lvt                                                    *		
//   ( 1.0V Low-Vt P+/NW, and N+/PW diode )                                   *		
//                                                                            *
//       37.LIB mc_dio_18                                                     *
//   ( 2.5V under-drive 1.8V P+/NW, and N+/PW diode statistical model)        *
//                                                                            *		
//       38.LIB TT_DIO_18                                                     *		
//              SS_DIO_18                                                     *		
//              FF_DIO_18                                                     *		
//   ( 2.5V under-drive 1.8V IO P+/NW, and N+/PW diode )                      *		
//                                                                            *
//       39.LIB mc_dio_25                                                     *
//   ( 2.5V P+/NW, and N+/PW diode statistical model)                         *
//                                                                            *		
//       40.LIB TT_DIO_25                                                     *		
//              SS_DIO_25                                                     *		
//              FF_DIO_25                                                     *		
//   ( 2.5V IO P+/NW, and N+/PW diode )                                       *		
//                                                                            *
//       41.LIB mc_dio_25ud18                                                 *
//   ( 2.5V under-drive 1.8V P+/NW, and N+/PW diode statistical model)        *
//                                                                            *		
//       42.LIB TT_DIO_25ud18                                                 *		
//              SS_DIO_25ud18                                                 *		
//              FF_DIO_25ud18                                                 *		
//   ( 2.5V under-drive 1.8V IO P+/NW, and N+/PW diode )                      *		
//                                                                            *
//       43.LIB mc_dio_25od33                                                 *
//   ( 2.5V over-drive 3.3V P+/NW, and N+/PW diode statistical model)         *
//                                                                            *		
//       44.LIB TT_DIO_25od33                                                 *		
//              SS_DIO_25od33                                                 *		
//              FF_DIO_25od33                                                 *		
//   ( 2.5V over-drive 3.3V IO P+/NW, and N+/PW diode )                       *		
//                                                                            *
//       45.LIB mc_dio_33                                                     *
//   ( 2.5V over-drive 3.3V P+/NW, and N+/PW diode statistical model)         *
//                                                                            *
//       46.LIB TT_DIO_33                                                     *
//              SS_DIO_33                                                     *
//              FF_DIO_33                                                     *
//   ( 2.5V over-drive 3.3V P+/NW, and N+/PW diode )                          *
//                                                                            *
//       47.LIB mc_dio_NA                                                     *
//   ( 1.0V native N+/PW diode statistical model)                             *
//                                                                            *		
//       48.LIB TT_DIO_na                                                     *		
//              SS_DIO_na                                                     *		
//              FF_DIO_na                                                     *		
//   ( 1.0V native N+/PW diode )                                   	     *	
//                                                                            *
//       49.LIB mc_dio_na25                                                   *
//   ( 2.5V native N+/PW diode statistical model)                             *
//                                                                            *
//       50.LIB TT_DIO_na25                                                   *
//              SS_DIO_na25                                                   *
//              FF_DIO_na25                                                   *
//   ( 2.5V native IO N+/PW diode )                                	     *
//                                                                            *
//       51.LIB mc_dio_na25od33                                               *
//   ( 2.5V over-drive native N+/PW diode statistical model)                  *
//                                                                            *
//       52.LIB TT_DIO_na25od33                                               *
//              SS_DIO_na25od33                                               *
//              FF_DIO_na25od33                                               *
//   ( 2.5V over-drive native IO N+/PW diode )                                *
//                                                                            *
//       53.LIB mc_dio_na33                                                   *
//   ( 3.3V native N+/PW diode statistical model)                             *
//                                                                            *
//       54.LIB TT_DIO_na33                                                   *
//              SS_DIO_na33                                                   *
//              FF_DIO_na33                                                   *
//   ( 3.3V native IO N+/PW diode )                                	     *
//                                                                            *
//       55.LIB mc_dio_DNW                                                    *
//   ( PW/DNW and DNW/PSUB diode statistical model)                           *
//                                                                            *
//       56.LIB TT_DIO_DNW                                                    *
//              SS_DIO_DNW                                                    *
//              FF_DIO_DNW                                                    *
//    (  PW/DNW and DNW/PSUB diode  )                                         *
//                                                                            *
//       57.LIB mc_dio_ESD                                                    *
//   ( ESD diode statistical model)                                           *
//                                                                            *
//       58.LIB TT_DIO_ESD                                                    *
//              SS_DIO_ESD                                                    *
//              FF_DIO_ESD                                                    *
//    (  ESD diode  )                                                         *
//                                                                            *
//       59.LIB stat_res                                                      *
//   ( Common resistor statistical library )                                  *
//                                                                            *
//       60.LIB mc_res                                                        *
//   ( Front-end 2T resistors statistical model)                              *
//                                                                            *
//       61.LIB TT_RES                                                        *
//              SS_RES                                                        *
//              FF_RES                                                        * 
//   ( Front-end 2T resistance corner and mismatch model)                     *
//                                                                            *
//       62.LIB TT_DISRES                                                     *
//              SS_DISRES                                                     *
//              FF_DISRES                                                     *
//        ( Front-end 3T resistance corner and mismatch model)                *
//                                                                            *
//       63.LIB mc_mos_cap                                                    *
//   ( core varactor statistical model)                                       *
//                                                                            *
//       64.LIB TT_MOS_CAP                                                    *
//              SS_MOS_CAP                                                    *
//              FF_MOS_CAP                                                    *
//   ( 1.0V Standard-Vt NMOS in N-Well varactor )                             *
//                                                                            *
//       65.LIB mc_mos_cap_25                                                 *
//   ( IO varactor statistical model)                                         *
//                                                                            *
//       66.LIB TT_MOS_CAP_25                                                 *
//              SS_MOS_CAP_25                                                 *
//              FF_MOS_CAP_25                                                 *
//   ( 2.5V IO NMOS in N-Well varactor )                                      *
//                                                                            * 
//       67.LIB TT_MIM                                                        *
//              SS_MIM                                                        *
//              FF_MIM                                                        *
//              MC_MIM                                                        *
//        ( MIM capactiance corner, mismatch and statistical model)           *
//                                                                            *
//       68.LIB TT_RTMOM                                                      *
//              SS_RTMOM                                                      *
//              FF_RTMOM                                                      *
//              MC_RTMOM                                                      *
//        ( RTMOM capactiance corner, mismatch and statistical model)         * 
//                                                                            *                                                          
//*****************************************************************************
//
// NOTE:
//  1. All parasitics capacitances are removed from intrinsic model. The model only
//     covers the intrinsic MOSFET. All parasitic components will be handled by LPE.
//     For pre-layout simulation, contact-to-poly capacitance can be simulated by 
//     setting ccoflag=1.
//
//  2. Best approximation for gate resistance extraction is 1/3 of Rg, DC gate 
//     resistance. Current LPE tools extract gate resistors from gate edge to center 
//     of gate. Error of 1/2 Rg methodology is less than 5% when W/L < 30.  It is 
//     recommended to split wide gate transistor to meet W/L < 30 for high precision 
//     designs. For pre-layout simulation, Rg effect can be simulated by setting 
//     rgflag=1
//
//  3. The WPE (well proximity effect) is modeled in Bsim4.5. Please refer the Bsim4.5 
//     manual for model equation details. There are three new instance parameters 
//     SCA, SCB and SCC for post-layout WPE simulation. The number should be extracted
//     from LPE. For pre-layout simulation, the single instance parameter, SC (shortest 
//     distance between Well and OD shown below), is used as the only input for WPE 
//     simulation. BSIM4.5 model will calculate one set of SCA/B/C internally based 
//     on given SC to perform the simulation. 
//
//    ---------^------------------
//    |	   SC |	-----		|
//    |	    --v-|---|----	|
//    |	    | M	| O | S |	|
//    |	    ----|---|----	|
//    |		-----		|
//    |				|
//    |				|
//    |	well			|
//    -----------------------------
//
//  4. Sample netlist for BSIM4.5 WPE effect:
//     =========================
//     .temp 25.000
//     .lib 'crn65gplus_2d5_lk_v1d0p1.l' TT_25
//     Vgs g 0 -2.5
//     Vbs b 0 0.000
//     Vss0 s0 0 0.000
//     Vds0 d0 0 -0.1
//     mdut0 d0 g s0 b pch_25 w=0.400u l=1.0000u sca=2.26 scb=2.01e-4 scc=4.42e-8
//     .op
//     .dc vgs 0.3 -2.50000 -0.010000
//     .measure dc vth_dut0 find v(g) when par('abs(i(Vss0))')="1e-7*0.4/1.0000"
//     .end
//
// **********************************************************************************
//**********************     FLAG FOR FLICKER NOISE CORNERS SIMULATION  ************************
//
// NOTE:
//  1. Transistor
//     noiseflagn=0 for typical, noiseflagn=1 for worstcase, noiseflagn=-1 for best case
//     noiseflagp=0 for typical, noiseflagp=1 for worstcase, noiseflagp=-1 for best case
//  2. Resistor
//     rnoiseflag=0 for typical, rnoiseflag=1 for worstcase, rnoiseflag=-1 for best case
//
//**********************************************************************************************
//********************     MISMATCH & STATISTICAL SIMULATION FOR SPECTRE     ***********
//
// NOTE:
//  1. To have the mismatch simulation result, the stat_mis_xxx libraries have to be included
//     with an interested corner (TT/FF/SS/FS/SF) together at the same time.
//  2. Only the process variation simulation is supported in mc_xxx MOS statistical
//     model library in this release version. To have the process variation result,
//     the stat library is required to include with mc_xxx together at the same time.
//
//**********************************************************************************************

section stat_mis_rfmos 
statistics { 
 mismatch { 
  vary parn1rf dist=gauss std=1/1 
  vary parn2rf dist=gauss std=1/1 
  vary parp1rf dist=gauss std=1/1 
  vary parp2rf dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rfmos 
  
section stat_mis_rfmos_18 
statistics { 
 mismatch { 
  vary parn1rf_18 dist=gauss std=1/1 
  vary parn2rf_18 dist=gauss std=1/1 
  vary parp1rf_18 dist=gauss std=1/1 
  vary parp2rf_18 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rfmos_18 
 
section stat_mis_rfmos_25 
statistics { 
 mismatch { 
  vary parn1rf_25 dist=gauss std=1/1 
  vary parn2rf_25 dist=gauss std=1/1 
  vary parp1rf_25 dist=gauss std=1/1 
  vary parp2rf_25 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rfmos_25 
 
section stat_mis_rfmos_33 
statistics { 
 mismatch { 
  vary parn1rf_33 dist=gauss std=1/1 
  vary parn2rf_33 dist=gauss std=1/1 
  vary parp1rf_33 dist=gauss std=1/1 
  vary parp2rf_33 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rfmos_33 



section stat_mis_rfmim
statistics {
    mismatch {
        vary par_rfmim dist=gauss std=1/1
        }
    }
endsection stat_mis_rfmim


section stat_mis_rfrtmom 
statistics { 
 mismatch { 
  vary par_rfmom dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rfrtmom 
 
 

section stat_mis_mim 
statistics { 
 mismatch { 
  vary par_mim dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_mim 


section stat_mis_rtmom 
statistics { 
 mismatch { 
  vary par_mom dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rtmom 

section stat_mis_disres
statistics { 
 mismatch { 
  vary par_res_m dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_disres



section stat_mis_res 
statistics { 
 mismatch { 
  vary par_res dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_res


section stat_mis_rfres_sa 
statistics { 
 mismatch { 
  vary par_rfres_sa dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rfres_sa



section stat_mis_rfres_rpo 
statistics { 
 mismatch { 
  vary par_rfres_rpo dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_rfres_rpo


section setup_rf
parameters factor_mos_rf=1
parameters noiseflagnrf=0
parameters noiseflagprf=0
endsection setup_rf
  

section setup_rf_18
parameters factor_mos_18_rf=1
parameters noiseflagnrf_18=0
parameters noiseflagprf_18=0
endsection setup_rf_18
 

section setup_rf_25
parameters factor_mos_25_rf=1
parameters noiseflagnrf_25=0
parameters noiseflagprf_25=0
endsection setup_rf_25
 

section setup_rf_33
parameters factor_mos_33_rf=1
parameters noiseflagnrf_33=0
parameters noiseflagprf_33=0
endsection setup_rf_33


section noiseflag_rfresrpo
parameters rnoiseflag_rfresrpo=0
endsection noiseflag_rfresrpo
 

// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_rfmos
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf
parameters a1rf=par1 * 6.0316e+000 * 3 / 2.1
parameters a2rf=par2 * 4.1466e+000 * 3 / 2.1
parameters a3rf=par3 * 3.6308e+000 * 3 / 2.1
parameters a4rf=par4 * 2.5547e+000 * 3 / 2.1
parameters parn1rf=0
parameters parn2rf=0
parameters parp1rf=0
parameters parp2rf=0
parameters toxprf=2.2000e-009 + ( - 5.0852e-012) * a1rf + (2.8679e-012) * a2rf + 
+ (9.6855e-012) * a3rf + (3.5262e-012) * a4rf
parameters dxwprf=0.0000e+000 + (5.9778e-010) * a1rf + ( - 1.4566e-009) * a2rf + 
+ ( - 1.0382e-009) * a3rf + ( - 2.1865e-010) * a4rf
parameters dxlprf=0.0000e+000 + ( - 3.6668e-010) * a1rf + (1.0699e-010) * a2rf + 
+ (2.2490e-010) * a3rf + (9.4412e-011) * a4rf
parameters dvthprf=0.0000e+000 + (2.6665e-003) * a1rf + ( - 3.2625e-003) * a2rf 
+ + (2.1130e-003) * a3rf + (1.1626e-003) * a4rf
parameters dlvthprf=0.0000e+000 + (2.9916e-011) * a1rf + ( - 6.0617e-011) * a2rf 
+ + (5.0020e-011) * a3rf + ( - 1.5761e-011) * a4rf
parameters dwvthprf=0.0000e+000 + (2.2495e-010) * a1rf + ( - 3.4619e-010) * a2rf 
+ + (2.5601e-010) * a3rf + (1.2967e-011) * a4rf
parameters dpvthprf=0.0000e+000 + (1.7160e-017) * a1rf + ( - 1.9478e-017) * a2rf 
+ + (1.1935e-017) * a3rf + (9.3033e-018) * a4rf
parameters cjprf=1.0600e-003 + ( - 6.7198e-006) * a1rf + (8.3935e-006) * a2rf + 
+ ( - 5.5129e-006) * a3rf + ( - 2.7241e-006) * a4rf
parameters cjswprf=6.4000e-011 + ( - 4.0573e-013) * a1rf + (5.0678e-013) * a2rf 
+ + ( - 3.3286e-013) * a3rf + ( - 1.6448e-013) * a4rf
parameters cjswgprf=2.5500e-010 + ( - 1.6166e-012) * a1rf + (2.0192e-012) * a2rf 
+ + ( - 1.3262e-012) * a3rf + ( - 6.5533e-013) * a4rf
parameters cgoprf=3.018880e-11 + (2.6220e-013) * a1rf + ( - 1.4777e-013) * a2rf 
+ + ( - 4.9980e-013) * a3rf + ( - 1.7990e-013) * a4rf
parameters cglprf=5.247580e-11 + (3.1663e-013) * a1rf + ( - 1.7858e-013) * a2rf 
+ + ( - 6.0312e-013) * a3rf + ( - 2.1957e-013) * a4rf
parameters cfprf=1.3800e-010 + (7.4159e-013) * a1rf + ( - 4.1823e-013) * a2rf + 
+ ( - 1.4125e-012) * a3rf + ( - 5.1423e-013) * a4rf + 4.6e-11
parameters du0prf=0.0000e+000 + ( - 1.5235e-005) * a1rf + (1.3925e-005) * a2rf + 
+ ( - 6.9060e-006) * a3rf + ( - 1.2298e-005) * a4rf
parameters dlu0prf=0.0000e+000 + ( - 3.4244e-013) * a1rf + (1.2002e-013) * a2rf 
+ + ( - 5.2447e-013) * a3rf + (5.0775e-013) * a4rf
parameters dwu0prf=0.0000e+000 + (2.7169e-012) * a1rf + ( - 3.3936e-012) * a2rf 
+ + (2.2290e-012) * a3rf + (1.1014e-012) * a4rf
parameters dpu0prf=0.0000e+000 + ( - 1.2016e-019) * a1rf + (1.4725e-019) * a2rf 
+ + ( - 9.5471e-020) * a3rf + ( - 5.2112e-020) * a4rf
parameters deta0prf=0.0000e+000 + ( - 4.8879e-003) * a1rf + (1.4050e-003) * a2rf 
+ + ( - 9.9194e-004) * a3rf + (9.1225e-003) * a4rf
parameters dleta0prf=0.0000e+000 + (2.8150e-010) * a1rf + ( - 6.3111e-011) * a2rf 
+ + (1.0627e-013) * a3rf + ( - 2.0951e-010) * a4rf
parameters dweta0prf=0.0000e+000 + (2.0e-009) * a1rf + ( - 6.4991e-010) * a2rf + 
+ (5.2604e-010) * a3rf + ( - 2.0e-009) * a4rf
parameters dpeta0prf=0.0000e+000 + ( - 7.7739e-017) * a1rf + (2.4163e-017) * a2rf 
+ + ( - 2.1597e-017) * a3rf + (1.7733e-016) * a4rf
parameters dvsatprf=0.0000e+000 + ( - 1.2613e+002) * a1rf + (3.2766e+002) * a2rf 
+ + ( - 2.8989e+002) * a3rf + (1.5293e+002) * a4rf
parameters dlvsatprf=0.0000e+000 + ( - 3.0090e-006) * a1rf + ( - 4.0283e-005) * 
+ a2rf + (9.4962e-006) * a3rf + (9.4313e-006) * a4rf
parameters ntoxprf=1.0000e+000 + (3.7421e-002) * a1rf + ( - 1.8992e-002) * a2rf 
+ + ( - 6.4966e-002) * a3rf + ( - 1.5028e-002) * a4rf
parameters dlk2prf=0.0000e+000 + ( - 4.9669e-011) * a1rf + ( - 3.2272e-011) * a2rf 
+ + (4.9802e-011) * a3rf + ( - 3.2810e-011) * a4rf
parameters dwk2prf=0.0000e+000 + ( - 9.0564e-011) * a1rf + (1.1312e-010) * a2rf 
+ + ( - 7.4298e-011) * a3rf + ( - 3.6713e-011) * a4rf
parameters dpk2prf=0.0000e+000 + (2.9057e-018) * a1rf + ( - 9.5150e-019) * a2rf 
+ + (1.5752e-018) * a3rf + (1.0306e-018) * a4rf
parameters dagsprf=0.0000e+000 + (3.8879e-004) * a1rf + (6.3192e-003) * a2rf + ( 
+ - 7.1377e-003) * a3rf + (8.3202e-003) * a4rf
parameters dwagsprf=0.0000e+000 + ( - 4.1563e-009) * a1rf + (4.5677e-009) * a2rf 
+ + ( - 2.7263e-009) * a3rf + ( - 2.4331e-009) * a4rf
parameters dla0prf=0.0000e+000 + (6.0340e-009) * a1rf + (4.9771e-009) * a2rf + ( 
+ - 3.8372e-009) * a3rf + ( - 3.4390e-009) * a4rf
parameters dlagsprf=0.0000e+000 + (4.8522e-009) * a1rf + ( - 3.8995e-010) * a2rf 
+ + ( - 2.2331e-009) * a3rf + (8.7691e-009) * a4rf
parameters dpagsprf=0.0000e+000 + ( - 9.7044e-016) * a1rf + (7.7990e-017) * a2rf 
+ + (4.4663e-016) * a3rf + ( - 1.7538e-015) * a4rf
parameters dcitprf=0.0000e+000 + (1.2613e-005) * a1rf + ( - 3.2766e-005) * a2rf 
+ + (2.8989e-005) * a3rf + ( - 1.5293e-005) * a4rf
parameters dlcitprf=0.0000e+000 + (1.1859e-012) * a1rf + (3.6085e-012) * a2rf + 
+ (1.8034e-011) * a3rf + (6.0285e-012) * a4rf
parameters dlvoffprf=0.0000e+000 + (6.5576e-012) * a1rf + ( - 3.9333e-011) * a2rf 
+ + ( - 3.5957e-011) * a3rf + ( - 3.2839e-011) * a4rf
parameters dlatprf=0.0000e+000 + ( - 1.4557e-005) * a1rf + (1.1699e-006) * a2rf 
+ + (6.6994e-006) * a3rf + ( - 2.6307e-005) * a4rf
parameters ff_flagrf=0.0000e+000 + (4.6113e-002) * a1rf + ( - 1.3828e-002) * a2rf 
+ + (1.1192e-002) * a3rf + ( - 9.6223e-002) * a4rf
parameters ss_flagrf=0.0000e+000 + ( - 4.8522e-002) * a1rf + (3.8995e-003) * a2rf 
+ + (2.2331e-002) * a3rf + ( - 8.7691e-002) * a4rf
parameters fs_flagrf=0.0000e+000 + (5.7047e-003) * a1rf + (6.9231e-002) * a2rf + 
+ ( - 2.2822e-002) * a3rf + (2.5541e-002) * a4rf
parameters sf_flagrf=0.0000e+000 + ( - 4.3253e-003) * a1rf + ( - 6.5044e-002) * 
+ a2rf + (8.8318e-003) * a3rf + (5.6978e-002) * a4rf
parameters toxnrf=2.0000e-009 + ( - 5.0852e-012) * a1rf + (2.8679e-012) * a2rf + 
+ (9.6855e-012) * a3rf + (3.5262e-012) * a4rf
parameters dxwnrf=0.0000e+000 + (7.5826e-010) * a1rf + (6.9182e-010) * a2rf + ( 
+ - 1.5446e-009) * a3rf + ( - 7.2166e-010) * a4rf
parameters dxlnrf=0.0000e+000 + ( - 3.7854e-010) * a1rf + (7.0910e-011) * a2rf + 
+ (4.4557e-011) * a3rf + (3.4127e-011) * a4rf
parameters dvthnrf=0.0000e+000 + ( - 2.9938e-003) * a1rf + ( - 2.9906e-003) * a2rf 
+ + ( - 1.1359e-003) * a3rf + (3.7559e-004) * a4rf
parameters dlvthnrf=0.0000e+000 + ( - 7.0996e-011) * a1rf + ( - 7.9326e-011) * a2rf 
+ + ( - 3.3477e-011) * a3rf + (2.3961e-011) * a4rf
parameters dwvthnrf=0.0000e+000 + ( - 9.2617e-011) * a1rf + ( - 4.9244e-011) * a2rf 
+ + ( - 1.4751e-012) * a3rf + ( - 6.5871e-011) * a4rf
parameters dpvthnrf=0.0000e+000 + ( - 2.1330e-017) * a1rf + ( - 2.1528e-017) * a2rf 
+ + ( - 8.2645e-018) * a3rf + (3.0708e-018) * a4rf
parameters cjnrf=1.2700e-003 + ( - 9.5656e-006) * a1rf + ( - 9.3103e-006) * a2rf 
+ + ( - 3.4387e-006) * a3rf + (7.6128e-007) * a4rf
parameters cjswnrf=6.4000e-011 + ( - 4.8205e-013) * a1rf + ( - 4.6918e-013) * a2rf 
+ + ( - 1.7329e-013) * a3rf + (3.8363e-014) * a4rf
parameters cjswgnrf=3.0500e-010 + ( - 2.2973e-012) * a1rf + ( - 2.2359e-012) * a2rf 
+ + ( - 8.2583e-013) * a3rf + (1.8283e-013) * a4rf
parameters cgonrf=5.725430e-11 + (4.0516e-013) * a1rf + ( - 2.2849e-013) * a2rf 
+ + ( - 7.7167e-013) * a3rf + ( - 2.8084e-013) * a4rf
parameters cglnrf=9.157840e-12 + (4.3203e-014) * a1rf + ( - 2.4366e-014) * a2rf 
+ + ( - 8.2293e-014) * a3rf + ( - 2.9950e-014) * a4rf
parameters cfnrf=1.3900e-010 + (7.4159e-013) * a1rf + ( - 4.1823e-013) * a2rf + 
+ ( - 1.4125e-012) * a3rf + ( - 5.1423e-013) * a4rf + 4.1e-11
parameters drdswnrf=0.0000e+000 + (2.4261e-001) * a1rf + ( - 1.9498e-002) * a2rf 
+ + ( - 1.1166e-001) * a3rf + (4.3846e-001) * a4rf
parameters dlu0nrf=0.0000e+000 + (1.8760e-012) * a1rf + ( - 2.8232e-012) * a2rf 
+ + ( - 1.3308e-012) * a3rf + (2.6845e-013) * a4rf
parameters deta0nrf=0.0000e+000 + (4.8522e-004) * a1rf + ( - 3.8995e-005) * a2rf 
+ + ( - 2.2331e-004) * a3rf + (8.7691e-004) * a4rf
parameters dleta0nrf=0.0000e+000 + ( - 5.4856e-011) * a1rf + ( - 6.3617e-011) * 
+ a2rf + ( - 2.7675e-011) * a3rf + (2.2676e-011) * a4rf
parameters dpeta0nrf=0.0000e+000 + (2.6542e-017) * a1rf + (3.0179e-017) * a2rf + 
+ (1.2922e-017) * a3rf + ( - 9.8943e-018) * a4rf
parameters dlvsatnrf=0.0000e+000 + ( - 2.3079e-005) * a1rf + (1.7002e-005) * a2rf 
+ + ( - 1.4589e-005) * a3rf + ( - 1.4982e-005) * a4rf
parameters dpvsatnrf=0.0000e+000 + ( - 6.2662e-012) * a1rf + ( - 6.8658e-012) * 
+ a2rf + ( - 2.8492e-012) * a3rf + (1.8720e-012) * a4rf
parameters ntoxnrf=1.0000e+000 + (1.4531e-002) * a1rf + ( - 7.7257e-003) * a2rf 
+ + ( - 2.6275e-002) * a3rf + ( - 7.6493e-003) * a4rf
parameters dk2nrf=0.0000e+000 + ( - 1.3018e-003) * a1rf + ( - 1.3693e-003) * a2rf 
+ + ( - 5.4751e-004) * a3rf + (2.8671e-004) * a4rf
parameters dlk2nrf=0.0000e+000 + (2.4261e-012) * a1rf + ( - 1.9498e-013) * a2rf 
+ + ( - 1.1166e-012) * a3rf + (4.3846e-012) * a4rf
parameters dwk2nrf=0.0000e+000 + ( - 1.9959e-010) * a1rf + ( - 1.9937e-010) * a2rf 
+ + ( - 7.5726e-011) * a3rf + (2.5039e-011) * a4rf
parameters dpk2nrf=0.0000e+000 + ( - 1.1214e-017) * a1rf + ( - 1.2704e-017) * a2rf 
+ + ( - 5.4233e-018) * a3rf + (4.0968e-018) * a4rf
parameters dagsnrf=0.0000e+000 + ( - 2.8273e-003) * a1rf + ( - 5.1760e-003) * a2rf 
+ + (2.3827e-003) * a3rf + ( - 3.1271e-003) * a4rf
parameters dlcitnrf=0.0000e+000 + (9.8822e-013) * a1rf + (3.0071e-012) * a2rf + 
+ (1.5029e-011) * a3rf + (5.0238e-012) * a4rf
parameters dlvoffnrf=0.0000e+000 + (3.2280e-011) * a1rf + (3.1418e-011) * a2rf + 
+ (1.1604e-011) * a3rf + ( - 2.5690e-012) * a4rf
parameters dlkt1nrf=0.0000e+000 + (2.1520e-011) * a1rf + (2.0946e-011) * a2rf + 
+ (7.7361e-012) * a3rf + ( - 1.7127e-012) * a4rf
parameters dkt2nrf=0.0000e+000 + (5.1054e-004) * a1rf + (1.2074e-005) * a2rf + (8.6335e-004) 
+ * a3rf + ( - 7.1104e-004) * a4rf
parameters dlatnrf=0.0000e+000 + ( - 2.6900e-005) * a1rf + ( - 2.6182e-005) * a2rf 
+ + ( - 9.6701e-006) * a3rf + (2.1408e-006) * a4rf
parameters dpatnrf=0.0000e+000 + ( - 6.4560e-012) * a1rf + ( - 6.2837e-012) * a2rf 
+ + ( - 2.3208e-012) * a3rf + (5.1380e-013) * a4rf
parameters dlagsnrf=0.0000e+000 + ( - 8.7765e-009) * a1rf + ( - 4.9634e-009) * a2rf 
+ + ( - 3.7083e-010) * a3rf + ( - 5.7102e-009) * a4rf
parameters dpagsnrf=0.0000e+000 + (1.0043e-015) * a1rf + (1.8467e-015) * a2rf + 
+ (1.0372e-015) * a3rf + ( - 1.6363e-015) * a4rf
parameters ddlcprf=4.745380e-09
parameters drdswprf=0.0000e+000
parameters dnfactorprf=0.0000e+000
parameters dlnfactorprf=0.0000e+000
parameters dwnfactorprf=0.0000e+000
parameters dpnfactorprf=0.0000e+000
parameters dwvsatprf=0.0000e+000
parameters dpvsatprf=0.0000e+000
parameters dk2prf=0.0000e+000
parameters dpclmprf=0.0000e+000
parameters dwa0prf=0.0000e+000
parameters dpa0prf=0.0000e+000
parameters dwcitprf=0.0000e+000
parameters dpcitprf=0.0000e+000
parameters dvoffprf=0.0000e+000
parameters dwvoffprf=0.0000e+000
parameters dpvoffprf=0.0000e+000
parameters da0prf=0.0000e+000
parameters jtsswgprf=7.2000e-010
parameters dluteprf=0.0000e+000
parameters dlpclmprf=0.0000e+000
parameters ddlcnrf=3.244300e-09
parameters dnfactornrf=0.0000e+000
parameters dlnfactornrf=0.0000e+000
parameters dwnfactornrf=0.0000e+000
parameters dpnfactornrf=0.0000e+000
parameters du0nrf=0.0000e+000
parameters dwu0nrf=0.0000e+000
parameters dpu0nrf=0.0000e+000
parameters dweta0nrf=0.0000e+000
parameters dvsatnrf=0.0000e+000
parameters dwvsatnrf=0.0000e+000
parameters dpclmnrf=0.0000e+000
parameters dppclmnrf=0.0000e+000
parameters dwcitnrf=0.0000e+000
parameters dpcitnrf=0.0000e+000
parameters da0nrf=0.0000e+000
parameters dla0nrf=0.0000e+000
parameters dwa0nrf=0.0000e+000
parameters dpa0nrf=0.0000e+000
parameters dvoffnrf=0.0000e+000
parameters dwvoffnrf=0.0000e+000
parameters dpvoffnrf=0.0000e+000
parameters dkt1nrf=0.0000e+000
parameters dwkt1nrf=0.0000e+000
parameters dpkt1nrf=0.0000e+000
parameters dlkt2nrf=0.0000e+000
parameters dwkt2nrf=0.0000e+000
parameters dpkt2nrf=0.0000e+000
parameters dub1nrf=0.0000e+000
parameters dlub1nrf=0.0000e+000
parameters dwub1nrf=0.0000e+000
parameters dpub1nrf=0.0000e+000
parameters dua1nrf=0.0000e+000
parameters dlua1nrf=0.0000e+000
parameters dwua1nrf=0.0000e+000
parameters dpua1nrf=0.0000e+000
parameters datnrf=0.0000e+000
parameters dwatnrf=0.0000e+000
parameters b1fnrf=-6.5E+40           
parameters b2fnrf=0
parameters b3fnrf=-2.49E+7           
parameters a1fnrf=9.25e+41   
parameters a2fnrf=0  
parameters a3fnrf=1.475e+9  
parameters c1fnrf=1.5E+41     
parameters c2fnrf=1E+14  
parameters c3fnrf=5E+7 
parameters b1fprf=-5.5E+41   
parameters b2fprf=0    
parameters b3fprf=-7E+9   
parameters a1fprf=1.19E+43   
parameters a2fprf=3.995E+17  
parameters a3fprf=4E+10 
parameters c1fprf=1.2E+42   
parameters c2fprf=1E+15    
parameters c3fprf=1.5E+10   
parameters noianrf=a1fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b1fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c1fnrf
parameters noibnrf=a2fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b2fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c2fnrf
parameters noicnrf=a3fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b3fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c3fnrf
parameters noiaprf=a1fprf * (abs(noiseflagprf) + noiseflagprf) + b1fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c1fprf
parameters noibprf=a2fprf * (abs(noiseflagprf) + noiseflagprf) + b2fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c2fprf
parameters noicprf=a3fprf * (abs(noiseflagprf) + noiseflagprf) + b3fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c3fprf
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos
endsection mc_rfmos
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_rfmos
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf
parameters parn1rf=0
parameters parn2rf=0
parameters parp1rf=0
parameters parp2rf=0
parameters toxprf=2.2e-09
parameters dxwprf=0
parameters dxlprf=0
parameters dvthprf=0
parameters dlvthprf=0
parameters dwvthprf=0
parameters dpvthprf=0
parameters cjprf=1.0600e-03
parameters cjswprf=6.4000e-11
parameters cjswgprf=2.5500e-10
parameters cgoprf=3.018880e-11
parameters cglprf=5.247580e-11
parameters ddlcprf=4.745380e-09
parameters cfprf=1.3800e-10 + 4.6e-11
parameters drdswprf=0
parameters dnfactorprf=0
parameters dlnfactorprf=0
parameters dwnfactorprf=0
parameters dpnfactorprf=0
parameters du0prf=0
parameters dlu0prf=0
parameters dwu0prf=0
parameters dpu0prf=0
parameters deta0prf=0
parameters dleta0prf=0
parameters dweta0prf=0
parameters dpeta0prf=0
parameters dvsatprf=0
parameters dlvsatprf=0
parameters dwvsatprf=0
parameters dpvsatprf=0
parameters ntoxprf=1
parameters dk2prf=0
parameters dlk2prf=0
parameters dwk2prf=0
parameters dpk2prf=0
parameters dagsprf=0
parameters dwagsprf=0
parameters dpclmprf=0
parameters dlpclmprf=0
parameters dla0prf=0
parameters dlagsprf=0
parameters dpagsprf=0
parameters dwa0prf=0
parameters dpa0prf=0
parameters dcitprf=0
parameters dlcitprf=0
parameters dwcitprf=0
parameters dpcitprf=0
parameters dvoffprf=0
parameters dlvoffprf=0
parameters dwvoffprf=0
parameters dpvoffprf=0
parameters da0prf=0
parameters jtsswgprf=7.2e-10
parameters dluteprf=0
parameters dlatprf=0
parameters ff_flagrf=0
parameters ss_flagrf=0
parameters fs_flagrf=0
parameters sf_flagrf=0
parameters toxnrf=2e-09
parameters dxwnrf=0
parameters dxlnrf=0
parameters dvthnrf=0
parameters dlvthnrf=0
parameters dwvthnrf=0
parameters dpvthnrf=0
parameters cjnrf=1.2700e-03
parameters cjswnrf=6.4000e-11
parameters cjswgnrf=3.0500e-10
parameters cgonrf=5.725430e-11
parameters cglnrf=9.157840e-12
parameters ddlcnrf=3.244300e-09
parameters cfnrf=1.3900e-10 + 4.1e-11
parameters drdswnrf=0
parameters dnfactornrf=0
parameters dlnfactornrf=0
parameters dwnfactornrf=0
parameters dpnfactornrf=0
parameters du0nrf=0
parameters dlu0nrf=0
parameters dwu0nrf=0
parameters dpu0nrf=0
parameters deta0nrf=0
parameters dleta0nrf=0
parameters dweta0nrf=0
parameters dpeta0nrf=0
parameters dvsatnrf=0
parameters dlvsatnrf=0
parameters dwvsatnrf=0
parameters dpvsatnrf=0
parameters ntoxnrf=1
parameters dk2nrf=0
parameters dlk2nrf=0
parameters dwk2nrf=0
parameters dpk2nrf=0
parameters dagsnrf=0
parameters dpclmnrf=0
parameters dppclmnrf=0
parameters dlcitnrf=0
parameters dwcitnrf=0
parameters dpcitnrf=0
parameters da0nrf=0
parameters dla0nrf=0
parameters dwa0nrf=0
parameters dpa0nrf=0
parameters dvoffnrf=0
parameters dlvoffnrf=0
parameters dwvoffnrf=0
parameters dpvoffnrf=0
parameters dkt1nrf=0
parameters dlkt1nrf=0
parameters dwkt1nrf=0
parameters dpkt1nrf=0
parameters dkt2nrf=0
parameters dlkt2nrf=0
parameters dwkt2nrf=0
parameters dpkt2nrf=0
parameters dub1nrf=0
parameters dlub1nrf=0
parameters dwub1nrf=0
parameters dpub1nrf=0
parameters dua1nrf=0
parameters dlua1nrf=0
parameters dwua1nrf=0
parameters dpua1nrf=0
parameters datnrf=0
parameters dlatnrf=0
parameters dpatnrf=0
parameters dwatnrf=0
parameters dlagsnrf=0
parameters dpagsnrf=0
parameters b1fnrf=-6.5E+40           
parameters b2fnrf=0
parameters b3fnrf=-2.49E+7           
parameters a1fnrf=9.25e+41   
parameters a2fnrf=0  
parameters a3fnrf=1.475e+9  
parameters c1fnrf=1.5E+41     
parameters c2fnrf=1E+14  
parameters c3fnrf=5E+7 
parameters b1fprf=-5.5E+41   
parameters b2fprf=0    
parameters b3fprf=-7E+9   
parameters a1fprf=1.19E+43   
parameters a2fprf=3.995E+17  
parameters a3fprf=4E+10 
parameters c1fprf=1.2E+42   
parameters c2fprf=1E+15    
parameters c3fprf=1.5E+10    
parameters noianrf=a1fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b1fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c1fnrf
parameters noibnrf=a2fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b2fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c2fnrf
parameters noicnrf=a3fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b3fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c3fnrf
parameters noiaprf=a1fprf * (abs(noiseflagprf) + noiseflagprf) + b1fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c1fprf
parameters noibprf=a2fprf * (abs(noiseflagprf) + noiseflagprf) + b2fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c2fprf
parameters noicprf=a3fprf * (abs(noiseflagprf) + noiseflagprf) + b3fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c3fprf
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos
endsection tt_rfmos
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_rfmos
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf
parameters parn1rf=0
parameters parn2rf=0
parameters parp1rf=0
parameters parp2rf=0
parameters toxprf=2.26e-09
parameters dxwprf=-8e-09
parameters dxlprf=4e-09
parameters dvthprf=-0.03
parameters dlvthprf=-1.4e-10
parameters dwvthprf=-1.95e-09
parameters dpvthprf=-2.055e-16
parameters cjprf=1.1342e-03
parameters cjswprf=6.8480e-11
parameters cjswgprf=2.7285e-10
parameters cgoprf=2.80756e-11
parameters cglprf=4.88025e-11
parameters ddlcprf=4.74538e-09
parameters cfprf=1.283e-10 + 4.6e-11
parameters drdswprf=0
parameters dnfactorprf=0
parameters dlnfactorprf=0
parameters dwnfactorprf=0
parameters dpnfactorprf=0
parameters du0prf=0.00021
parameters dlu0prf=0
parameters dwu0prf=-3e-11
parameters dpu0prf=1.35e-18
parameters deta0prf=0.0057
parameters dleta0prf= - 0.4e-09 * 0 - 1.8e-09
parameters dweta0prf=0
parameters dpeta0prf=-8e-17
parameters dvsatprf=0
parameters dlvsatprf=0
parameters dwvsatprf=0
parameters dpvsatprf=0
parameters ntoxprf=0.52
parameters dk2prf=0
parameters dlk2prf=0.8e-09
parameters dwk2prf=1e-09
parameters dpk2prf=-3e-17
parameters dagsprf=-0.06
parameters dwagsprf=5.1e-08
parameters dpclmprf=0
parameters dlpclmprf=1e-7
parameters dla0prf= - 6e-08
parameters dlagsprf= - 1e-07
parameters dpagsprf=2e-14
parameters dwa0prf=0
parameters dpa0prf=0
parameters dcitprf=0
parameters dlcitprf=0
parameters dwcitprf=0
parameters dpcitprf=0
parameters dvoffprf=0
parameters dlvoffprf=0
parameters dwvoffprf=0
parameters dpvoffprf=0
parameters da0prf=0
parameters jtsswgprf=7.2e-10
parameters dluteprf=0
parameters dlatprf=0.3e-03
parameters ff_flagrf=0
parameters ss_flagrf=1
parameters fs_flagrf=0
parameters sf_flagrf=0
parameters toxnrf=2.06e-09
parameters dxwnrf=-8e-09
parameters dxlnrf=4e-09
parameters dvthnrf=0.0270
parameters dlvthnrf=5.5e-10
parameters dwvthnrf=1.3e-09
parameters dpvthnrf=1.9e-16
parameters cjnrf=1.3589e-03
parameters cjswnrf=6.8480e-11
parameters cjswgnrf=3.2635e-10
parameters cgonrf=5.32465e-11
parameters cglnrf=8.51679e-12
parameters ddlcnrf=3.24430e-09
parameters cfnrf=1.293e-10 + 4.1e-11
parameters drdswnrf=-5
parameters dnfactornrf=0
parameters dlnfactornrf=0
parameters dwnfactornrf=0
parameters dpnfactornrf=0
parameters du0nrf=0
parameters dlu0nrf=-2.0e-11
parameters dwu0nrf=0
parameters dpu0nrf=0
parameters deta0nrf=-0.01
parameters dleta0nrf=1.7e-09 * 0 + 0.4e-09
parameters dweta0nrf=0
parameters dpeta0nrf=-2e-16
parameters dvsatnrf=0
parameters dlvsatnrf=0.00029
parameters dwvsatnrf=0
parameters dpvsatnrf=5e-11
parameters ntoxnrf=0.82
parameters dk2nrf=0.011
parameters dlk2nrf=-5e-11
parameters dwk2nrf=1.8e-09
parameters dpk2nrf=8.5e-17
parameters dagsnrf=0.05
parameters dpclmnrf=0
parameters dppclmnrf=0
parameters dlcitnrf=5e-11 * 0
parameters dwcitnrf=0
parameters dpcitnrf=0
parameters da0nrf=0
parameters dla0nrf=0
parameters dwa0nrf=0
parameters dpa0nrf=0
parameters dvoffnrf=0
parameters dlvoffnrf= - 0.3e-09
parameters dwvoffnrf=0
parameters dpvoffnrf=0.3e-09 * 0
parameters dkt1nrf=0
parameters dlkt1nrf=-2e-10
parameters dwkt1nrf=0
parameters dpkt1nrf=0
parameters dkt2nrf=0
parameters dlkt2nrf=0
parameters dwkt2nrf=0
parameters dpkt2nrf=0
parameters dub1nrf=0
parameters dlub1nrf=0
parameters dwub1nrf=0
parameters dpub1nrf=0
parameters dua1nrf=0
parameters dlua1nrf=0
parameters dwua1nrf=0
parameters dpua1nrf=0
parameters datnrf=0
parameters dlatnrf=0.00025
parameters dpatnrf=6e-11
parameters dwatnrf=0
parameters dlagsnrf=1.2e-07
parameters dpagsnrf=0
parameters b1fnrf=-6.5E+40           
parameters b2fnrf=0
parameters b3fnrf=-2.49E+7           
parameters a1fnrf=9.25e+41   
parameters a2fnrf=0  
parameters a3fnrf=1.475e+9  
parameters c1fnrf=1.5E+41     
parameters c2fnrf=1E+14  
parameters c3fnrf=5E+7 
parameters b1fprf=-5.5E+41   
parameters b2fprf=0    
parameters b3fprf=-7E+9   
parameters a1fprf=1.19E+43   
parameters a2fprf=3.995E+17  
parameters a3fprf=4E+10 
parameters c1fprf=1.2E+42   
parameters c2fprf=1E+15    
parameters c3fprf=1.5E+10    
parameters noianrf=a1fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b1fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c1fnrf
parameters noibnrf=a2fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b2fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c2fnrf
parameters noicnrf=a3fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b3fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c3fnrf
parameters noiaprf=a1fprf * (abs(noiseflagprf) + noiseflagprf) + b1fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c1fprf
parameters noibprf=a2fprf * (abs(noiseflagprf) + noiseflagprf) + b2fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c2fprf
parameters noicprf=a3fprf * (abs(noiseflagprf) + noiseflagprf) + b3fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c3fprf
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos
endsection ss_rfmos
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_rfmos
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf
parameters parn1rf=0
parameters parn2rf=0
parameters parp1rf=0
parameters parp2rf=0
parameters toxprf=2.14e-09
parameters dxwprf=8e-09
parameters dxlprf=-4e-09
parameters dvthprf=0.0288
parameters dlvthprf=5.5e-10
parameters dwvthprf=3.1e-09
parameters dpvthprf=1.71e-16
parameters cjprf=9.8580e-04
parameters cjswprf=5.9520e-11
parameters cjswgprf=2.3715e-10
parameters cgoprf=3.23020e-11
parameters cglprf=5.61491e-11
parameters ddlcprf=4.74538e-09
parameters cfprf=1.477e-10 + 4.6e-11
parameters drdswprf=0
parameters dnfactorprf=0
parameters dlnfactorprf=0
parameters dwnfactorprf=0
parameters dpnfactorprf=0
parameters du0prf=-0.00012
parameters dlu0prf=-7e-12
parameters dwu0prf=3e-11
parameters dpu0prf=-1.3e-18
parameters deta0prf=-0.1
parameters dleta0prf=3.3e-09 * 0 + 3.8e-09
parameters dweta0prf=4.7e-08
parameters dpeta0prf=-1.77e-15
parameters dvsatprf=-3000
parameters dlvsatprf=0
parameters dwvsatprf=0
parameters dpvsatprf=0
parameters ntoxprf=1.39
parameters dk2prf=0
parameters dlk2prf=-0.2e-09
parameters dwk2prf=-1e-09
parameters dpk2prf=3e-17
parameters dagsprf=-0.06
parameters dwagsprf=-4e-08
parameters dpclmprf=0
parameters dlpclmprf=0
parameters dla0prf=6e-08
parameters dlagsprf=0
parameters dpagsprf=0
parameters dwa0prf=0
parameters dpa0prf=0
parameters dcitprf=0.0003
parameters dlcitprf=1.5e-11
parameters dwcitprf=0
parameters dpcitprf=0
parameters dvoffprf=0
parameters dlvoffprf=0.25e-09
parameters dwvoffprf=0
parameters dpvoffprf=0
parameters da0prf=0
parameters jtsswgprf=7.2e-10
parameters dluteprf=0
parameters dlatprf=0
parameters ff_flagrf=1
parameters ss_flagrf=0
parameters fs_flagrf=0
parameters sf_flagrf=0
parameters toxnrf=1.94e-09
parameters dxwnrf=8e-09
parameters dxlnrf=-4e-09
parameters dvthnrf=-0.0285
parameters dlvthnrf=-7.5e-10
parameters dwvthnrf=-0.5e-09
parameters dpvthnrf=-2.05e-16
parameters cjnrf=1.1811e-03
parameters cjswnrf=5.9520e-11
parameters cjswgnrf=2.8365e-10
parameters cgonrf=6.12621e-11
parameters cglnrf=9.79889e-12
parameters ddlcnrf=3.24430e-09
parameters cfnrf=1.487e-10 + 4.1e-11
parameters drdswnrf=0
parameters dnfactornrf=0
parameters dlnfactornrf=0
parameters dwnfactornrf=0
parameters dpnfactornrf=0
parameters du0nrf=0
parameters dlu0nrf= - 3e-12 * 0 + 1e-11
parameters dwu0nrf=0
parameters dpu0nrf=0
parameters deta0nrf=0
parameters dleta0nrf= - 1.1e-09 * 0 - 0.6e-09
parameters dweta0nrf=0
parameters dpeta0nrf=2.85e-16
parameters dvsatnrf=0
parameters dlvsatnrf=-0.0002
parameters dwvsatnrf=0
parameters dpvsatnrf=-6.5e-11
parameters ntoxnrf=1.16
parameters dk2nrf=-0.013
parameters dlk2nrf=0
parameters dwk2nrf=-1.9e-09
parameters dpk2nrf=-1.2e-16
parameters dagsnrf=0
parameters dpclmnrf=0
parameters dppclmnrf=0
parameters dlcitnrf= - 5e-11 * 0
parameters dwcitnrf=0
parameters dpcitnrf=0
parameters da0nrf=0
parameters dla0nrf=0
parameters dwa0nrf=0
parameters dpa0nrf=0
parameters dvoffnrf=0
parameters dlvoffnrf=0.3e-9
parameters dwvoffnrf=0
parameters dpvoffnrf=0
parameters dkt1nrf=0
parameters dlkt1nrf=2e-10
parameters dwkt1nrf=0
parameters dpkt1nrf=0
parameters dkt2nrf=0.01
parameters dlkt2nrf=0
parameters dwkt2nrf=0
parameters dpkt2nrf=0
parameters dub1nrf=0
parameters dlub1nrf=0
parameters dwub1nrf=0
parameters dpub1nrf=0
parameters dua1nrf=0
parameters dlua1nrf=0
parameters dwua1nrf=0
parameters dpua1nrf=0
parameters datnrf=0
parameters dlatnrf=-0.00025
parameters dpatnrf=-6e-11
parameters dwatnrf=0
parameters dlagsnrf= - 0.5e-07
parameters dpagsnrf=1.7e-14
parameters b1fnrf=-6.5E+40           
parameters b2fnrf=0
parameters b3fnrf=-2.49E+7           
parameters a1fnrf=9.25e+41   
parameters a2fnrf=0  
parameters a3fnrf=1.475e+9  
parameters c1fnrf=1.5E+41     
parameters c2fnrf=1E+14  
parameters c3fnrf=5E+7 
parameters b1fprf=-5.5E+41   
parameters b2fprf=0    
parameters b3fprf=-7E+9   
parameters a1fprf=1.19E+43   
parameters a2fprf=3.995E+17  
parameters a3fprf=4E+10 
parameters c1fprf=1.2E+42   
parameters c2fprf=1E+15    
parameters c3fprf=1.5E+10    
parameters noianrf=a1fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b1fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c1fnrf
parameters noibnrf=a2fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b2fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c2fnrf
parameters noicnrf=a3fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b3fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c3fnrf
parameters noiaprf=a1fprf * (abs(noiseflagprf) + noiseflagprf) + b1fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c1fprf
parameters noibprf=a2fprf * (abs(noiseflagprf) + noiseflagprf) + b2fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c2fprf
parameters noicprf=a3fprf * (abs(noiseflagprf) + noiseflagprf) + b3fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c3fprf
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos
endsection ff_rfmos
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_rfmos
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf
parameters parn1rf=0
parameters parn2rf=0
parameters parp1rf=0
parameters parp2rf=0
parameters a1nrf=0.8
parameters a1prf=-0.8
parameters a2nrf=0
parameters a2prf=0
parameters a3nrf=-1
parameters a3prf=1
parameters a4nprf=0
parameters toxprf=2.2e-09 + 6.0000e-11 * a4nprf
parameters dxwprf=8e-09 * a3prf
parameters dxlprf=4e-09 * a2prf
parameters dvthprf= - 0.0288 * a1prf
parameters dlvthprf= - 5.5e-10 * a1prf
parameters dwvthprf= - 3.1e-09 * a1prf
parameters dpvthprf= - 1.71e-16 * a1prf
parameters cjprf=1.0600e-03 * (1 + 0.070 * a1prf)
parameters cjswprf=6.4000e-11 * (1 + 0.070 * a1prf)
parameters cjswgprf=2.5500e-10 * (1 + 0.070 * a1prf)
parameters cgoprf=3.01888e-11 * (1 - 0.070 * a4nprf)
parameters cglprf=5.24758e-11 * (1 - 0.070 * a4nprf)
parameters ddlcprf=4.74538e-09
parameters cfprf=1.38e-10 * (1 - 0.070 * a4nprf) + 4.6e-11
parameters drdswprf=0
parameters dnfactorprf=0
parameters dlnfactorprf=0
parameters dwnfactorprf=0
parameters dpnfactorprf=0
parameters du0prf=0.00012 * a1prf
parameters dlu0prf=1e-12 * a1prf
parameters dwu0prf= - 3e-11 * a1prf
parameters dpu0prf=1.3e-18 * a1prf
parameters deta0prf=0.1 * a1prf
parameters dleta0prf= - 3.8e-09 * a1prf
parameters dweta0prf= - 4.7e-08 * a1prf
parameters dpeta0prf=1.77e-15 * a1prf * 1.1
parameters dvsatprf=3000 * a1prf
parameters dlvsatprf=0.0003
parameters dwvsatprf=0
parameters dpvsatprf=0
parameters ntoxprf=1 +  - 3.9000e-01 * a4nprf
parameters dk2prf=0
parameters dlk2prf= - 1.0e-09 * a1prf * 0.4
parameters dwk2prf=1e-09 * a1prf
parameters dpk2prf= - 1.5e-17 * a1prf
parameters dagsprf=0.06 * a1prf
parameters dwagsprf=4e-08 * a1prf
parameters dpclmprf=0
parameters dla0prf=6e-08 * a1prf
parameters dlagsprf=0
parameters dpagsprf=0
parameters dwa0prf=0
parameters dpa0prf=0
parameters dlpclmprf=0
parameters dcitprf= - 0.0003 * a1prf
parameters dlcitprf= - 1.5e-11 * a1prf
parameters dwcitprf=0
parameters dpcitprf=0
parameters dvoffprf=0
parameters dlvoffprf=0
parameters dwvoffprf=0
parameters dpvoffprf=0
parameters da0prf=0
parameters jtsswgprf=7.2e-10
parameters dluteprf=0
parameters dlatprf=0
parameters ff_flagrf=0
parameters ss_flagrf=0
parameters fs_flagrf=0
parameters sf_flagrf=1
parameters toxnrf=2e-09 + 6.0000e-11 * a4nprf
parameters dxwnrf=8e-09 * a3nrf
parameters dxlnrf=4e-09 * a2nrf
parameters dvthnrf=0.0285 * a1nrf
parameters dlvthnrf=4.5e-10 * a1nrf
parameters dwvthnrf=5e-10 * a1nrf
parameters dpvthnrf=2.05e-16 * a1nrf
parameters cjnrf=1.2700e-03 * (1 + 0.070 * a1nrf)
parameters cjswnrf=6.4000e-11 * (1 + 0.070 * a1nrf)
parameters cjswgnrf=3.0500e-10 * (1 + 0.070 * a1nrf)
parameters cgonrf=5.72543e-11 * (1 - 0.070 * a4nprf)
parameters cglnrf=9.15784e-12 * (1 - 0.070 * a4nprf)
parameters ddlcnrf=3.24430e-09
parameters cfnrf=1.3900e-10 * (1 - 0.070 * a4nprf) + 4.1e-11
parameters drdswnrf=0
parameters dnfactornrf=0
parameters dlnfactornrf=0
parameters dwnfactornrf=0
parameters dpnfactornrf=0
parameters du0nrf=0
parameters dlu0nrf=3e-12 * a1nrf
parameters dwu0nrf=0
parameters dpu0nrf=0
parameters deta0nrf=0
parameters dleta0nrf=0.4e-09 * a1nrf
parameters dweta0nrf=0
parameters dpeta0nrf= - 2.85e-16 * a1nrf
parameters dvsatnrf=0
parameters dlvsatnrf= - 0.00015 * a1nrf
parameters dwvsatnrf=0
parameters dpvsatnrf=6.5e-11 * a1nrf
parameters ntoxnrf=1 +  - 1.6000e-01 * a4nprf
parameters dk2nrf=0.013 * a1nrf
parameters dlk2nrf=0
parameters dwk2nrf=1.9e-09 * a1nrf
parameters dpk2nrf=1.2e-16 * a1nrf
parameters dagsnrf=0.05 * a1nrf
parameters dpclmnrf=0
parameters dppclmnrf=0
parameters dlcitnrf=0
parameters dwcitnrf=0
parameters dpcitnrf=0
parameters da0nrf=0
parameters dla0nrf=0
parameters dwa0nrf=0
parameters dpa0nrf=0
parameters dvoffnrf=0
parameters dlvoffnrf= - 0.3e-09 * a1nrf
parameters dwvoffnrf=0
parameters dpvoffnrf=0
parameters dkt1nrf=0
parameters dlkt1nrf= - 2e-10 * a1nrf
parameters dwkt1nrf=0
parameters dpkt1nrf=0
parameters dkt2nrf=0
parameters dlkt2nrf=0
parameters dwkt2nrf=0
parameters dpkt2nrf=0
parameters dub1nrf=0
parameters dlub1nrf=0
parameters dwub1nrf=0
parameters dpub1nrf=0
parameters dua1nrf=0
parameters dlua1nrf=0
parameters dwua1nrf=0
parameters dpua1nrf=0
parameters datnrf=0
parameters dlatnrf=0.00025 * a1nrf
parameters dpatnrf=6e-11 * a1nrf
parameters dwatnrf=0
parameters dlagsnrf=0.5e-07 * a1nrf
parameters dpagsnrf= - 1.7e-14 * a1nrf
parameters b1fnrf=-6.5E+40           
parameters b2fnrf=0
parameters b3fnrf=-2.49E+7           
parameters a1fnrf=9.25e+41   
parameters a2fnrf=0  
parameters a3fnrf=1.475e+9  
parameters c1fnrf=1.5E+41     
parameters c2fnrf=1E+14  
parameters c3fnrf=5E+7 
parameters b1fprf=-5.5E+41   
parameters b2fprf=0    
parameters b3fprf=-7E+9   
parameters a1fprf=1.19E+43   
parameters a2fprf=3.995E+17  
parameters a3fprf=4E+10 
parameters c1fprf=1.2E+42   
parameters c2fprf=1E+15    
parameters c3fprf=1.5E+10   
parameters noianrf=a1fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b1fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c1fnrf
parameters noibnrf=a2fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b2fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c2fnrf
parameters noicnrf=a3fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b3fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c3fnrf
parameters noiaprf=a1fprf * (abs(noiseflagprf) + noiseflagprf) + b1fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c1fprf
parameters noibprf=a2fprf * (abs(noiseflagprf) + noiseflagprf) + b2fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c2fprf
parameters noicprf=a3fprf * (abs(noiseflagprf) + noiseflagprf) + b3fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c3fprf
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos
endsection sf_rfmos
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_rfmos
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf
parameters parn1rf=0
parameters parn2rf=0
parameters parp1rf=0
parameters parp2rf=0
parameters a1nrf=-0.8
parameters a1prf=0.8
parameters a2nrf=0
parameters a2prf=0
parameters a3nrf=1
parameters a3prf=-1
parameters a4nprf=0
parameters toxprf=2.2e-09 + 6.0000e-11 * a4nprf
parameters dxwprf=8e-09 * a3prf
parameters dxlprf=4e-09 * a2prf
parameters dvthprf= - 0.0288 * a1prf
parameters dlvthprf= - 5.5e-10 * a1prf
parameters dwvthprf= - 3.1e-09 * a1prf
parameters dpvthprf= - 1.71e-16 * a1prf
parameters cjprf=1.0600e-03 * (1 + 0.070 * a1prf)
parameters cjswprf=6.4000e-11 * (1 + 0.070 * a1prf)
parameters cjswgprf=2.5500e-10 * (1 + 0.070 * a1prf)
parameters cgoprf=3.01888e-11 * (1 - 0.070 * a4nprf)
parameters cglprf=5.24758e-11 * (1 - 0.070 * a4nprf)
parameters ddlcprf=4.74538e-09
parameters cfprf=1.3800e-10 * (1 - 0.070 * a4nprf) + 4.6e-11
parameters drdswprf=0
parameters dnfactorprf=0
parameters dlnfactorprf=0
parameters dwnfactorprf=0
parameters dpnfactorprf=0
parameters du0prf=0.00012 * a1prf
parameters dlu0prf=1e-12 * a1prf
parameters dwu0prf= - 3e-11 * a1prf
parameters dpu0prf=1.3e-18 * a1prf
parameters deta0prf=0.1 * a1prf
parameters dleta0prf= - 3.8e-09 * a1prf
parameters dweta0prf= - 2.0e-08 * a1prf
parameters dpeta0prf=1.77e-15 * a1prf * 0.5
parameters dvsatprf=3000 * a1prf
parameters dlvsatprf=-0.0003
parameters dwvsatprf=0
parameters dpvsatprf=0
parameters ntoxprf=1 +  - 3.9000e-01 * a4nprf
parameters dk2prf=0
parameters dlk2prf= - 1.0e-09 * a1prf * 0.4
parameters dwk2prf=1e-09 * a1prf
parameters dpk2prf= - 0e-17 * a1prf
parameters dagsprf=0.06 * a1prf
parameters dwagsprf=4e-08 * a1prf
parameters dpclmprf=0
parameters dla0prf=6e-08 * a1prf
parameters dlagsprf=0
parameters dpagsprf=0
parameters dwa0prf=0
parameters dpa0prf=0
parameters dlpclmprf=0
parameters dcitprf= - 0.0003 * a1prf
parameters dlcitprf= - 1.5e-11 * a1prf
parameters dwcitprf=0
parameters dpcitprf=0
parameters dvoffprf=0
parameters dlvoffprf=0
parameters dwvoffprf=0
parameters dpvoffprf=0
parameters da0prf=0
parameters jtsswgprf=7.2e-10
parameters dluteprf=0
parameters dlatprf=0
parameters ff_flagrf=0
parameters ss_flagrf=0
parameters fs_flagrf=1
parameters sf_flagrf=0
parameters toxnrf=2e-09 + 6.0000e-11 * a4nprf
parameters dxwnrf=8e-09 * a3nrf
parameters dxlnrf=4e-09 * a2nrf
parameters dvthnrf=0.0285 * a1nrf
parameters dlvthnrf=4.5e-10 * a1nrf
parameters dwvthnrf=5e-10 * a1nrf
parameters dpvthnrf=2.05e-16 * a1nrf
parameters cjnrf=1.2700e-03 * (1 + 0.070 * a1nrf)
parameters cjswnrf=6.4000e-11 * (1 + 0.070 * a1nrf)
parameters cjswgnrf=3.0500e-10 * (1 + 0.070 * a1nrf)
parameters cgonrf=5.72543e-11 * (1 - 0.070 * a4nprf)
parameters cglnrf=9.15784e-12 * (1 - 0.070 * a4nprf)
parameters ddlcnrf=3.24430e-09
parameters cfnrf=1.3900e-10 * (1 - 0.070 * a4nprf) + 4.1e-11
parameters drdswnrf=0
parameters dnfactornrf=0
parameters dlnfactornrf=0
parameters dwnfactornrf=0
parameters dpnfactornrf=0
parameters du0nrf=0
parameters dlu0nrf=3e-12 * a1nrf
parameters dwu0nrf=0
parameters dpu0nrf=0
parameters deta0nrf=0
parameters dleta0nrf=0.4e-09 * a1nrf
parameters dweta0nrf=0
parameters dpeta0nrf= - 2.85e-16 * a1nrf
parameters dvsatnrf=0
parameters dlvsatnrf= - 0.00015 * a1nrf
parameters dwvsatnrf=0
parameters dpvsatnrf=6.5e-11 * a1nrf
parameters ntoxnrf=1 +  - 1.6000e-01 * a4nprf
parameters dk2nrf=0.013 * a1nrf
parameters dlk2nrf=0
parameters dwk2nrf=1.9e-09 * a1nrf
parameters dpk2nrf=1.2e-16 * a1nrf
parameters dagsnrf=0.05 * a1nrf
parameters dpclmnrf=0
parameters dppclmnrf=0
parameters dlcitnrf=0
parameters dwcitnrf=0
parameters dpcitnrf=0
parameters da0nrf=0
parameters dla0nrf=0
parameters dwa0nrf=0
parameters dpa0nrf=0
parameters dvoffnrf=0
parameters dlvoffnrf= - 0.3e-09 * a1nrf
parameters dwvoffnrf=0
parameters dpvoffnrf=0
parameters dkt1nrf=0
parameters dlkt1nrf= - 2e-10 * a1nrf
parameters dwkt1nrf=0
parameters dpkt1nrf=0
parameters dkt2nrf=0
parameters dlkt2nrf=0
parameters dwkt2nrf=0
parameters dpkt2nrf=0
parameters dub1nrf=0
parameters dlub1nrf=0
parameters dwub1nrf=0
parameters dpub1nrf=0
parameters dua1nrf=0
parameters dlua1nrf=0
parameters dwua1nrf=0
parameters dpua1nrf=0
parameters datnrf=0
parameters dlatnrf=0.00025 * a1nrf
parameters dpatnrf=6e-11 * a1nrf
parameters dwatnrf=0
parameters dlagsnrf=0.5e-07 * a1nrf
parameters dpagsnrf= - 1.7e-14 * a1nrf
parameters b1fnrf=-6.5E+40           
parameters b2fnrf=0
parameters b3fnrf=-2.49E+7           
parameters a1fnrf=9.25e+41   
parameters a2fnrf=0  
parameters a3fnrf=1.475e+9  
parameters c1fnrf=1.5E+41     
parameters c2fnrf=1E+14  
parameters c3fnrf=5E+7 
parameters b1fprf=-5.5E+41   
parameters b2fprf=0    
parameters b3fprf=-7E+9   
parameters a1fprf=1.19E+43   
parameters a2fprf=3.995E+17  
parameters a3fprf=4E+10 
parameters c1fprf=1.2E+42   
parameters c2fprf=1E+15    
parameters c3fprf=1.5E+10     
parameters noianrf=a1fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b1fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c1fnrf
parameters noibnrf=a2fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b2fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c2fnrf
parameters noicnrf=a3fnrf * (abs(noiseflagnrf) + noiseflagnrf) + b3fnrf * (abs(noiseflagnrf) 
+ - noiseflagnrf) + c3fnrf
parameters noiaprf=a1fprf * (abs(noiseflagprf) + noiseflagprf) + b1fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c1fprf
parameters noibprf=a2fprf * (abs(noiseflagprf) + noiseflagprf) + b2fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c2fprf
parameters noicprf=a3fprf * (abs(noiseflagprf) + noiseflagprf) + b3fprf * (abs(noiseflagprf) 
+ - noiseflagprf) + c3fprf
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos
endsection fs_rfmos
 

 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_rfmos_18
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_18
parameters a1rf_18=par6 * 4.1285 * 3 / 1.85
parameters a2rf_18=par7 * 3.581 * 3 / 1.85
parameters a3rf_18=par8 * 2.9155 * 3 / 1.85
parameters a4rf_18=par9 * 0.7952 * 3 / 1.85
parameters parn1rf_18=0
parameters parn2rf_18=0
parameters parp1rf_18=0
parameters parp2rf_18=0
parameters toxnrf_18=5.6e-09 + ( - 2.5615e-011) * a1rf_18 + (6.1353e-011) 
+ * a2rf_18 + ( - 7.8327e-012) * a3rf_18 + (6.4438e-012) * a4rf_18
parameters dxlnrf_18=0 + ( - 1.0858e-009) * a1rf_18 + (1.2881e-009) * a2rf_18 
+ + ( - 1.8628e-010) * a3rf_18 + (3.1565e-011) * a4rf_18
parameters dxwnrf_18=0 + (1.073e-009) * a1rf_18 + ( - 2.6264e-009) * a2rf_18 
+ + ( - 2.052e-009) * a3rf_18 + ( - 4.6046e-010) * a4rf_18
parameters cjnrf_18=0.001051 + ( - 1.235e-005) * a1rf_18 + ( - 3.0305e-006) 
+ * a2rf_18 + (1.155e-005) * a3rf_18 + ( - 2.1341e-006) * a4rf_18
parameters cjswnrf_18=1.355e-10 + ( - 1.5904e-012) * a1rf_18 + ( - 3.9162e-013) 
+ * a2rf_18 + (1.4891e-012) * a3rf_18 + ( - 2.592e-013) * a4rf_18
parameters cjswgnrf_18=1.621e-10 + ( - 1.8941e-012) * a1rf_18 + ( - 4.7195e-013) 
+ * a2rf_18 + (1.7821e-012) * a3rf_18 + ( - 3.091e-013) * a4rf_18
parameters cgonrf_18=3.855e-11 + (2.306e-013) * a1rf_18 + ( - 5.5195e-013) 
+ * a2rf_18 + (7.0472e-014) * a3rf_18 + ( - 5.7939e-014) * a4rf_18
parameters cglnrf_18=2.513e-10 + (1.5032e-012) * a1rf_18 + ( - 3.598e-012) 
+ * a2rf_18 + (4.5938e-013) * a3rf_18 + ( - 3.777e-013) * a4rf_18
parameters dvthnrf_18=0 + ( - 0.0063639) * a1rf_18 + ( - 0.0015722) * a2rf_18 
+ + (0.0059665) * a3rf_18 + ( - 0.0010375) * a4rf_18
parameters dlvthnrf_18=0 + (1.7513e-010) * a1rf_18 + ( - 6.9137e-010) * 
+ a2rf_18 + ( - 3.1398e-010) * a3rf_18 + ( - 1.2413e-010) * a4rf_18
parameters dwvthnrf_18=0 + ( - 8.3735e-011) * a1rf_18 + ( - 2.0686e-011) 
+ * a2rf_18 + (7.8506e-011) * a3rf_18 + ( - 1.3652e-011) * a4rf_18
parameters dpvthnrf_18=0 + ( - 4.9068e-016) * a1rf_18 + ( - 3.2312e-017) 
+ * a2rf_18 + (4.9274e-016) * a3rf_18 + (1.0499e-018) * a4rf_18
parameters dlu0nrf_18=0 + (5.0241e-011) * a1rf_18 + (1.2412e-011) * a2rf_18 
+ + ( - 4.7104e-011) * a3rf_18 + (8.1911e-012) * a4rf_18
parameters dwu0nrf_18=0 + (1.9935e-011) * a1rf_18 + (2.664e-012) * a2rf_18 
+ + ( - 1.5509e-011) * a3rf_18 + (1.8423e-011) * a4rf_18
parameters dpu0nrf_18=0 + ( - 1.037e-017) * a1rf_18 + ( - 7.0838e-018) * 
+ a2rf_18 + (1.6087e-017) * a3rf_18 + (2.8655e-017) * a4rf_18
parameters dcitnrf_18=0 + ( - 1.6747e-005) * a1rf_18 + ( - 4.1373e-006) 
+ * a2rf_18 + (1.5701e-005) * a3rf_18 + ( - 2.7304e-006) * a4rf_18
parameters dwcitnrf_18=0 + (1.6747e-011) * a1rf_18 + (4.1373e-012) * a2rf_18 
+ + ( - 1.5701e-011) * a3rf_18 + (2.7304e-012) * a4rf_18
parameters deta0nrf_18=0 + ( - 0.0051851) * a1rf_18 + ( - 0.0035419) * a2rf_18 
+ + (0.0080433) * a3rf_18 + (0.014327) * a4rf_18
parameters cfnrf_18=9.000000e-011 + (5.3791e-013) * a1rf_18 + ( - 1.2884e-012) 
+ * a2rf_18 + (1.6449e-013) * a3rf_18 + ( - 1.3532e-013) * a4rf_18 + 
+ 2.4e-11
parameters dxlprf_18=0 + ( - 9.9299e-010) * a1rf_18 + (1.5909e-009) * a2rf_18 
+ + ( - 2.162e-010) * a3rf_18 + (1.0486e-010) * a4rf_18
parameters dxwprf_18=0 + (9.7619e-010) * a1rf_18 + ( - 2.2819e-009) * a2rf_18 
+ + (2.6786e-009) * a3rf_18 + ( - 5.5037e-011) * a4rf_18
parameters toxprf_18=5.9e-09 + ( - 2.5615e-011) * a1rf_18 + (6.1353e-011) 
+ * a2rf_18 + ( - 7.8327e-012) * a3rf_18 + (6.4438e-012) * a4rf_18
parameters cjprf_18=0.00112 + ( - 1.2935e-005) * a1rf_18 + ( - 6.2524e-006) 
+ * a2rf_18 + ( - 1.2293e-005) * a3rf_18 + ( - 4.5409e-006) * a4rf_18
parameters cjswprf_18=9e-11 + ( - 1.0436e-012) * a1rf_18 + ( - 5.0072e-013) 
+ * a2rf_18 + ( - 9.8822e-013) * a3rf_18 + ( - 3.6538e-013) * a4rf_18
parameters cjswgprf_18=1.7e-10 + ( - 1.9713e-012) * a1rf_18 + ( - 9.458e-013) 
+ * a2rf_18 + ( - 1.8666e-012) * a3rf_18 + ( - 6.9016e-013) * a4rf_18
parameters cgoprf_18=5.23324e-11 + (3.1281e-013) * a1rf_18 + ( - 7.4919e-013) 
+ * a2rf_18 + (9.5644e-014) * a3rf_18 + ( - 7.8129e-014) * a4rf_18
parameters cglprf_18=2.68907e-10 + (1.6071e-012) * a1rf_18 + ( - 3.8496e-012) 
+ * a2rf_18 + (4.9145e-013) * a3rf_18 + ( - 4.0371e-013) * a4rf_18
parameters dvthprf_18=0 + (0.0030887) * a1rf_18 + (0.0042809) * a2rf_18 
+ + (0.0012288) * a3rf_18 + (0.0030287) * a4rf_18
parameters dlvthprf_18=0 + (2.7388e-010) * a1rf_18 + (7.0657e-010) * a2rf_18 
+ + ( - 3.6515e-011) * a3rf_18 + (3.0717e-010) * a4rf_18
parameters dwvthprf_18=0 + (7.3006e-010) * a1rf_18 + ( - 7.2584e-011) * 
+ a2rf_18 + (1.3037e-009) * a3rf_18 + ( - 1.3163e-009) * a4rf_18
parameters dpvthprf_18=0 + (2.9312e-016) * a1rf_18 + (9.8592e-017) * a2rf_18 
+ + (2.3799e-016) * a3rf_18 + (3.0669e-016) * a4rf_18
parameters dlu0prf_18=0 + (1.0189e-012) * a1rf_18 + (1.0894e-012) * a2rf_18 
+ + (1.5301e-012) * a3rf_18 + ( - 2.5585e-012) * a4rf_18
parameters dwu0prf_18=0 + ( - 1.6566e-011) * a1rf_18 + ( - 7.9479e-012) 
+ * a2rf_18 + ( - 1.5686e-011) * a3rf_18 + ( - 5.7997e-012) * a4rf_18
parameters dlcitprf_18=0 + ( - 2.0377e-012) * a1rf_18 + ( - 2.1789e-012) 
+ * a2rf_18 + ( - 3.0602e-012) * a3rf_18 + (5.1171e-012) * a4rf_18
parameters dpvsatprf_18=0 + (1.414e-010) * a1rf_18 + ( - 4.5798e-011) * 
+ a2rf_18 + (1.8571e-010) * a3rf_18 + (3.1549e-011) * a4rf_18
parameters dleta0prf_18=0 + (3.9508e-009) * a1rf_18 + (1.2949e-009) * a2rf_18 
+ + (3.1757e-009) * a3rf_18 + (4.2985e-009) * a4rf_18
parameters dpa0prf_18=0 + ( - 1.8735e-014) * a1rf_18 + ( - 5.3852e-015) 
+ * a2rf_18 + ( - 1.4349e-014) * a3rf_18 + ( - 2.4051e-014) * a4rf_18
parameters cfprf_18=9.000000e-011 + (5.3791e-013) * a1rf_18 + ( - 1.2884e-012) 
+ * a2rf_18 + (1.6449e-013) * a3rf_18 + ( - 1.3532e-013) * a4rf_18 + 
+ 2.4e-11
parameters dlkt1prf_18=0 + (5.0943e-010) * a1rf_18 + (5.4472e-010) * a2rf_18 
+ + (7.6504e-010) * a3rf_18 + ( - 1.2793e-009) * a4rf_18
parameters dlcnrf_18=4.654e-08
parameters du0nrf_18=0
parameters dlcitnrf_18=0
parameters dpcitnrf_18=0
parameters dleta0nrf_18=0
parameters dweta0nrf_18=0
parameters dpeta0nrf_18=0
parameters dk2nrf_18=0
parameters dlk2nrf_18=0
parameters dwk2nrf_18=0
parameters dpk2nrf_18=0
parameters dk2rf_18=0
parameters dlcprf_18=5.49049e-08
parameters du0prf_18=0
parameters dpu0prf_18=0
parameters dnfactorprf_18=0
parameters dlnfactorprf_18=0
parameters dwnfactorprf_18=0
parameters dpnfactorprf_18=0
parameters dcitprf_18=0
parameters dwcitprf_18=0
parameters dpcitprf_18=0
parameters dvsatprf_18=0
parameters dlvsatprf_18=0
parameters dwvsatprf_18=0
parameters dpeta0prf_18=0
parameters dla0prf_18=0
parameters dwa0prf_18=0
parameters b1fnrf_18=-7.25E+40
parameters b2fnrf_18=4.75E+22 
parameters b3fnrf_18=-1.925E+8   
parameters a1fnrf_18=8.975E+41 
parameters a2fnrf_18=4.75E+22  
parameters a3fnrf_18=4.825e+8  
parameters c1fnrf_18=2.05E+41  
parameters c2fnrf_18=4E+10    
parameters c3fnrf_18=5.35e+8 
parameters b1fprf_18=-3.55E+41   
parameters b2fprf_18=0    
parameters b3fprf_18=-2.225E+9    
parameters a1fprf_18=1.573E+42    
parameters a2fprf_18=0  
parameters a3fprf_18=4.825E+9 
parameters c1fprf_18=8.05E+41     
parameters c2fprf_18=4E+10  
parameters c3fprf_18=5.35E+9    
parameters noianrf_18=a1fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b1fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c1fnrf_18
parameters noibnrf_18=a2fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b2fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c2fnrf_18
parameters noicnrf_18=a3fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b3fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c3fnrf_18
parameters noiaprf_18=a1fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b1fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c1fprf_18
parameters noibprf_18=a2fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b2fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c2fprf_18
parameters noicprf_18=a3fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b3fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c3fprf_18
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_18
endsection mc_rfmos_18
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_rfmos_18
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_18
parameters parn1rf_18=0
parameters parn2rf_18=0
parameters parp1rf_18=0
parameters parp2rf_18=0
parameters toxnrf_18=5.6e-09
parameters dxlnrf_18=0
parameters dxwnrf_18=0
parameters cjnrf_18=0.001051
parameters cjswnrf_18=1.355e-10
parameters cjswgnrf_18=1.621e-10
parameters dlcnrf_18=4.654e-08
parameters cgonrf_18=3.855e-11
parameters cglnrf_18=2.513e-10
parameters dvthnrf_18=0
parameters dlvthnrf_18=0
parameters dwvthnrf_18=0
parameters dpvthnrf_18=0
parameters du0nrf_18=0
parameters dlu0nrf_18=0
parameters dwu0nrf_18=0
parameters dpu0nrf_18=0
parameters dcitnrf_18=0
parameters dlcitnrf_18=0
parameters dwcitnrf_18=0
parameters dpcitnrf_18=0
parameters deta0nrf_18=0
parameters dleta0nrf_18=0
parameters dweta0nrf_18=0
parameters dpeta0nrf_18=0
parameters dk2nrf_18=0
parameters dlk2nrf_18=0
parameters dwk2nrf_18=0
parameters dpk2nrf_18=0
parameters cfnrf_18=9e-11 + 2.4e-11
parameters dk2rf_18=0
parameters dxlprf_18=0
parameters dxwprf_18=0
parameters toxprf_18=5.9e-09
parameters cjprf_18=0.00112
parameters cjswprf_18=9e-11
parameters cjswgprf_18=1.7e-10
parameters dlcprf_18=5.49049e-08
parameters cgoprf_18=5.23324e-11
parameters cglprf_18=2.68907e-10
parameters dvthprf_18=0
parameters dlvthprf_18=0
parameters dwvthprf_18=0
parameters dpvthprf_18=0
parameters du0prf_18=0
parameters dlu0prf_18=0
parameters dwu0prf_18=0
parameters dpu0prf_18=0
parameters dnfactorprf_18=0
parameters dlnfactorprf_18=0
parameters dwnfactorprf_18=0
parameters dpnfactorprf_18=0
parameters dcitprf_18=0
parameters dlcitprf_18=0
parameters dwcitprf_18=0
parameters dpcitprf_18=0
parameters dvsatprf_18=0
parameters dlvsatprf_18=0
parameters dwvsatprf_18=0
parameters dpvsatprf_18=0
parameters dleta0prf_18=0
parameters dpeta0prf_18=0
parameters dla0prf_18=0
parameters dwa0prf_18=0
parameters dpa0prf_18=0
parameters cfprf_18=9e-11 + 2.4e-11
parameters dlkt1prf_18=0
parameters b1fnrf_18=-7.25E+40
parameters b2fnrf_18=4.75E+22 
parameters b3fnrf_18=-1.925E+8   
parameters a1fnrf_18=8.975E+41 
parameters a2fnrf_18=4.75E+22  
parameters a3fnrf_18=4.825e+8  
parameters c1fnrf_18=2.05E+41  
parameters c2fnrf_18=4E+10    
parameters c3fnrf_18=5.35e+8 
parameters b1fprf_18=-3.55E+41   
parameters b2fprf_18=0    
parameters b3fprf_18=-2.225E+9    
parameters a1fprf_18=1.573E+42    
parameters a2fprf_18=0  
parameters a3fprf_18=4.825E+9 
parameters c1fprf_18=8.05E+41     
parameters c2fprf_18=4E+10  
parameters c3fprf_18=5.35E+9   
parameters noianrf_18=a1fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b1fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c1fnrf_18
parameters noibnrf_18=a2fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b2fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c2fnrf_18
parameters noicnrf_18=a3fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b3fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c3fnrf_18
parameters noiaprf_18=a1fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b1fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c1fprf_18
parameters noibprf_18=a2fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b2fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c2fprf_18
parameters noicprf_18=a3fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b3fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c3fprf_18
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_18
endsection tt_rfmos_18
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_rfmos_18
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_18
parameters parn1rf_18=0
parameters parn2rf_18=0
parameters parp1rf_18=0
parameters parp2rf_18=0
parameters toxnrf_18=5.9e-09
parameters dxlnrf_18=1e-08
parameters dxwnrf_18=-1.2e-08
parameters cjnrf_18=0.001125
parameters cjswnrf_18=1.45e-10
parameters cjswgnrf_18=1.734e-10
parameters dlcnrf_18=4.654e-08
parameters cgonrf_18=3.585e-11
parameters cglnrf_18=2.337e-10
parameters dvthnrf_18=0.038
parameters dlvthnrf_18=-2.5e-09
parameters dwvthnrf_18=5e-10
parameters dpvthnrf_18=3e-15
parameters du0nrf_18=0
parameters dlu0nrf_18=-3e-10
parameters dwu0nrf_18=-1.5e-10
parameters dpu0nrf_18=0
parameters dcitnrf_18=0.0001
parameters dlcitnrf_18=0
parameters dwcitnrf_18=-1e-10
parameters dpcitnrf_18=0
parameters deta0nrf_18=0
parameters dleta0nrf_18=0
parameters dweta0nrf_18=0
parameters dpeta0nrf_18=0
parameters dk2nrf_18=0
parameters dlk2nrf_18=0
parameters dwk2nrf_18=0
parameters dpk2nrf_18=0
parameters cfnrf_18=8.37e-11 + 2.4e-11
parameters dk2rf_18=0
parameters dxlprf_18=1e-08
parameters dxwprf_18=-1.2e-08
parameters toxprf_18=6.2e-09
parameters cjprf_18=0.001198
parameters cjswprf_18=9.63e-11
parameters cjswgprf_18=1.819e-10
parameters dlcprf_18=5.49049e-08
parameters cgoprf_18=4.8668e-11
parameters cglprf_18=2.50083e-10
parameters dvthprf_18=-0.015
parameters dlvthprf_18=-6e-10
parameters dwvthprf_18=-2.9e-09
parameters dpvthprf_18=-2.2e-15
parameters du0prf_18=0
parameters dlu0prf_18=0
parameters dwu0prf_18=1e-10
parameters dpu0prf_18=0
parameters dnfactorprf_18=0
parameters dlnfactorprf_18=0
parameters dwnfactorprf_18=0
parameters dpnfactorprf_18=0
parameters dcitprf_18=0
parameters dlcitprf_18=0
parameters dwcitprf_18=0
parameters dpcitprf_18=0
parameters dvsatprf_18=0
parameters dlvsatprf_18=0
parameters dwvsatprf_18=0
parameters dpvsatprf_18=-1.1e-09
parameters dleta0prf_18=-3e-08
parameters dpeta0prf_18=0
parameters dla0prf_18=0
parameters dwa0prf_18=0
parameters dpa0prf_18=1.5e-13
parameters cfprf_18=8.37e-11 + 2.4e-11
parameters dlkt1prf_18=0
parameters b1fnrf_18=-7.25E+40
parameters b2fnrf_18=4.75E+22 
parameters b3fnrf_18=-1.925E+8   
parameters a1fnrf_18=8.975E+41 
parameters a2fnrf_18=4.75E+22  
parameters a3fnrf_18=4.825e+8  
parameters c1fnrf_18=2.05E+41  
parameters c2fnrf_18=4E+10    
parameters c3fnrf_18=5.35e+8 
parameters b1fprf_18=-3.55E+41   
parameters b2fprf_18=0    
parameters b3fprf_18=-2.225E+9    
parameters a1fprf_18=1.573E+42    
parameters a2fprf_18=0  
parameters a3fprf_18=4.825E+9 
parameters c1fprf_18=8.05E+41     
parameters c2fprf_18=4E+10  
parameters c3fprf_18=5.35E+9   
parameters noianrf_18=a1fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b1fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c1fnrf_18
parameters noibnrf_18=a2fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b2fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c2fnrf_18
parameters noicnrf_18=a3fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b3fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c3fnrf_18
parameters noiaprf_18=a1fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b1fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c1fprf_18
parameters noibprf_18=a2fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b2fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c2fprf_18
parameters noicprf_18=a3fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b3fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c3fprf_18
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_18
endsection ss_rfmos_18
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_rfmos_18
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_18
parameters parn1rf_18=0
parameters parn2rf_18=0
parameters parp1rf_18=0
parameters parp2rf_18=0
parameters toxnrf_18=5.3e-09
parameters dxlnrf_18=-1e-08
parameters dxwnrf_18=1.2e-08
parameters cjnrf_18=0.0009774
parameters cjswnrf_18=1.26e-10
parameters cjswgnrf_18=1.508e-10
parameters dlcnrf_18=4.654e-08
parameters cgonrf_18=4.125e-11
parameters cglnrf_18=2.689e-10
parameters dvthnrf_18=-0.038
parameters dlvthnrf_18=2.5e-09
parameters dwvthnrf_18=-5e-10
parameters dpvthnrf_18=-3.2e-15
parameters du0nrf_18=0
parameters dlu0nrf_18=3e-10
parameters dwu0nrf_18=1e-10
parameters dpu0nrf_18=-1e-16
parameters dcitnrf_18=-0.0001
parameters dlcitnrf_18=0
parameters dwcitnrf_18=1e-10
parameters dpcitnrf_18=0
parameters deta0nrf_18=-0.05
parameters dleta0nrf_18=0
parameters dweta0nrf_18=0
parameters dpeta0nrf_18=0
parameters dk2nrf_18=0
parameters dlk2nrf_18=0
parameters dwk2nrf_18=0
parameters dpk2nrf_18=0
parameters cfnrf_18=9.63e-11 + 2.4e-11
parameters dk2rf_18=0
parameters dxlprf_18=-1e-08
parameters dxwprf_18=1.2e-08
parameters toxprf_18=5.6e-09
parameters cjprf_18=0.001042
parameters cjswprf_18=8.37e-11
parameters cjswgprf_18=1.581e-10
parameters dlcprf_18=5.49049e-08
parameters cgoprf_18=5.5995e-11
parameters cglprf_18=2.87729e-10
parameters dvthprf_18=0.01
parameters dlvthprf_18=2e-10
parameters dwvthprf_18=7.9e-09
parameters dpvthprf_18=1.5e-15
parameters du0prf_18=0
parameters dlu0prf_18=1e-11
parameters dwu0prf_18=-1e-10
parameters dpu0prf_18=0
parameters dnfactorprf_18=0
parameters dlnfactorprf_18=0
parameters dwnfactorprf_18=0
parameters dpnfactorprf_18=0
parameters dcitprf_18=0
parameters dlcitprf_18=-2e-11
parameters dwcitprf_18=0
parameters dpcitprf_18=0
parameters dvsatprf_18=0
parameters dlvsatprf_18=0
parameters dwvsatprf_18=0
parameters dpvsatprf_18=1.1e-09
parameters dleta0prf_18=2e-08
parameters dpeta0prf_18=0
parameters dla0prf_18=0
parameters dwa0prf_18=0
parameters dpa0prf_18=-9e-14
parameters cfprf_18=9.63e-11 + 2.4e-11
parameters dlkt1prf_18=5e-09
parameters b1fnrf_18=-7.25E+40
parameters b2fnrf_18=4.75E+22 
parameters b3fnrf_18=-1.925E+8   
parameters a1fnrf_18=8.975E+41 
parameters a2fnrf_18=4.75E+22  
parameters a3fnrf_18=4.825e+8  
parameters c1fnrf_18=2.05E+41  
parameters c2fnrf_18=4E+10    
parameters c3fnrf_18=5.35e+8 
parameters b1fprf_18=-3.55E+41   
parameters b2fprf_18=0    
parameters b3fprf_18=-2.225E+9    
parameters a1fprf_18=1.573E+42    
parameters a2fprf_18=0  
parameters a3fprf_18=4.825E+9 
parameters c1fprf_18=8.05E+41     
parameters c2fprf_18=4E+10  
parameters c3fprf_18=5.35E+9      
parameters noianrf_18=a1fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b1fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c1fnrf_18
parameters noibnrf_18=a2fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b2fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c2fnrf_18
parameters noicnrf_18=a3fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b3fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c3fnrf_18
parameters noiaprf_18=a1fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b1fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c1fprf_18
parameters noibprf_18=a2fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b2fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c2fprf_18
parameters noicprf_18=a3fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b3fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c3fprf_18
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_18
endsection ff_rfmos_18
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_rfmos_18
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_18
parameters parn1rf_18=0
parameters parn2rf_18=0
parameters parp1rf_18=0
parameters parp2rf_18=0
parameters a1nrf_18=0.8
parameters a1prf_18=-0.8
parameters a2nrf_18=0
parameters a2prf_18=0
parameters a3nrf_18=-1
parameters a3prf_18=1
parameters a4nprf_18=0
parameters toxnrf_18=5.6e-09 + 3.0000e-010 * a4nprf_18
parameters dxlnrf_18=1e-008 * a2nrf_18
parameters dxwnrf_18=1.2e-008 * a3nrf_18
parameters cjnrf_18=0.001051 * (1 + 0.070 * a1nrf_18)
parameters cjswnrf_18=1.355e-10 * (1 + 0.070 * a1nrf_18)
parameters cjswgnrf_18=1.621e-10 * (1 + 0.070 * a1nrf_18)
parameters dlcnrf_18=4.654e-08
parameters cgonrf_18=3.855e-11 * (1 - 0.070 * a4nprf_18)
parameters cglnrf_18=2.513e-10 * (1 - 0.070 * a4nprf_18)
parameters dvthnrf_18=0.038 * a1nrf_18
parameters dlvthnrf_18= - 2.5e-009 * a1nrf_18
parameters dwvthnrf_18=5e-010 * a1nrf_18
parameters dpvthnrf_18=3.2e-015 * a1nrf_18
parameters du0nrf_18=0
parameters dlu0nrf_18= - 3e-010 * a1nrf_18
parameters dwu0nrf_18= - 1e-010 * a1nrf_18
parameters dpu0nrf_18=1e-016 * a1nrf_18
parameters dcitnrf_18=0.0001 * a1nrf_18
parameters dlcitnrf_18=0
parameters dwcitnrf_18= - 1e-010 * a1nrf_18
parameters dpcitnrf_18=0
parameters deta0nrf_18=0.05 * a1nrf_18
parameters dleta0nrf_18=0
parameters dweta0nrf_18=0
parameters dpeta0nrf_18=0
parameters dk2nrf_18=0
parameters dlk2nrf_18=0
parameters dwk2nrf_18=0
parameters dpk2nrf_18=0
parameters cfnrf_18=9e-11 * (1 - 0.070 * a4nprf_18) + 2.4e-11
parameters dk2rf_18=0
parameters dxlprf_18=1e-008 * a2prf_18
parameters dxwprf_18=1.2e-008 * a3prf_18
parameters toxprf_18=5.9e-09 + 3.0000e-010 * a4nprf_18
parameters cjprf_18=0.00112 * (1 + 0.070 * a1prf_18)
parameters cjswprf_18=9e-11 * (1 + 0.070 * a1prf_18)
parameters cjswgprf_18=1.7e-10 * (1 + 0.070 * a1prf_18)
parameters dlcprf_18=5.49049e-08
parameters cgoprf_18=5.23324e-11 * (1 - 0.070 * a4nprf_18)
parameters cglprf_18=2.68907e-10 * (1 - 0.070 * a4nprf_18)
parameters dvthprf_18= - 0.01 * a1prf_18
parameters dlvthprf_18= - 2e-010 * a1prf_18
parameters dwvthprf_18= - 7.9e-009 * a1prf_18
parameters dpvthprf_18= - 1.5e-015 * a1prf_18
parameters du0prf_18=0
parameters dlu0prf_18= - 1e-011 * a1prf_18
parameters dwu0prf_18=1e-010 * a1prf_18
parameters dpu0prf_18=0
parameters dnfactorprf_18=0
parameters dlnfactorprf_18=0
parameters dwnfactorprf_18=0
parameters dpnfactorprf_18=0
parameters dcitprf_18=0
parameters dlcitprf_18=2e-011 * a1prf_18
parameters dwcitprf_18=0
parameters dpcitprf_18=0
parameters dvsatprf_18=0
parameters dlvsatprf_18=0
parameters dwvsatprf_18=0
parameters dpvsatprf_18= - 1.1e-009 * a1prf_18
parameters dleta0prf_18= - 2e-008 * a1prf_18
parameters dpeta0prf_18=0
parameters dla0prf_18=0
parameters dwa0prf_18=0
parameters dpa0prf_18=9e-014 * a1prf_18
parameters cfprf_18=9e-11 * (1 - 0.070 * a4nprf_18) + 2.4e-11
parameters dlkt1prf_18= - 5e-009 * a1prf_18
parameters b1fnrf_18=-7.25E+40
parameters b2fnrf_18=4.75E+22 
parameters b3fnrf_18=-1.925E+8   
parameters a1fnrf_18=8.975E+41 
parameters a2fnrf_18=4.75E+22  
parameters a3fnrf_18=4.825e+8  
parameters c1fnrf_18=2.05E+41  
parameters c2fnrf_18=4E+10    
parameters c3fnrf_18=5.35e+8 
parameters b1fprf_18=-3.55E+41   
parameters b2fprf_18=0    
parameters b3fprf_18=-2.225E+9    
parameters a1fprf_18=1.573E+42    
parameters a2fprf_18=0  
parameters a3fprf_18=4.825E+9 
parameters c1fprf_18=8.05E+41     
parameters c2fprf_18=4E+10  
parameters c3fprf_18=5.35E+9     
parameters noianrf_18=a1fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b1fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c1fnrf_18
parameters noibnrf_18=a2fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b2fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c2fnrf_18
parameters noicnrf_18=a3fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b3fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c3fnrf_18
parameters noiaprf_18=a1fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b1fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c1fprf_18
parameters noibprf_18=a2fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b2fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c2fprf_18
parameters noicprf_18=a3fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b3fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c3fprf_18
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_18
endsection sf_rfmos_18
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_rfmos_18
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_18
parameters parn1rf_18=0
parameters parn2rf_18=0
parameters parp1rf_18=0
parameters parp2rf_18=0
parameters a1nrf_18=-0.8
parameters a1prf_18=0.8
parameters a2nrf_18=0
parameters a2prf_18=0
parameters a3nrf_18=1
parameters a3prf_18=-1
parameters a4nprf_18=0
parameters toxnrf_18=5.6e-09 + 3.0000e-010 * a4nprf_18
parameters dxlnrf_18=1e-008 * a2nrf_18
parameters dxwnrf_18=1.2e-008 * a3nrf_18
parameters cjnrf_18=0.001051 * (1 + 0.070 * a1nrf_18)
parameters cjswnrf_18=1.355e-10 * (1 + 0.070 * a1nrf_18)
parameters cjswgnrf_18=1.621e-10 * (1 + 0.070 * a1nrf_18)
parameters dlcnrf_18=4.654e-08
parameters cgonrf_18=3.855e-11 * (1 - 0.070 * a4nprf_18)
parameters cglnrf_18=2.513e-10 * (1 - 0.070 * a4nprf_18)
parameters dvthnrf_18=0.038 * a1nrf_18
parameters dlvthnrf_18= - 2.5e-009 * a1nrf_18
parameters dwvthnrf_18=5e-010 * a1nrf_18
parameters dpvthnrf_18=3.2e-015 * a1nrf_18
parameters du0nrf_18=0
parameters dlu0nrf_18= - 3e-010 * a1nrf_18
parameters dwu0nrf_18= - 1e-010 * a1nrf_18
parameters dpu0nrf_18=1e-016 * a1nrf_18
parameters dcitnrf_18=0.0001 * a1nrf_18
parameters dlcitnrf_18=0
parameters dwcitnrf_18= - 1e-010 * a1nrf_18
parameters dpcitnrf_18=0
parameters deta0nrf_18=0.05 * a1nrf_18
parameters dleta0nrf_18=0
parameters dweta0nrf_18=0
parameters dpeta0nrf_18=0
parameters dk2nrf_18=0
parameters dlk2nrf_18=0
parameters dwk2nrf_18=0
parameters dpk2nrf_18=0
parameters cfnrf_18=9e-11 * (1 - 0.070 * a4nprf_18) + 2.4e-11
parameters dk2rf_18=0
parameters dxlprf_18=1e-008 * a2prf_18
parameters dxwprf_18=1.2e-008 * a3prf_18
parameters toxprf_18=5.9e-09 + 3.0000e-010 * a4nprf_18
parameters cjprf_18=0.00112 * (1 + 0.070 * a1prf_18)
parameters cjswprf_18=9e-11 * (1 + 0.070 * a1prf_18)
parameters cjswgprf_18=1.7e-10 * (1 + 0.070 * a1prf_18)
parameters dlcprf_18=5.49049e-08
parameters cgoprf_18=5.23324e-11 * (1 - 0.070 * a4nprf_18)
parameters cglprf_18=2.68907e-10 * (1 - 0.070 * a4nprf_18)
parameters dvthprf_18= - 0.01 * a1prf_18
parameters dlvthprf_18= - 2e-010 * a1prf_18
parameters dwvthprf_18= - 7.9e-009 * a1prf_18
parameters dpvthprf_18= - 1.5e-015 * a1prf_18
parameters du0prf_18=0
parameters dlu0prf_18= - 1e-011 * a1prf_18
parameters dwu0prf_18=1e-010 * a1prf_18
parameters dpu0prf_18=0
parameters dnfactorprf_18=0
parameters dlnfactorprf_18=0
parameters dwnfactorprf_18=0
parameters dpnfactorprf_18=0
parameters dcitprf_18=0
parameters dlcitprf_18=2e-011 * a1prf_18
parameters dwcitprf_18=0
parameters dpcitprf_18=0
parameters dvsatprf_18=0
parameters dlvsatprf_18=0
parameters dwvsatprf_18=0
parameters dpvsatprf_18= - 1.1e-009 * a1prf_18
parameters dleta0prf_18= - 2e-008 * a1prf_18
parameters dpeta0prf_18=0
parameters dla0prf_18=0
parameters dwa0prf_18=0
parameters dpa0prf_18=9e-014 * a1prf_18
parameters cfprf_18=9e-11 * (1 - 0.070 * a4nprf_18) + 2.4e-11
parameters dlkt1prf_18= - 5e-009 * a1prf_18
parameters b1fnrf_18=-7.25E+40
parameters b2fnrf_18=4.75E+22 
parameters b3fnrf_18=-1.925E+8   
parameters a1fnrf_18=8.975E+41 
parameters a2fnrf_18=4.75E+22  
parameters a3fnrf_18=4.825e+8  
parameters c1fnrf_18=2.05E+41  
parameters c2fnrf_18=4E+10    
parameters c3fnrf_18=5.35e+8 
parameters b1fprf_18=-3.55E+41   
parameters b2fprf_18=0    
parameters b3fprf_18=-2.225E+9    
parameters a1fprf_18=1.573E+42    
parameters a2fprf_18=0  
parameters a3fprf_18=4.825E+9 
parameters c1fprf_18=8.05E+41     
parameters c2fprf_18=4E+10  
parameters c3fprf_18=5.35E+9      
parameters noianrf_18=a1fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b1fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c1fnrf_18
parameters noibnrf_18=a2fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b2fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c2fnrf_18
parameters noicnrf_18=a3fnrf_18 * (abs(noiseflagnrf_18) + noiseflagnrf_18) 
+ + b3fnrf_18 * (abs(noiseflagnrf_18) - noiseflagnrf_18) + c3fnrf_18
parameters noiaprf_18=a1fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b1fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c1fprf_18
parameters noibprf_18=a2fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b2fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c2fprf_18
parameters noicprf_18=a3fprf_18 * (abs(noiseflagprf_18) + noiseflagprf_18) 
+ + b3fprf_18 * (abs(noiseflagprf_18) - noiseflagprf_18) + c3fprf_18
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_18
endsection fs_rfmos_18
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_rfmos_25
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_25
parameters a1rf_25=par6 * 4.3219e+000 * 3 / 2.1
parameters a2rf_25=par7 * 3.4010e+000 * 3 / 2.1
parameters a3rf_25=par8 * 2.8997e+000 * 3 / 2.1
parameters parn1rf_25=0
parameters parn2rf_25=0
parameters parp1rf_25=0
parameters parp2rf_25=0
parameters toxnrf_25=5.6000e-009 + ( - 5.4716e-012) * a1rf_25 + ( - 7.0317e-011) 
+ * a2rf_25 + ( - 1.6227e-011) * a3rf_25
parameters dxlnrf_25=0.0000e+000 + ( - 7.9271e-011) * a1rf_25 + ( - 2.2385e-009) 
+ * a2rf_25 + ( - 5.1409e-010) * a3rf_25
parameters dxwnrf_25=0.0000e+000 + (1.9090e-010) * a1rf_25 + (2.4225e-009) * a2rf_25 
+ + (2.9937e-009) * a3rf_25
parameters cjnrf_25=1.0510e-003 + (1.3228e-005) * a1rf_25 + ( - 6.2919e-007) * a2rf_25 
+ + ( - 1.1737e-005) * a3rf_25
parameters cjswnrf_25=1.3550e-010 + (1.7043e-012) * a1rf_25 + ( - 7.9152e-014) * 
+ a2rf_25 + ( - 1.5127e-012) * a3rf_25
parameters cjswgnrf_25=1.6210e-010 + (2.0333e-012) * a1rf_25 + ( - 8.6312e-014) 
+ * a2rf_25 + ( - 1.8079e-012) * a3rf_25
parameters cgonrf_25=3.8550e-011 + (4.9089e-014) * a1rf_25 + (6.3269e-013) * a2rf_25 
+ + (1.4600e-013) * a3rf_25
parameters cglnrf_25=2.5130e-010 + (3.2007e-013) * a1rf_25 + (4.1243e-012) * a2rf_25 
+ + (9.5175e-013) * a3rf_25
parameters dvthnrf_25=0.0000e+000 + (6.8227e-003) * a1rf_25 + ( - 3.0935e-004) * 
+ a2rf_25 + ( - 6.0588e-003) * a3rf_25
parameters dlvthnrf_25=0.0000e+000 + ( - 4.4886e-010) * a1rf_25 + (2.0352e-011) 
+ * a2rf_25 + (3.9860e-010) * a3rf_25
parameters dwvthnrf_25=0.0000e+000 + (8.9772e-011) * a1rf_25 + ( - 4.0705e-012) 
+ * a2rf_25 + ( - 7.9721e-011) * a3rf_25
parameters dpvthnrf_25=0.0000e+000 + (5.6621e-016) * a1rf_25 + ( - 1.2855e-017) 
+ * a2rf_25 + ( - 5.0727e-016) * a3rf_25
parameters dlu0nrf_25=0.0000e+000 + ( - 5.3863e-011) * a1rf_25 + (2.4423e-012) * 
+ a2rf_25 + (4.7832e-011) * a3rf_25
parameters dwu0nrf_25=0.0000e+000 + ( - 2.0037e-011) * a1rf_25 + (4.1130e-012) * 
+ a2rf_25 + (1.6678e-011) * a3rf_25
parameters dpu0nrf_25=0.0000e+000 + (1.3789e-017) * a1rf_25 + (5.7837e-018) * a2rf_25 
+ + ( - 1.4476e-017) * a3rf_25
parameters dcitnrf_25=0.0000e+000 + (1.7954e-005) * a1rf_25 + ( - 8.1409e-007) * 
+ a2rf_25 + ( - 1.5944e-005) * a3rf_25
parameters dlcitnrf_25=0.0000e+000 + ( - 8.2492e-012) * a1rf_25 + ( - 8.4309e-012) 
+ * a2rf_25 + ( - 2.1455e-012) * a3rf_25
parameters dwcitnrf_25=0.0000e+000 + ( - 1.7954e-011) * a1rf_25 + (8.1409e-013) 
+ * a2rf_25 + (1.5944e-011) * a3rf_25
parameters dpcitnrf_25=0.0000e+000 + (1.0312e-018) * a1rf_25 + (1.0539e-018) * a2rf_25 
+ + (2.6818e-019) * a3rf_25
parameters cfnrf_25=9.0000e-011 + (1.1490e-013) * a1rf_25 + (1.4766e-012) * a2rf_25 
+ + (3.4077e-013) * a3rf_25 + 2.4e-11
parameters dxlprf_25=0.0000e+000 + ( - 7.9271e-011) * a1rf_25 + ( - 2.2385e-009) 
+ * a2rf_25 + ( - 5.1409e-010) * a3rf_25
parameters dxwprf_25=0.0000e+000 + (2.4682e-010) * a1rf_25 + (3.2029e-009) * a2rf_25 
+ + ( - 1.6955e-009) * a3rf_25
parameters toxprf_25=5.9000e-009 + ( - 5.4716e-012) * a1rf_25 + ( - 7.0317e-011) 
+ * a2rf_25 + ( - 1.6227e-011) * a3rf_25
parameters cjprf_25=1.1200e-003 + (1.3750e-005) * a1rf_25 + ( - 4.6655e-006) * a2rf_25 
+ + (1.2019e-005) * a3rf_25
parameters cjswprf_25=9.0000e-011 + (1.1076e-012) * a1rf_25 + ( - 3.7905e-013) * 
+ a2rf_25 + (9.6497e-013) * a3rf_25
parameters cjswgprf_25=1.7000e-010 + (2.0922e-012) * a1rf_25 + ( - 7.1599e-013) 
+ * a2rf_25 + (1.8227e-012) * a3rf_25
parameters cgoprf_25=5.2332e-011 + (1.3774e-013) * a1rf_25 + (1.8487e-012) * a2rf_25 
+ + ( - 5.7507e-012) * a3rf_25
parameters cglprf_25=2.6891e-010 + (4.1880e-013) * a1rf_25 + (5.4647e-012) * a2rf_25 
+ + ( - 5.3077e-012) * a3rf_25
parameters dvthprf_25=0.0000e+000 + ( - 1.9664e-003) * a1rf_25 + (9.3156e-004) * 
+ a2rf_25 + ( - 1.4583e-003) * a3rf_25
parameters dlvthprf_25=0.0000e+000 + ( - 3.2016e-010) * a1rf_25 + (2.6802e-011) 
+ * a2rf_25 + ( - 3.6047e-010) * a3rf_25
parameters dwvthprf_25=0.0000e+000 + ( - 1.1807e-009) * a1rf_25 + (1.4543e-010) 
+ * a2rf_25 + ( - 1.2835e-009) * a3rf_25
parameters dpvthprf_25=0.0000e+000 + ( - 2.9288e-016) * a1rf_25 + (1.3644e-016) 
+ * a2rf_25 + ( - 2.1948e-016) * a3rf_25
parameters dlu0prf_25=0.0000e+000 + ( - 1.3417e-012) * a1rf_25 + ( - 5.8112e-014) 
+ * a2rf_25 + ( - 1.6785e-012) * a3rf_25
parameters dwu0prf_25=0.0000e+000 + (1.7582e-011) * a1rf_25 + ( - 6.0167e-012) * 
+ a2rf_25 + (1.5317e-011) * a3rf_25
parameters dlcitprf_25=0.0000e+000 + ( - 5.1558e-012) * a1rf_25 + ( - 5.2693e-012) 
+ * a2rf_25 + ( - 1.3409e-012) * a3rf_25
parameters dpvsatprf_25=0.0000e+000 + ( - 1.9340e-010) * a1rf_25 + (6.6184e-011) 
+ * a2rf_25 + ( - 1.6849e-010) * a3rf_25
parameters dleta0prf_25=0.0000e+000 + ( - 3.9328e-009) * a1rf_25 + (1.8631e-009) 
+ * a2rf_25 + ( - 2.9166e-009) * a3rf_25
parameters dpa0prf_25=0.0000e+000 + (1.8322e-014) * a1rf_25 + ( - 9.3737e-015) * 
+ a2rf_25 + (1.2904e-014) * a3rf_25
parameters cfprf_25=9.0000e-011 + (1.1490e-013) * a1rf_25 + (1.4766e-012) * a2rf_25 
+ + (3.4077e-013) * a3rf_25 + 2.4e-11
parameters dlcnrf_25=4.6540e-008
parameters du0nrf_25=0.0000e+000
parameters dk2nrf_25=0.0000e+000
parameters dlk2nrf_25=0.0000e+000
parameters dwk2nrf_25=0.0000e+000
parameters dpk2nrf_25=0.0000e+000
parameters dk2rf_25=0.0000e+000
parameters dlcprf_25=5.4905e-008
parameters du0prf_25=0.0000e+000
parameters dpu0prf_25=0.0000e+000
parameters dnfactorprf_25=0.0000e+000
parameters dlnfactorprf_25=0.0000e+000
parameters dwnfactorprf_25=0.0000e+000
parameters dpnfactorprf_25=0.0000e+000
parameters dcitprf_25=0.0000e+000
parameters dwcitprf_25=0.0000e+000
parameters dpcitprf_25=0.0000e+000
parameters dvsatprf_25=0.0000e+000
parameters dlvsatprf_25=0.0000e+000
parameters dwvsatprf_25=0.0000e+000
parameters dpeta0prf_25=0.0000e+000
parameters dla0prf_25=0.0000e+000
parameters dwa0prf_25=0.0000e+000
parameters b1fnrf_25=-7.25E+40
parameters b2fnrf_25=4.75E+22 
parameters b3fnrf_25=-1.925E+8   
parameters a1fnrf_25=8.975E+41 
parameters a2fnrf_25=4.75E+22  
parameters a3fnrf_25=4.825e+8  
parameters c1fnrf_25=2.05E+41  
parameters c2fnrf_25=4E+10    
parameters c3fnrf_25=5.35e+8 
parameters b1fprf_25=-3.55E+41   
parameters b2fprf_25=0    
parameters b3fprf_25=-2.225E+9    
parameters a1fprf_25=1.573E+42    
parameters a2fprf_25=0  
parameters a3fprf_25=4.825E+9 
parameters c1fprf_25=8.05E+41     
parameters c2fprf_25=4E+10  
parameters c3fprf_25=5.35E+9    
parameters noianrf_25=a1fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b1fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c1fnrf_25
parameters noibnrf_25=a2fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b2fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c2fnrf_25
parameters noicnrf_25=a3fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b3fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c3fnrf_25
parameters noiaprf_25=a1fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b1fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c1fprf_25
parameters noibprf_25=a2fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b2fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c2fprf_25
parameters noicprf_25=a3fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b3fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c3fprf_25
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_25
endsection mc_rfmos_25
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_rfmos_25
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_25
parameters parn1rf_25=0
parameters parn2rf_25=0
parameters parp1rf_25=0
parameters parp2rf_25=0
parameters toxnrf_25=5.6e-09
parameters dxlnrf_25=0
parameters dxwnrf_25=0
parameters cjnrf_25=1.051e-03
parameters cjswnrf_25=1.355e-10
parameters cjswgnrf_25=1.621e-10
parameters dlcnrf_25=4.654e-08
parameters cgonrf_25=3.855e-11
parameters cglnrf_25=2.513e-10
parameters dvthnrf_25=0
parameters dlvthnrf_25=0
parameters dwvthnrf_25=0
parameters dpvthnrf_25=0
parameters du0nrf_25=0
parameters dlu0nrf_25=0
parameters dwu0nrf_25=0
parameters dpu0nrf_25=0
parameters dcitnrf_25=0
parameters dlcitnrf_25=0
parameters dwcitnrf_25=0
parameters dpcitnrf_25=0
parameters dk2nrf_25=0
parameters dlk2nrf_25=0
parameters dwk2nrf_25=0
parameters dpk2nrf_25=0
parameters cfnrf_25=9.0000e-11 + 2.4e-11
parameters dk2rf_25=0
parameters dxlprf_25=0
parameters dxwprf_25=0
parameters toxprf_25=5.9e-09
parameters cjprf_25=0.00112
parameters cjswprf_25=9e-11
parameters cjswgprf_25=1.7e-10
parameters dlcprf_25=5.49049e-08
parameters cgoprf_25=5.23324e-11
parameters cglprf_25=2.68907e-10
parameters dvthprf_25=0
parameters dlvthprf_25=0
parameters dwvthprf_25=0
parameters dpvthprf_25=0
parameters du0prf_25=0
parameters dlu0prf_25=0
parameters dwu0prf_25=0
parameters dpu0prf_25=0
parameters dnfactorprf_25=0
parameters dlnfactorprf_25=0
parameters dwnfactorprf_25=0
parameters dpnfactorprf_25=0
parameters dcitprf_25=0
parameters dlcitprf_25=0
parameters dwcitprf_25=0
parameters dpcitprf_25=0
parameters dvsatprf_25=0
parameters dlvsatprf_25=0
parameters dwvsatprf_25=0
parameters dpvsatprf_25=0
parameters dleta0prf_25=0
parameters dpeta0prf_25=0
parameters dla0prf_25=0
parameters dwa0prf_25=0
parameters dpa0prf_25=0
parameters cfprf_25=9e-11 + 2.4e-11
parameters b1fnrf_25=-7.25E+40
parameters b2fnrf_25=4.75E+22 
parameters b3fnrf_25=-1.925E+8   
parameters a1fnrf_25=8.975E+41 
parameters a2fnrf_25=4.75E+22  
parameters a3fnrf_25=4.825e+8  
parameters c1fnrf_25=2.05E+41  
parameters c2fnrf_25=4E+10    
parameters c3fnrf_25=5.35e+8 
parameters b1fprf_25=-3.55E+41   
parameters b2fprf_25=0    
parameters b3fprf_25=-2.225E+9    
parameters a1fprf_25=1.573E+42    
parameters a2fprf_25=0  
parameters a3fprf_25=4.825E+9 
parameters c1fprf_25=8.05E+41     
parameters c2fprf_25=4E+10  
parameters c3fprf_25=5.35E+9     
parameters noianrf_25=a1fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b1fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c1fnrf_25
parameters noibnrf_25=a2fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b2fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c2fnrf_25
parameters noicnrf_25=a3fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b3fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c3fnrf_25
parameters noiaprf_25=a1fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b1fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c1fprf_25
parameters noibprf_25=a2fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b2fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c2fprf_25
parameters noicprf_25=a3fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b3fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c3fprf_25
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_25
endsection tt_rfmos_25
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_rfmos_25
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_25
parameters parn1rf_25=0
parameters parn2rf_25=0
parameters parp1rf_25=0
parameters parp2rf_25=0
parameters toxnrf_25=5.9e-09
parameters dxlnrf_25=1e-08
parameters dxwnrf_25=-1.2e-08
parameters cjnrf_25=1.125e-03
parameters cjswnrf_25=1.450e-10
parameters cjswgnrf_25=1.734e-10
parameters dlcnrf_25=4.654e-08
parameters cgonrf_25=3.585e-11
parameters cglnrf_25=2.337e-10
parameters dvthnrf_25=0.038
parameters dlvthnrf_25=-2.5e-09
parameters dwvthnrf_25=5e-10
parameters dpvthnrf_25=3e-15
parameters du0nrf_25=0
parameters dlu0nrf_25=-3e-10
parameters dwu0nrf_25=-1.5e-10
parameters dpu0nrf_25=0
parameters dcitnrf_25=0.0001
parameters dlcitnrf_25=0
parameters dwcitnrf_25=-1e-10
parameters dpcitnrf_25=0
parameters dk2nrf_25=0
parameters dlk2nrf_25=0
parameters dwk2nrf_25=0
parameters dpk2nrf_25=0
parameters cfnrf_25=8.370e-11 + 2.4e-11
parameters dk2rf_25=0
parameters dxlprf_25=1e-08
parameters dxwprf_25=-1.2e-08
parameters toxprf_25=6.2e-09
parameters cjprf_25=0.001198
parameters cjswprf_25=9.63e-11
parameters cjswgprf_25=1.819e-10
parameters dlcprf_25=5.49049e-08
parameters cgoprf_25=4.8668e-11
parameters cglprf_25=2.50083e-10
parameters dvthprf_25=-0.015
parameters dlvthprf_25=-6e-10
parameters dwvthprf_25=-2.9e-09
parameters dpvthprf_25=-2.2e-15
parameters du0prf_25=0
parameters dlu0prf_25=0
parameters dwu0prf_25=1e-10
parameters dpu0prf_25=0
parameters dnfactorprf_25=0
parameters dlnfactorprf_25=0
parameters dwnfactorprf_25=0
parameters dpnfactorprf_25=0
parameters dcitprf_25=0
parameters dlcitprf_25=0
parameters dwcitprf_25=0
parameters dpcitprf_25=0
parameters dvsatprf_25=0
parameters dlvsatprf_25=0
parameters dwvsatprf_25=0
parameters dpvsatprf_25=-1.1e-09
parameters dleta0prf_25=-3e-08
parameters dpeta0prf_25=0
parameters dla0prf_25=0
parameters dwa0prf_25=0
parameters dpa0prf_25=1.5e-13
parameters cfprf_25=8.37e-11 + 2.4e-11
parameters b1fnrf_25=-7.25E+40
parameters b2fnrf_25=4.75E+22 
parameters b3fnrf_25=-1.925E+8   
parameters a1fnrf_25=8.975E+41 
parameters a2fnrf_25=4.75E+22  
parameters a3fnrf_25=4.825e+8  
parameters c1fnrf_25=2.05E+41  
parameters c2fnrf_25=4E+10    
parameters c3fnrf_25=5.35e+8 
parameters b1fprf_25=-3.55E+41   
parameters b2fprf_25=0    
parameters b3fprf_25=-2.225E+9    
parameters a1fprf_25=1.573E+42    
parameters a2fprf_25=0  
parameters a3fprf_25=4.825E+9 
parameters c1fprf_25=8.05E+41     
parameters c2fprf_25=4E+10  
parameters c3fprf_25=5.35E+9   
parameters noianrf_25=a1fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b1fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c1fnrf_25
parameters noibnrf_25=a2fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b2fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c2fnrf_25
parameters noicnrf_25=a3fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b3fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c3fnrf_25
parameters noiaprf_25=a1fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b1fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c1fprf_25
parameters noibprf_25=a2fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b2fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c2fprf_25
parameters noicprf_25=a3fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b3fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c3fprf_25
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_25
endsection ss_rfmos_25
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_rfmos_25
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_25
parameters parn1rf_25=0
parameters parn2rf_25=0
parameters parp1rf_25=0
parameters parp2rf_25=0
parameters toxnrf_25=5.3e-09
parameters dxlnrf_25=-1e-08
parameters dxwnrf_25=1.2e-08
parameters cjnrf_25=9.774e-04
parameters cjswnrf_25=1.260e-10
parameters cjswgnrf_25=1.508e-10
parameters dlcnrf_25=4.654e-08
parameters cgonrf_25=4.125e-11
parameters cglnrf_25=2.689e-10
parameters dvthnrf_25=-0.038
parameters dlvthnrf_25=2.5e-09
parameters dwvthnrf_25=-5e-10
parameters dpvthnrf_25=-3.2e-15
parameters du0nrf_25=0
parameters dlu0nrf_25=3e-10
parameters dwu0nrf_25=1e-10
parameters dpu0nrf_25=-1e-16
parameters dcitnrf_25=-0.0001
parameters dlcitnrf_25=0
parameters dwcitnrf_25=1e-10
parameters dpcitnrf_25=0
parameters dk2nrf_25=0
parameters dlk2nrf_25=0
parameters dwk2nrf_25=0
parameters dpk2nrf_25=0
parameters cfnrf_25=9.630e-11 + 2.4e-11
parameters dk2rf_25=0
parameters dxlprf_25=-1e-08
parameters dxwprf_25=1.2e-08
parameters toxprf_25=5.6e-09
parameters cjprf_25=0.001042
parameters cjswprf_25=8.37e-11
parameters cjswgprf_25=1.581e-10
parameters dlcprf_25=5.49049e-08
parameters cgoprf_25=5.5995e-11
parameters cglprf_25=2.87729e-10
parameters dvthprf_25=0.01
parameters dlvthprf_25=2.2e-09
parameters dwvthprf_25=7.9e-09
parameters dpvthprf_25=1.5e-15
parameters du0prf_25=0
parameters dlu0prf_25=1e-11
parameters dwu0prf_25=-1e-10
parameters dpu0prf_25=0
parameters dnfactorprf_25=0
parameters dlnfactorprf_25=0
parameters dwnfactorprf_25=0
parameters dpnfactorprf_25=0
parameters dcitprf_25=0
parameters dlcitprf_25=0
parameters dwcitprf_25=0
parameters dpcitprf_25=0
parameters dvsatprf_25=0
parameters dlvsatprf_25=0
parameters dwvsatprf_25=0
parameters dpvsatprf_25=1.1e-09
parameters dleta0prf_25=2e-08
parameters dpeta0prf_25=0
parameters dla0prf_25=0
parameters dwa0prf_25=0
parameters dpa0prf_25=-9e-14
parameters cfprf_25=9.63e-11 + 2.4e-11
parameters b1fnrf_25=-7.25E+40
parameters b2fnrf_25=4.75E+22 
parameters b3fnrf_25=-1.925E+8   
parameters a1fnrf_25=8.975E+41 
parameters a2fnrf_25=4.75E+22  
parameters a3fnrf_25=4.825e+8  
parameters c1fnrf_25=2.05E+41  
parameters c2fnrf_25=4E+10    
parameters c3fnrf_25=5.35e+8 
parameters b1fprf_25=-3.55E+41   
parameters b2fprf_25=0    
parameters b3fprf_25=-2.225E+9    
parameters a1fprf_25=1.573E+42    
parameters a2fprf_25=0  
parameters a3fprf_25=4.825E+9 
parameters c1fprf_25=8.05E+41     
parameters c2fprf_25=4E+10  
parameters c3fprf_25=5.35E+9   
parameters noianrf_25=a1fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b1fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c1fnrf_25
parameters noibnrf_25=a2fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b2fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c2fnrf_25
parameters noicnrf_25=a3fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b3fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c3fnrf_25
parameters noiaprf_25=a1fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b1fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c1fprf_25
parameters noibprf_25=a2fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b2fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c2fprf_25
parameters noicprf_25=a3fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b3fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c3fprf_25
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_25
endsection ff_rfmos_25
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_rfmos_25
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_25
parameters parn1rf_25=0
parameters parn2rf_25=0
parameters parp1rf_25=0
parameters parp2rf_25=0
parameters a1nrf_25=0.8
parameters a1prf_25=-0.8
parameters a2nrf_25=0
parameters a2prf_25=0
parameters a3nrf_25=-1
parameters a3prf_25=1
parameters a4nprf_25=0
parameters toxnrf_25=5.6e-09 + 3.0000e-010 * a4nprf_25
parameters dxlnrf_25=1e-008 * a2nrf_25
parameters dxwnrf_25=1.2e-008 * a3nrf_25
parameters cjnrf_25=1.051e-03 * (1 + 0.070 * a1nrf_25)
parameters cjswnrf_25=1.355e-10 * (1 + 0.070 * a1nrf_25)
parameters cjswgnrf_25=1.621e-10 * (1 + 0.070 * a1nrf_25)
parameters dlcnrf_25=4.654e-08
parameters cgonrf_25=3.855e-11 * (1 - 0.070 * a4nprf_25)
parameters cglnrf_25=2.513e-10 * (1 - 0.070 * a4nprf_25)
parameters dvthnrf_25=0.038 * a1nrf_25
parameters dlvthnrf_25= - 2.5e-009 * a1nrf_25
parameters dwvthnrf_25=5e-010 * a1nrf_25
parameters dpvthnrf_25=3.2e-015 * a1nrf_25
parameters du0nrf_25=0
parameters dlu0nrf_25= - 3e-010 * a1nrf_25
parameters dwu0nrf_25= - 1e-010 * a1nrf_25
parameters dpu0nrf_25=1e-016 * a1nrf_25
parameters dcitnrf_25=0.0001 * a1nrf_25
parameters dlcitnrf_25=0
parameters dwcitnrf_25= - 1e-010 * a1nrf_25
parameters dpcitnrf_25=0
parameters dk2nrf_25=0
parameters dlk2nrf_25=0
parameters dwk2nrf_25=0
parameters dpk2nrf_25=0
parameters cfnrf_25=9.0000e-11 * (1 - 0.070 * a4nprf_25) + 2.4e-11
parameters dk2rf_25=0
parameters dxlprf_25=1e-008 * a2prf_25
parameters dxwprf_25=1.2e-008 * a3prf_25
parameters toxprf_25=5.9e-09 + 3.0000e-010 * a4nprf_25
parameters cjprf_25=0.00112 * (1 + 0.070 * a1prf_25)
parameters cjswprf_25=9e-11 * (1 + 0.070 * a1prf_25)
parameters cjswgprf_25=1.7e-10 * (1 + 0.070 * a1prf_25)
parameters dlcprf_25=5.49049e-08
parameters cgoprf_25=5.23324e-11 +  - 3.8059e-011 * a1prf_25
parameters cglprf_25=2.68907e-10 +  - 4.0471e-011 * a1prf_25
parameters dvthprf_25= - 0.01 * a1prf_25
parameters dlvthprf_25= - 2.2e-009 * a1prf_25
parameters dwvthprf_25= - 7.9e-009 * a1prf_25
parameters dpvthprf_25= - 1.5e-015 * a1prf_25
parameters du0prf_25=0
parameters dlu0prf_25= - 1e-011 * a1prf_25
parameters dwu0prf_25=1e-010 * a1prf_25
parameters dpu0prf_25=0
parameters dnfactorprf_25=0
parameters dlnfactorprf_25=0
parameters dwnfactorprf_25=0
parameters dpnfactorprf_25=0
parameters dcitprf_25=0
parameters dlcitprf_25=0
parameters dwcitprf_25=0
parameters dpcitprf_25=0
parameters dvsatprf_25=0
parameters dlvsatprf_25=0
parameters dwvsatprf_25=0
parameters dpvsatprf_25= - 1.1e-009 * a1prf_25
parameters dleta0prf_25= - 2e-008 * a1prf_25
parameters dpeta0prf_25=0
parameters dla0prf_25=0
parameters dwa0prf_25=0
parameters dpa0prf_25=9e-014 * a1prf_25
parameters cfprf_25=9e-11 * (1 - 0.070 * a4nprf_25) + 2.4e-11
parameters b1fnrf_25=-7.25E+40
parameters b2fnrf_25=4.75E+22 
parameters b3fnrf_25=-1.925E+8   
parameters a1fnrf_25=8.975E+41 
parameters a2fnrf_25=4.75E+22  
parameters a3fnrf_25=4.825e+8  
parameters c1fnrf_25=2.05E+41  
parameters c2fnrf_25=4E+10    
parameters c3fnrf_25=5.35e+8 
parameters b1fprf_25=-3.55E+41   
parameters b2fprf_25=0    
parameters b3fprf_25=-2.225E+9    
parameters a1fprf_25=1.573E+42    
parameters a2fprf_25=0  
parameters a3fprf_25=4.825E+9 
parameters c1fprf_25=8.05E+41     
parameters c2fprf_25=4E+10  
parameters c3fprf_25=5.35E+9   
parameters noianrf_25=a1fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b1fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c1fnrf_25
parameters noibnrf_25=a2fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b2fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c2fnrf_25
parameters noicnrf_25=a3fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b3fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c3fnrf_25
parameters noiaprf_25=a1fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b1fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c1fprf_25
parameters noibprf_25=a2fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b2fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c2fprf_25
parameters noicprf_25=a3fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b3fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c3fprf_25
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_25
endsection sf_rfmos_25
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_rfmos_25
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_25
parameters parn1rf_25=0
parameters parn2rf_25=0
parameters parp1rf_25=0
parameters parp2rf_25=0
parameters a1nrf_25=-0.8
parameters a1prf_25=0.8
parameters a2nrf_25=0
parameters a2prf_25=0
parameters a3nrf_25=1
parameters a3prf_25=-1
parameters a4nprf_25=0
parameters toxnrf_25=5.6e-09 + 3.0000e-010 * a4nprf_25
parameters dxlnrf_25=1e-008 * a2nrf_25
parameters dxwnrf_25=1.2e-008 * a3nrf_25
parameters cjnrf_25=1.051e-03 * (1 + 0.070 * a1nrf_25)
parameters cjswnrf_25=1.355e-10 * (1 + 0.070 * a1nrf_25)
parameters cjswgnrf_25=1.621e-10 * (1 + 0.070 * a1nrf_25)
parameters dlcnrf_25=4.654e-08
parameters cgonrf_25=3.855e-11 * (1 - 0.070 * a4nprf_25)
parameters cglnrf_25=2.513e-10 * (1 - 0.070 * a4nprf_25)
parameters dvthnrf_25=0.038 * a1nrf_25
parameters dlvthnrf_25= - 2.5e-009 * a1nrf_25
parameters dwvthnrf_25=5e-010 * a1nrf_25
parameters dpvthnrf_25=3.2e-015 * a1nrf_25
parameters du0nrf_25=0
parameters dlu0nrf_25= - 3e-010 * a1nrf_25
parameters dwu0nrf_25= - 1e-010 * a1nrf_25
parameters dpu0nrf_25=1e-016 * a1nrf_25
parameters dcitnrf_25=0.0001 * a1nrf_25
parameters dlcitnrf_25=0
parameters dwcitnrf_25= - 1e-010 * a1nrf_25
parameters dpcitnrf_25=0
parameters dk2nrf_25=0
parameters dlk2nrf_25=0
parameters dwk2nrf_25=0
parameters dpk2nrf_25=0
parameters cfnrf_25=9.0000e-11 * (1 - 0.070 * a4nprf_25) + 2.4e-11
parameters dk2rf_25=0
parameters dxlprf_25=1e-008 * a2prf_25
parameters dxwprf_25=1.2e-008 * a3prf_25
parameters toxprf_25=5.9e-09 + 3.0000e-010 * a4nprf_25
parameters cjprf_25=0.00112 * (1 + 0.070 * a1prf_25)
parameters cjswprf_25=9e-11 * (1 + 0.070 * a1prf_25)
parameters cjswgprf_25=1.7e-10 * (1 + 0.070 * a1prf_25)
parameters dlcprf_25=5.49049e-08
parameters cgoprf_25=5.23324e-11 +  - 3.8059e-011 * a1prf_25
parameters cglprf_25=2.68907e-10 +  - 4.0471e-011 * a1prf_25
parameters dvthprf_25= - 0.01 * a1prf_25
parameters dlvthprf_25= - 2.2e-009 * a1prf_25
parameters dwvthprf_25= - 7.9e-009 * a1prf_25
parameters dpvthprf_25= - 1.5e-015 * a1prf_25
parameters du0prf_25=0
parameters dlu0prf_25= - 1e-011 * a1prf_25
parameters dwu0prf_25=1e-010 * a1prf_25
parameters dpu0prf_25=0
parameters dnfactorprf_25=0
parameters dlnfactorprf_25=0
parameters dwnfactorprf_25=0
parameters dpnfactorprf_25=0
parameters dcitprf_25=0
parameters dlcitprf_25=0
parameters dwcitprf_25=0
parameters dpcitprf_25=0
parameters dvsatprf_25=0
parameters dlvsatprf_25=0
parameters dwvsatprf_25=0
parameters dpvsatprf_25= - 1.1e-009 * a1prf_25
parameters dleta0prf_25= - 2e-008 * a1prf_25
parameters dpeta0prf_25=0
parameters dla0prf_25=0
parameters dwa0prf_25=0
parameters dpa0prf_25=9e-014 * a1prf_25
parameters cfprf_25=9e-11 * (1 - 0.070 * a4nprf_25) + 2.4e-11
parameters b1fnrf_25=-7.25E+40
parameters b2fnrf_25=4.75E+22 
parameters b3fnrf_25=-1.925E+8   
parameters a1fnrf_25=8.975E+41 
parameters a2fnrf_25=4.75E+22  
parameters a3fnrf_25=4.825e+8  
parameters c1fnrf_25=2.05E+41  
parameters c2fnrf_25=4E+10    
parameters c3fnrf_25=5.35e+8 
parameters b1fprf_25=-3.55E+41   
parameters b2fprf_25=0    
parameters b3fprf_25=-2.225E+9    
parameters a1fprf_25=1.573E+42    
parameters a2fprf_25=0  
parameters a3fprf_25=4.825E+9 
parameters c1fprf_25=8.05E+41     
parameters c2fprf_25=4E+10  
parameters c3fprf_25=5.35E+9   
parameters noianrf_25=a1fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b1fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c1fnrf_25
parameters noibnrf_25=a2fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b2fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c2fnrf_25
parameters noicnrf_25=a3fnrf_25 * (abs(noiseflagnrf_25) + noiseflagnrf_25) + b3fnrf_25 
+ * (abs(noiseflagnrf_25) - noiseflagnrf_25) + c3fnrf_25
parameters noiaprf_25=a1fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b1fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c1fprf_25
parameters noibprf_25=a2fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b2fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c2fprf_25
parameters noicprf_25=a3fprf_25 * (abs(noiseflagprf_25) + noiseflagprf_25) + b3fprf_25 
+ * (abs(noiseflagprf_25) - noiseflagprf_25) + c3fprf_25
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_25
endsection fs_rfmos_25
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_rfmos_33
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_33
parameters a1rf_33=par6 * 4.4286e+000 * 3 / 2.1
parameters a2rf_33=par7 * 3.5643e+000 * 3 / 2.1
parameters a3rf_33=par8 * 2.7400e+000 * 3 / 2.1
parameters a4rf_33=par9 * 1.0842e+000 * 3 / 2.1
parameters parn1rf_33=0
parameters parn2rf_33=0
parameters parp1rf_33=0
parameters parp2rf_33=0
parameters toxnrf_33=5.6000e-009 + ( - 6.5018e-012) * a1rf_33 + ( - 6.7923e-011) 
+ * a2rf_33 + ( - 3.6884e-012) * a3rf_33 + (1.9727e-011) * a4rf_33
parameters dxlnrf_33=0.0000e+000 + ( - 2.9725e-010) * a1rf_33 + ( - 2.1376e-009) 
+ * a2rf_33 + ( - 1.0726e-010) * a3rf_33 + (6.2908e-010) * a4rf_33
parameters dxwnrf_33=0.0000e+000 + (1.6711e-010) * a1rf_33 + (2.8058e-009) 
+ * a2rf_33 + ( - 2.3725e-009) * a3rf_33 + ( - 1.0008e-009) * a4rf_33
parameters cjnrf_33=1.0510e-003 + ( - 1.2419e-005) * a1rf_33 + (5.6657e-007) 
+ * a2rf_33 + (1.3650e-005) * a3rf_33 + (1.8119e-006) * a4rf_33
parameters cjswnrf_33=1.3550e-010 + ( - 1.5995e-012) * a1rf_33 + (7.4816e-014) 
+ * a2rf_33 + (1.7597e-012) * a3rf_33 + (2.4460e-013) * a4rf_33
parameters cjswgnrf_33=1.6210e-010 + ( - 1.9069e-012) * a1rf_33 + (9.5990e-014) 
+ * a2rf_33 + (2.1049e-012) * a3rf_33 + (2.9020e-013) * a4rf_33
parameters cgonrf_33=3.8550e-011 + (5.8637e-014) * a1rf_33 + (6.1111e-013) 
+ * a2rf_33 + (3.3172e-014) * a3rf_33 + ( - 1.7750e-013) * a4rf_33
parameters cglnrf_33=2.5130e-010 + (3.8216e-013) * a1rf_33 + (3.9837e-012) 
+ * a2rf_33 + (2.1625e-013) * a3rf_33 + ( - 1.1571e-012) * a4rf_33
parameters dvthnrf_33=0.0000e+000 + ( - 6.4021e-003) * a1rf_33 + (3.0574e-004) 
+ * a2rf_33 + (7.0496e-003) * a3rf_33 + (9.7771e-004) * a4rf_33
parameters dlvthnrf_33=0.0000e+000 + (4.2119e-010) * a1rf_33 + ( - 2.0114e-011) 
+ * a2rf_33 + ( - 4.6379e-010) * a3rf_33 + ( - 6.4323e-011) * a4rf_33
parameters dwvthnrf_33=0.0000e+000 + ( - 8.4238e-011) * a1rf_33 + (4.0229e-012) 
+ * a2rf_33 + (9.2758e-011) * a3rf_33 + (1.2865e-011) * a4rf_33
parameters dpvthnrf_33=0.0000e+000 + ( - 5.2868e-016) * a1rf_33 + (3.6925e-017) 
+ * a2rf_33 + (5.9277e-016) * a3rf_33 + (1.2341e-016) * a4rf_33
parameters dlu0nrf_33=0.0000e+000 + (5.0543e-011) * a1rf_33 + ( - 2.4137e-012) 
+ * a2rf_33 + ( - 5.5655e-011) * a3rf_33 + ( - 7.7188e-012) * a4rf_33
parameters dwu0nrf_33=0.0000e+000 + (1.9457e-011) * a1rf_33 + (1.9899e-012) 
+ * a2rf_33 + ( - 1.8771e-011) * a3rf_33 + (7.6973e-012) * a4rf_33
parameters dpu0nrf_33=0.0000e+000 + ( - 1.1628e-017) * a1rf_33 + (6.3936e-018) 
+ * a2rf_33 + (1.8112e-017) * a3rf_33 + (2.3113e-017) * a4rf_33
parameters dcitnrf_33=0.0000e+000 + ( - 1.6848e-005) * a1rf_33 + (8.0458e-007) 
+ * a2rf_33 + (1.8552e-005) * a3rf_33 + (2.5729e-006) * a4rf_33
parameters dwcitnrf_33=0.0000e+000 + (1.6848e-011) * a1rf_33 + ( - 8.0458e-013) 
+ * a2rf_33 + ( - 1.8552e-011) * a3rf_33 + ( - 2.5729e-012) * a4rf_33
parameters cfnrf_33=9.0000e-011 + (1.3654e-013) * a1rf_33 + (1.4264e-012) 
+ * a2rf_33 + (7.7457e-014) * a3rf_33 + ( - 4.1427e-013) * a4rf_33 + 
+ 2.4e-11
parameters dxlprf_33=0.0000e+000 + ( - 2.9725e-010) * a1rf_33 + ( - 2.1376e-009) 
+ * a2rf_33 + ( - 1.0726e-010) * a3rf_33 + (6.2908e-010) * a4rf_33
parameters dxwprf_33=0.0000e+000 + (3.5303e-010) * a1rf_33 + (2.6280e-009) 
+ * a2rf_33 + (2.6676e-009) * a3rf_33 + ( - 5.7739e-010) * a4rf_33
parameters toxprf_33=5.9000e-009 + ( - 6.5018e-012) * a1rf_33 + ( - 6.7923e-011) 
+ * a2rf_33 + ( - 3.6884e-012) * a3rf_33 + (1.9727e-011) * a4rf_33
parameters cjprf_33=1.1200e-003 + ( - 1.4139e-005) * a1rf_33 + (1.6002e-006) 
+ * a2rf_33 + ( - 1.1800e-005) * a3rf_33 + ( - 2.1075e-007) * a4rf_33
parameters cjswprf_33=9.0000e-011 + ( - 1.1395e-012) * a1rf_33 + (1.2538e-013) 
+ * a2rf_33 + ( - 9.4807e-013) * a3rf_33 + ( - 1.5737e-014) * a4rf_33
parameters cjswgprf_33=1.7000e-010 + ( - 2.1524e-012) * a1rf_33 + (2.3683e-013) 
+ * a2rf_33 + ( - 1.7908e-012) * a3rf_33 + ( - 2.9726e-014) * a4rf_33
parameters cgoprf_33=5.2332e-011 + (7.9418e-014) * a1rf_33 + (8.2943e-013) 
+ * a2rf_33 + (4.5033e-014) * a3rf_33 + ( - 2.4049e-013) * a4rf_33
parameters cglprf_33=2.6891e-010 + (4.0790e-013) * a1rf_33 + (4.2618e-012) 
+ * a2rf_33 + (2.3143e-013) * a3rf_33 + ( - 1.2373e-012) * a4rf_33
parameters dvthprf_33=0.0000e+000 + (2.0697e-003) * a1rf_33 + (8.0438e-005) 
+ * a2rf_33 + (1.4829e-003) * a3rf_33 + (1.0520e-003) * a4rf_33
parameters dlvthprf_33=0.0000e+000 + (3.1440e-010) * a1rf_33 + ( - 1.3321e-010) 
+ * a2rf_33 + (3.3810e-010) * a3rf_33 + ( - 3.2315e-010) * a4rf_33
parameters dwvthprf_33=0.0000e+000 + (1.1679e-009) * a1rf_33 + ( - 4.3667e-010) 
+ * a2rf_33 + (1.2108e-009) * a3rf_33 + ( - 1.0073e-009) * a4rf_33
parameters dpvthprf_33=0.0000e+000 + (3.0784e-016) * a1rf_33 + (9.2712e-018) 
+ * a2rf_33 + (2.2266e-016) * a3rf_33 + (1.4753e-016) * a4rf_33
parameters dlu0prf_33=0.0000e+000 + (1.2867e-012) * a1rf_33 + ( - 7.5792e-013) 
+ * a2rf_33 + (1.5488e-012) * a3rf_33 + ( - 2.0291e-012) * a4rf_33
parameters dwu0prf_33=0.0000e+000 + ( - 1.8087e-011) * a1rf_33 + (1.9901e-012) 
+ * a2rf_33 + ( - 1.5049e-011) * a3rf_33 + ( - 2.4980e-013) * a4rf_33
parameters dpu0prf_33=0.0000e+000 + (5.8959e-017) * a1rf_33 + ( - 9.4028e-019) 
+ * a2rf_33 + (4.4751e-017) * a3rf_33 + (1.9236e-017) * a4rf_33
parameters dwcitprf_33=0.0000e+000 + (5.2197e-012) * a1rf_33 + (5.5890e-012) 
+ * a2rf_33 + ( - 4.3945e-013) * a3rf_33 + (2.0540e-011) * a4rf_33
parameters dpcitprf_33=0.0000e+000 + (2.4158e-018) * a1rf_33 + ( - 3.7955e-018) 
+ * a2rf_33 + ( - 4.7066e-019) * a3rf_33 + (8.5487e-019) * a4rf_33
parameters dlvsatprf_33=0.0000e+000 + ( - 1.2867e-004) * a1rf_33 + (7.5792e-005) 
+ * a2rf_33 + ( - 1.5488e-004) * a3rf_33 + (2.0291e-004) * a4rf_33
parameters dpvsatprf_33=0.0000e+000 + ( - 3.0262e-010) * a1rf_33 + ( - 3.6822e-012) 
+ * a2rf_33 + ( - 2.2310e-010) * a3rf_33 + ( - 1.2699e-010) * a4rf_33
parameters dleta0prf_33=0.0000e+000 + (4.1394e-009) * a1rf_33 + (1.6088e-010) 
+ * a2rf_33 + (2.9658e-009) * a3rf_33 + (2.1040e-009) * a4rf_33
parameters dpa0prf_33=0.0000e+000 + ( - 1.0439e-015) * a1rf_33 + ( - 1.1178e-015) 
+ * a2rf_33 + (8.7890e-017) * a3rf_33 + ( - 4.1081e-015) * a4rf_33
parameters dpk2rf_33=0.0000e+000 + ( - 5.4261e-016) * a1rf_33 + (5.9704e-017) 
+ * a2rf_33 + ( - 4.5146e-016) * a3rf_33 + ( - 7.4939e-018) * a4rf_33
parameters cfprf_33=9.0000e-011 + (1.3654e-013) * a1rf_33 + (1.4264e-012) 
+ * a2rf_33 + (7.7457e-014) * a3rf_33 + ( - 4.1427e-013) * a4rf_33 + 
+ 2.4e-11
parameters dlcnrf_33=4.6540e-008
parameters du0nrf_33=0.0000e+000
parameters dlcitnrf_33=0.0000e+000
parameters dpcitnrf_33=0.0000e+000
parameters dk2nrf_33=0.0000e+000
parameters dlk2nrf_33=0.0000e+000
parameters dwk2nrf_33=0.0000e+000
parameters dpk2nrf_33=0.0000e+000
parameters dk2rf_33=0.0000e+000
parameters dlcprf_33=5.4905e-008
parameters du0prf_33=0.0000e+000
parameters dnfactorprf_33=0.0000e+000
parameters dlnfactorprf_33=0.0000e+000
parameters dwnfactorprf_33=0.0000e+000
parameters dpnfactorprf_33=0.0000e+000
parameters dcitprf_33=0.0000e+000
parameters dlcitprf_33=0.0000e+000
parameters dvsatprf_33=0.0000e+000
parameters dwvsatprf_33=0.0000e+000
parameters dpeta0prf_33=0.0000e+000
parameters dla0prf_33=0.0000e+000
parameters dwa0prf_33=0.0000e+000
parameters dlk2rf_33=0.0000e+000
parameters dwk2rf_33=0.0000e+000
parameters b1fnrf_33=-7.25E+40
parameters b2fnrf_33=4.75E+22 
parameters b3fnrf_33=-1.925E+8   
parameters a1fnrf_33=8.975E+41 
parameters a2fnrf_33=4.75E+22  
parameters a3fnrf_33=4.825e+8  
parameters c1fnrf_33=2.05E+41  
parameters c2fnrf_33=4E+10    
parameters c3fnrf_33=5.35e+8 
parameters b1fprf_33=-3.55E+41   
parameters b2fprf_33=0    
parameters b3fprf_33=-2.225E+9    
parameters a1fprf_33=1.573E+42    
parameters a2fprf_33=0  
parameters a3fprf_33=4.825E+9 
parameters c1fprf_33=8.05E+41     
parameters c2fprf_33=4E+10  
parameters c3fprf_33=5.35E+9    
parameters noianrf_33=a1fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b1fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c1fnrf_33
parameters noibnrf_33=a2fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b2fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c2fnrf_33
parameters noicnrf_33=a3fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b3fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c3fnrf_33
parameters noiaprf_33=a1fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b1fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c1fprf_33
parameters noibprf_33=a2fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b2fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c2fprf_33
parameters noicprf_33=a3fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b3fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c3fprf_33
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_33
endsection mc_rfmos_33
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_rfmos_33
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_33
parameters parn1rf_33=0
parameters parn2rf_33=0
parameters parp1rf_33=0
parameters parp2rf_33=0
parameters toxnrf_33=5.6e-09
parameters dxlnrf_33=0
parameters dxwnrf_33=0
parameters cjnrf_33=0.001051
parameters cjswnrf_33=1.355e-10
parameters cjswgnrf_33=1.621e-10
parameters dlcnrf_33=4.654e-08
parameters cgonrf_33=3.855e-11
parameters cglnrf_33=2.513e-10
parameters dvthnrf_33=0
parameters dlvthnrf_33=0
parameters dwvthnrf_33=0
parameters dpvthnrf_33=0
parameters du0nrf_33=0
parameters dlu0nrf_33=0
parameters dwu0nrf_33=0
parameters dpu0nrf_33=0
parameters dcitnrf_33=0
parameters dlcitnrf_33=0
parameters dwcitnrf_33=0
parameters dpcitnrf_33=0
parameters dk2nrf_33=0
parameters dlk2nrf_33=0
parameters dwk2nrf_33=0
parameters dpk2nrf_33=0
parameters cfnrf_33=9e-11 + 2.4e-11
parameters dk2rf_33=0
parameters dxlprf_33=0
parameters dxwprf_33=0
parameters toxprf_33=5.9e-09
parameters cjprf_33=0.00112
parameters cjswprf_33=9e-11
parameters cjswgprf_33=1.7e-10
parameters dlcprf_33=5.49049e-08
parameters cgoprf_33=5.23324e-11
parameters cglprf_33=2.68907e-10
parameters dvthprf_33=0
parameters dlvthprf_33=0
parameters dwvthprf_33=0
parameters dpvthprf_33=0
parameters du0prf_33=0
parameters dlu0prf_33=0
parameters dwu0prf_33=0
parameters dpu0prf_33=0
parameters dnfactorprf_33=0
parameters dlnfactorprf_33=0
parameters dwnfactorprf_33=0
parameters dpnfactorprf_33=0
parameters dcitprf_33=0
parameters dlcitprf_33=0
parameters dwcitprf_33=0
parameters dpcitprf_33=0
parameters dvsatprf_33=0
parameters dlvsatprf_33=0
parameters dwvsatprf_33=0
parameters dpvsatprf_33=0
parameters dleta0prf_33=0
parameters dpeta0prf_33=0
parameters dla0prf_33=0
parameters dwa0prf_33=0
parameters dpa0prf_33=0
parameters dlk2rf_33=0
parameters dwk2rf_33=0
parameters dpk2rf_33=0
parameters cfprf_33=9e-11 + 2.4e-11
parameters b1fnrf_33=-7.25E+40
parameters b2fnrf_33=4.75E+22 
parameters b3fnrf_33=-1.925E+8   
parameters a1fnrf_33=8.975E+41 
parameters a2fnrf_33=4.75E+22  
parameters a3fnrf_33=4.825e+8  
parameters c1fnrf_33=2.05E+41  
parameters c2fnrf_33=4E+10    
parameters c3fnrf_33=5.35e+8 
parameters b1fprf_33=-3.55E+41   
parameters b2fprf_33=0    
parameters b3fprf_33=-2.225E+9    
parameters a1fprf_33=1.573E+42    
parameters a2fprf_33=0  
parameters a3fprf_33=4.825E+9 
parameters c1fprf_33=8.05E+41     
parameters c2fprf_33=4E+10  
parameters c3fprf_33=5.35E+9     
parameters noianrf_33=a1fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b1fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c1fnrf_33
parameters noibnrf_33=a2fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b2fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c2fnrf_33
parameters noicnrf_33=a3fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b3fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c3fnrf_33
parameters noiaprf_33=a1fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b1fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c1fprf_33
parameters noibprf_33=a2fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b2fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c2fprf_33
parameters noicprf_33=a3fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b3fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c3fprf_33
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_33
endsection tt_rfmos_33
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_rfmos_33
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_33
parameters parn1rf_33=0
parameters parn2rf_33=0
parameters parp1rf_33=0
parameters parp2rf_33=0
parameters toxnrf_33=5.9e-09
parameters dxlnrf_33=1e-08
parameters dxwnrf_33=-1.2e-08
parameters cjnrf_33=0.001125
parameters cjswnrf_33=1.45e-10
parameters cjswgnrf_33=1.734e-10
parameters dlcnrf_33=4.654e-08
parameters cgonrf_33=3.585e-11
parameters cglnrf_33=2.337e-10
parameters dvthnrf_33=0.038
parameters dlvthnrf_33=-2.5e-09
parameters dwvthnrf_33=5e-10
parameters dpvthnrf_33=3e-15
parameters du0nrf_33=0
parameters dlu0nrf_33=-3e-10
parameters dwu0nrf_33=-1.5e-10
parameters dpu0nrf_33=0
parameters dcitnrf_33=0.0001
parameters dlcitnrf_33=0
parameters dwcitnrf_33=-1e-10
parameters dpcitnrf_33=0
parameters dk2nrf_33=0
parameters dlk2nrf_33=0
parameters dwk2nrf_33=0
parameters dpk2nrf_33=0
parameters cfnrf_33=8.37e-11 + 2.4e-11
parameters dk2rf_33=0
parameters dxlprf_33=1e-08
parameters dxwprf_33=-1.2e-08
parameters toxprf_33=6.2e-09
parameters cjprf_33=0.001198
parameters cjswprf_33=9.63e-11
parameters cjswgprf_33=1.819e-10
parameters dlcprf_33=5.49049e-08
parameters cgoprf_33=4.8668e-11
parameters cglprf_33=2.50083e-10
parameters dvthprf_33=-0.015
parameters dlvthprf_33=-6e-10
parameters dwvthprf_33=-2.9e-09
parameters dpvthprf_33=-2.2e-15
parameters du0prf_33=0
parameters dlu0prf_33=0
parameters dwu0prf_33=1e-10
parameters dpu0prf_33=-3.9e-16
parameters dnfactorprf_33=0
parameters dlnfactorprf_33=0
parameters dwnfactorprf_33=0
parameters dpnfactorprf_33=0
parameters dcitprf_33=0
parameters dlcitprf_33=-0e-11
parameters dwcitprf_33=-1e-10
parameters dpcitprf_33=-0e-17
parameters dvsatprf_33=0
parameters dlvsatprf_33=0
parameters dwvsatprf_33=0
parameters dpvsatprf_33=2.1e-09
parameters dleta0prf_33=-3e-08
parameters dpeta0prf_33=0
parameters dla0prf_33=0
parameters dwa0prf_33=0
parameters dpa0prf_33=2e-14
parameters dlk2rf_33=0
parameters dwk2rf_33=0
parameters dpk2rf_33=3e-15
parameters cfprf_33=8.37e-11 + 2.4e-11
parameters b1fnrf_33=-7.25E+40
parameters b2fnrf_33=4.75E+22 
parameters b3fnrf_33=-1.925E+8   
parameters a1fnrf_33=8.975E+41 
parameters a2fnrf_33=4.75E+22  
parameters a3fnrf_33=4.825e+8  
parameters c1fnrf_33=2.05E+41  
parameters c2fnrf_33=4E+10    
parameters c3fnrf_33=5.35e+8 
parameters b1fprf_33=-3.55E+41   
parameters b2fprf_33=0    
parameters b3fprf_33=-2.225E+9    
parameters a1fprf_33=1.573E+42    
parameters a2fprf_33=0  
parameters a3fprf_33=4.825E+9 
parameters c1fprf_33=8.05E+41     
parameters c2fprf_33=4E+10  
parameters c3fprf_33=5.35E+9      
parameters noianrf_33=a1fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b1fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c1fnrf_33
parameters noibnrf_33=a2fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b2fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c2fnrf_33
parameters noicnrf_33=a3fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b3fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c3fnrf_33
parameters noiaprf_33=a1fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b1fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c1fprf_33
parameters noibprf_33=a2fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b2fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c2fprf_33
parameters noicprf_33=a3fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b3fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c3fprf_33
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_33
endsection ss_rfmos_33
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_rfmos_33
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_33
parameters parn1rf_33=0
parameters parn2rf_33=0
parameters parp1rf_33=0
parameters parp2rf_33=0
parameters toxnrf_33=5.3e-09
parameters dxlnrf_33=-1e-08
parameters dxwnrf_33=1.2e-08
parameters cjnrf_33=0.0009774
parameters cjswnrf_33=1.26e-10
parameters cjswgnrf_33=1.508e-10
parameters dlcnrf_33=4.654e-08
parameters cgonrf_33=4.125e-11
parameters cglnrf_33=2.689e-10
parameters dvthnrf_33=-0.038
parameters dlvthnrf_33=2.5e-09
parameters dwvthnrf_33=-5e-10
parameters dpvthnrf_33=-3.2e-15
parameters du0nrf_33=0
parameters dlu0nrf_33=3e-10
parameters dwu0nrf_33=1e-10
parameters dpu0nrf_33=-1e-16
parameters dcitnrf_33=-0.0001
parameters dlcitnrf_33=0
parameters dwcitnrf_33=1e-10
parameters dpcitnrf_33=0
parameters dk2nrf_33=0
parameters dlk2nrf_33=0
parameters dwk2nrf_33=0
parameters dpk2nrf_33=0
parameters cfnrf_33=9.63e-11 + 2.4e-11
parameters dk2rf_33=0
parameters dxlprf_33=-1e-08
parameters dxwprf_33=1.2e-08
parameters toxprf_33=5.6e-09
parameters cjprf_33=0.001042
parameters cjswprf_33=8.37e-11
parameters cjswgprf_33=1.581e-10
parameters dlcprf_33=5.49049e-08
parameters cgoprf_33=5.5995e-11
parameters cglprf_33=2.87729e-10
parameters dvthprf_33=0.01
parameters dlvthprf_33=2.2e-09
parameters dwvthprf_33=7.9e-09
parameters dpvthprf_33=1.5e-15
parameters du0prf_33=0
parameters dlu0prf_33=1e-11
parameters dwu0prf_33=-1e-10
parameters dpu0prf_33=3e-16
parameters dnfactorprf_33=0
parameters dlnfactorprf_33=0
parameters dwnfactorprf_33=0
parameters dpnfactorprf_33=0
parameters dcitprf_33=0
parameters dlcitprf_33=0
parameters dwcitprf_33=0
parameters dpcitprf_33=0
parameters dvsatprf_33=0
parameters dlvsatprf_33=-0.001
parameters dwvsatprf_33=0
parameters dpvsatprf_33=-1.5e-09
parameters dleta0prf_33=2e-08
parameters dpeta0prf_33=0
parameters dla0prf_33=0
parameters dwa0prf_33=0
parameters dpa0prf_33=0
parameters dlk2rf_33=0
parameters dwk2rf_33=0
parameters dpk2rf_33=-3e-15
parameters cfprf_33=9.63e-11 + 2.4e-11
parameters b1fnrf_33=-7.25E+40
parameters b2fnrf_33=4.75E+22 
parameters b3fnrf_33=-1.925E+8   
parameters a1fnrf_33=8.975E+41 
parameters a2fnrf_33=4.75E+22  
parameters a3fnrf_33=4.825e+8  
parameters c1fnrf_33=2.05E+41  
parameters c2fnrf_33=4E+10    
parameters c3fnrf_33=5.35e+8 
parameters b1fprf_33=-3.55E+41   
parameters b2fprf_33=0    
parameters b3fprf_33=-2.225E+9    
parameters a1fprf_33=1.573E+42    
parameters a2fprf_33=0  
parameters a3fprf_33=4.825E+9 
parameters c1fprf_33=8.05E+41     
parameters c2fprf_33=4E+10  
parameters c3fprf_33=5.35E+9     
parameters noianrf_33=a1fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b1fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c1fnrf_33
parameters noibnrf_33=a2fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b2fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c2fnrf_33
parameters noicnrf_33=a3fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b3fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c3fnrf_33
parameters noiaprf_33=a1fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b1fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c1fprf_33
parameters noibprf_33=a2fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b2fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c2fprf_33
parameters noicprf_33=a3fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b3fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c3fprf_33
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_33
endsection ff_rfmos_33
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_rfmos_33
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_33
parameters parn1rf_33=0
parameters parn2rf_33=0
parameters parp1rf_33=0
parameters parp2rf_33=0
parameters a1nrf_33=0.8
parameters a1prf_33=-0.8
parameters a2nrf_33=0
parameters a2prf_33=0
parameters a3nrf_33=-1
parameters a3prf_33=1
parameters a4nprf_33=0
parameters toxnrf_33=5.6e-09 + 3.0000e-010 * a4nprf_33
parameters dxlnrf_33=1e-008 * a2nrf_33
parameters dxwnrf_33=1.2e-008 * a3nrf_33
parameters cjnrf_33=0.001051 * (1 + 0.070 * a1nrf_33)
parameters cjswnrf_33=1.355e-10 * (1 + 0.070 * a1nrf_33)
parameters cjswgnrf_33=1.621e-10 * (1 + 0.070 * a1nrf_33)
parameters dlcnrf_33=4.654e-08
parameters cgonrf_33=3.855e-11 * (1 - 0.070 * a4nprf_33)
parameters cglnrf_33=2.513e-10 * (1 - 0.070 * a4nprf_33)
parameters dvthnrf_33=0.038 * a1nrf_33
parameters dlvthnrf_33= - 2.5e-009 * a1nrf_33
parameters dwvthnrf_33=5e-010 * a1nrf_33
parameters dpvthnrf_33=3.2e-015 * a1nrf_33
parameters du0nrf_33=0
parameters dlu0nrf_33= - 3e-010 * a1nrf_33
parameters dwu0nrf_33= - 1e-010 * a1nrf_33
parameters dpu0nrf_33=1e-016 * a1nrf_33
parameters dcitnrf_33=0.0001 * a1nrf_33
parameters dlcitnrf_33=0
parameters dwcitnrf_33= - 1e-010 * a1nrf_33
parameters dpcitnrf_33=0
parameters dk2nrf_33=0
parameters dlk2nrf_33=0
parameters dwk2nrf_33=0
parameters dpk2nrf_33=0
parameters cfnrf_33=9e-11 * (1 - 0.070 * a4nprf_33) + 2.4e-11
parameters dk2rf_33=0
parameters dxlprf_33=1e-008 * a2prf_33
parameters dxwprf_33=1.2e-008 * a3prf_33
parameters toxprf_33=5.9e-09 + 3.0000e-010 * a4nprf_33
parameters cjprf_33=0.00112 * (1 + 0.070 * a1prf_33)
parameters cjswprf_33=9e-11 * (1 + 0.070 * a1prf_33)
parameters cjswgprf_33=1.7e-10 * (1 + 0.070 * a1prf_33)
parameters dlcprf_33=5.49049e-08
parameters cgoprf_33=5.23324e-11 * (1 - 0.070 * a4nprf_33)
parameters cglprf_33=2.68907e-10 * (1 - 0.070 * a4nprf_33)
parameters dvthprf_33= - 0.01 * a1prf_33
parameters dlvthprf_33= - 2.2e-009 * a1prf_33
parameters dwvthprf_33= - 7.9e-009 * a1prf_33
parameters dpvthprf_33= - 1.5e-015 * a1prf_33
parameters du0prf_33=0
parameters dlu0prf_33= - 1e-011 * a1prf_33
parameters dwu0prf_33=1e-010 * a1prf_33
parameters dpu0prf_33= - 3e-016 * a1prf_33
parameters dnfactorprf_33=0
parameters dlnfactorprf_33=0
parameters dwnfactorprf_33=0
parameters dpnfactorprf_33=0
parameters dcitprf_33=0
parameters dlcitprf_33=0
parameters dwcitprf_33=0
parameters dpcitprf_33=0
parameters dvsatprf_33=0
parameters dlvsatprf_33=0.001 * a1prf_33
parameters dwvsatprf_33=0
parameters dpvsatprf_33=1.5e-009 * a1prf_33
parameters dleta0prf_33= - 2e-008 * a1prf_33
parameters dpeta0prf_33=0
parameters dla0prf_33=0
parameters dwa0prf_33=0
parameters dpa0prf_33=0
parameters dlk2rf_33=0
parameters dwk2rf_33=0
parameters dpk2rf_33=3e-015 * a1prf_33
parameters cfprf_33=9e-11 * (1 - 0.070 * a4nprf_33) + 2.4e-11
parameters b1fnrf_33=-7.25E+40
parameters b2fnrf_33=4.75E+22 
parameters b3fnrf_33=-1.925E+8   
parameters a1fnrf_33=8.975E+41 
parameters a2fnrf_33=4.75E+22  
parameters a3fnrf_33=4.825e+8  
parameters c1fnrf_33=2.05E+41  
parameters c2fnrf_33=4E+10    
parameters c3fnrf_33=5.35e+8 
parameters b1fprf_33=-3.55E+41   
parameters b2fprf_33=0    
parameters b3fprf_33=-2.225E+9    
parameters a1fprf_33=1.573E+42    
parameters a2fprf_33=0  
parameters a3fprf_33=4.825E+9 
parameters c1fprf_33=8.05E+41     
parameters c2fprf_33=4E+10  
parameters c3fprf_33=5.35E+9      
parameters noianrf_33=a1fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b1fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c1fnrf_33
parameters noibnrf_33=a2fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b2fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c2fnrf_33
parameters noicnrf_33=a3fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b3fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c3fnrf_33
parameters noiaprf_33=a1fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b1fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c1fprf_33
parameters noibprf_33=a2fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b2fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c2fprf_33
parameters noicprf_33=a3fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b3fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c3fprf_33
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_33
endsection sf_rfmos_33
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_rfmos_33
include "crn65gplus_2d5_lk_v1d0.scs" section=setup_rf_33
parameters parn1rf_33=0
parameters parn2rf_33=0
parameters parp1rf_33=0
parameters parp2rf_33=0
parameters a1nrf_33=-0.8
parameters a1prf_33=0.8
parameters a2nrf_33=0
parameters a2prf_33=0
parameters a3nrf_33=1
parameters a3prf_33=-1
parameters a4nprf_33=0
parameters toxnrf_33=5.6e-09 + 3.0000e-010 * a4nprf_33
parameters dxlnrf_33=1e-008 * a2nrf_33
parameters dxwnrf_33=1.2e-008 * a3nrf_33
parameters cjnrf_33=0.001051 * (1 + 0.070 * a1nrf_33)
parameters cjswnrf_33=1.355e-10 * (1 + 0.070 * a1nrf_33)
parameters cjswgnrf_33=1.621e-10 * (1 + 0.070 * a1nrf_33)
parameters dlcnrf_33=4.654e-08
parameters cgonrf_33=3.855e-11 * (1 - 0.070 * a4nprf_33)
parameters cglnrf_33=2.513e-10 * (1 - 0.070 * a4nprf_33)
parameters dvthnrf_33=0.038 * a1nrf_33
parameters dlvthnrf_33= - 2.5e-009 * a1nrf_33
parameters dwvthnrf_33=5e-010 * a1nrf_33
parameters dpvthnrf_33=3.2e-015 * a1nrf_33
parameters du0nrf_33=0
parameters dlu0nrf_33= - 3e-010 * a1nrf_33
parameters dwu0nrf_33= - 1e-010 * a1nrf_33
parameters dpu0nrf_33=1e-016 * a1nrf_33
parameters dcitnrf_33=0.0001 * a1nrf_33
parameters dlcitnrf_33=0
parameters dwcitnrf_33= - 1e-010 * a1nrf_33
parameters dpcitnrf_33=0
parameters dk2nrf_33=0
parameters dlk2nrf_33=0
parameters dwk2nrf_33=0
parameters dpk2nrf_33=0
parameters cfnrf_33=9e-11 * (1 - 0.070 * a4nprf_33) + 2.4e-11
parameters dk2rf_33=0
parameters dxlprf_33=1e-008 * a2prf_33
parameters dxwprf_33=1.2e-008 * a3prf_33
parameters toxprf_33=5.9e-09 + 3.0000e-010 * a4nprf_33
parameters cjprf_33=0.00112 * (1 + 0.070 * a1prf_33)
parameters cjswprf_33=9e-11 * (1 + 0.070 * a1prf_33)
parameters cjswgprf_33=1.7e-10 * (1 + 0.070 * a1prf_33)
parameters dlcprf_33=5.49049e-08
parameters cgoprf_33=5.23324e-11 * (1 - 0.070 * a4nprf_33)
parameters cglprf_33=2.68907e-10 * (1 - 0.070 * a4nprf_33)
parameters dvthprf_33= - 0.01 * a1prf_33
parameters dlvthprf_33= - 2.2e-009 * a1prf_33
parameters dwvthprf_33= - 7.9e-009 * a1prf_33
parameters dpvthprf_33= - 1.5e-015 * a1prf_33
parameters du0prf_33=0
parameters dlu0prf_33= - 1e-011 * a1prf_33
parameters dwu0prf_33=1e-010 * a1prf_33
parameters dpu0prf_33= - 3e-016 * a1prf_33
parameters dnfactorprf_33=0
parameters dlnfactorprf_33=0
parameters dwnfactorprf_33=0
parameters dpnfactorprf_33=0
parameters dcitprf_33=0
parameters dlcitprf_33=0
parameters dwcitprf_33=0
parameters dpcitprf_33=0
parameters dvsatprf_33=0
parameters dlvsatprf_33=0.001 * a1prf_33
parameters dwvsatprf_33=0
parameters dpvsatprf_33=1.5e-009 * a1prf_33
parameters dleta0prf_33= - 2e-008 * a1prf_33
parameters dpeta0prf_33=0
parameters dla0prf_33=0
parameters dwa0prf_33=0
parameters dpa0prf_33=0
parameters dlk2rf_33=0
parameters dwk2rf_33=0
parameters dpk2rf_33=3e-015 * a1prf_33
parameters cfprf_33=9e-11 * (1 - 0.070 * a4nprf_33) + 2.4e-11
parameters b1fnrf_33=-7.25E+40
parameters b2fnrf_33=4.75E+22 
parameters b3fnrf_33=-1.925E+8   
parameters a1fnrf_33=8.975E+41 
parameters a2fnrf_33=4.75E+22  
parameters a3fnrf_33=4.825e+8  
parameters c1fnrf_33=2.05E+41  
parameters c2fnrf_33=4E+10    
parameters c3fnrf_33=5.35e+8 
parameters b1fprf_33=-3.55E+41   
parameters b2fprf_33=0    
parameters b3fprf_33=-2.225E+9    
parameters a1fprf_33=1.573E+42    
parameters a2fprf_33=0  
parameters a3fprf_33=4.825E+9 
parameters c1fprf_33=8.05E+41     
parameters c2fprf_33=4E+10  
parameters c3fprf_33=5.35E+9     
parameters noianrf_33=a1fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b1fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c1fnrf_33
parameters noibnrf_33=a2fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b2fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c2fnrf_33
parameters noicnrf_33=a3fnrf_33 * (abs(noiseflagnrf_33) + noiseflagnrf_33) 
+ + b3fnrf_33 * (abs(noiseflagnrf_33) - noiseflagnrf_33) + c3fnrf_33
parameters noiaprf_33=a1fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b1fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c1fprf_33
parameters noibprf_33=a2fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b2fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c2fprf_33
parameters noicprf_33=a3fprf_33 * (abs(noiseflagprf_33) + noiseflagprf_33) 
+ + b3fprf_33 * (abs(noiseflagprf_33) - noiseflagprf_33) + c3fprf_33
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mos_33
endsection fs_rfmos_33
 
// *************************************************************************************************
// 
//  1.0V CORE SVT MOS MODEL
// 
// 
// 
//               .lib RF_MOS
// 
//               Model name       nr               lr (um)           wr (um)
//                             low   high        low     high     low    high
//             -----------------------------------------------------------------
//               nmos_rf        1     32         0.06    0.24     0.6    6.0
//             -----------------------------------------------------------------
//               pmos_rf        1     32         0.06    0.24     0.6    6.0
//             -----------------------------------------------------------------
//               pmos_rf_nw     1     32         0.06    0.24     0.6    6.0
//             -----------------------------------------------------------------
//             **nr: Finger number
//             **wr: Width per finger
// 
// *************************************************************************************************

section rf_mos
inline subckt nmos_rf ( d g s b ) 
parameters lr=0.06e-6 wr=1e-6 nr=4 mismatchflag=0 sigma=1 temp1=parn1rf temp2=parn2rf 
+ fac1=0.443742 * temp1 * sigma + 0.896155 * temp2 * sigma fac2=0.443742 * temp1 
+ * sigma - 0.896155 * temp2 * sigma lef=lr - 1.46e-08 wef=wr + 1.6e-08 geo_fac=1 
+ / sqrt(nr * lef * wef * 1e12) vthmisnrf=0.00235886 * geo_fac * fac1 * mismatchflag 
+ dlmisnrf=0.00171632 * geo_fac * lef * fac2 * mismatchflag dwmisnrf= - 0.00171632 
+ * geo_fac * wef * fac2 * mismatchflag toxmisnrf=0.00171632 * geo_fac * toxnrf 
+ * fac2 * mismatchflag lspace=0.24u ledge=0.45u ledgeeff=0.24u lsti=0.5u wsti=1.0u 
+ rod=835 rsti=1200 ns=int(nr / 2 + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 
+ 2) * 2) dummyflag=1 sleff=ledge + dummyflag * (ledgeeff - ledge) sreff=ledge + 
+ dummyflag * (ledgeeff - ledge) ldios=(ns - 2) * lspace + sleff + sreff + nodd 
+ * (lspace - sleff) ldiod=(ns - 1) * lspace + nodd * sleff lod=nr * (lr + lspace) 
+ + 2 * ledge - lspace sdiofa=wr * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 
+ - dummyflag) ddiofa=wr * ldiod ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) 
+ sdiogp=wr * nr + (2 - nodd) * wr * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag 
+ sax=1 / (log((ledge + lr / 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) 
+ * (lr + lspace)) / (ledge + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr 
+ * (lr + lspace)) + 1 / (nr * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 
+ + 0.54) / (lr * 1e6 - 0.003) + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * 
+ wr * 1e6 + 0.02906) + 0.11307 * wr * 1e6 + 0.916 * lr * 1e6 + 1503.6 * lr / nr 
+ / wr + 4.9295) rsx=(0.0337 * (lr + lspace) * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 
+ / ns + 1.68) / (wr * 1e6) rdx=0.01 * (lr + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 
+ * (wr * 1e6 + 1.41) / nd + 0.201 / (0.2 + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 
+ + 1e-8 / lr) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) * 
+ (rod * wr / 12 + rsti * wsti / 2) / ((lod - 2 * ledge + lspace + 3e-6) * (rod 
+ * (lod + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) + wr * (rod * wr / 12 
+ + rsti * wsti / 2)) rdbx=2.4 + 260 / (wr * nr * 1e6) + 45 / nr cgsx=(0.52 * nr 
+ * (lr + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) + 0.27 * wr * 1e6 + 0.1) * 1e-15 
+ cgdx=(0.15 * nr * (lr + lspace) * 1e6 + 0.05 * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 
+ * nr * wr / (lr + lspace) + 1.6 * nr * (lr + lspace) / (wr + 9.8e-6)) * 1e-15 
+ tnoiax=1.603e05 / (lr * 1e6) + 2.013e07 rnoiax=0.011 / (lr * 1e6) + 0.4433 
// *********************
 
 
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( sb si ) ndio_rf_f area=sdiofa pj=sdiofp
ddd ( db di ) ndio_rf_f area=ddiofa pj=ddiofp
dsg ( sb si ) ndio_rf_g area=1e-15 pj=sdiogp
ddg ( db di ) ndio_rf_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
nmos_rf ( di gi si bi ) nch_rf l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax sca=0 
+ scb=0 scc=0
 
model nch_rf bsim4  { 
     1: type=n 
+ lmin=1e-007-(dxlnrf+dlmisnrf)                       lmax=2.401e-007
+ wmin=1e-006-(dxwnrf+dwmisnrf)                       wmax=6.01e-006
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.953               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxnrf+toxmisnrf)
+ toxm=2e-009               dtox=2.4905e-010          epsrox=3.9
+ wint=0                    lint=2.8625e-10           ll=0.0050965
+ wl=0                      lln=-0.875                wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.46e-08+(dxlnrf+dlmisnrf)                      xw=1.6e-08+(dxwnrf+dwmisnrf)
+ dlc=2.8625e-10+ddlcnrf    dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.31703+(dvthnrf+vthmisnrf)
+ k1=0.24753                k2=-0.0041123731+dk2nrf   kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lk2=1.8164781e-009+dlk2nrf                          wk2=-2.2983394e-009+dwk2nrf
+ pk2=2.4569193e-016+dpk2nrf                          k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00014804749
+ lcit=4.6261635e-010+dlcitnrf                        wcit=1.4753784e-009+dwcitnrf
+ pcit=-2.6857591e-016+dpcitnrf                       voff=-0.12931886+dvoffnrf
+ lvoff=-2.6411604e-009+dlvoffnrf                     wvoff=2.3858227e-010+dwvoffnrf
+ pvoff=8.400871e-016+dpvoffnrf                       nfactor=0.6+dnfactornrf
+ eta0=0.12702749+deta0nrf  leta0=5.8414043e-013+dleta0nrf
+ weta0=2.2435567e-008+dweta0nrf                      peta0=-5.3897131e-019+dpeta0nrf
+ etab=-0.06480454          letab=-2.8262198e-014     wetab=7.08999e-008
+ petab=2.3109453e-020      u0=0.022320968+du0nrf     lu0=-2.24302e-010+dlu0nrf
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-1.4555707e-009+dwu0nrf
+ pu0=-2.3976379e-016+dpu0nrf                         ua=-1.4967634e-009
+ lua=-2.7226435e-017       wua=1.0438898e-017        pua=1.521437e-024
+ ub=2.0634228e-018         lub=1.0345374e-026        wub=-2.3715874e-026
+ pub=-2.6904759e-032       uc=7.91364e-11            luc=7.1196346e-018
+ wuc=4.720788e-018         puc=-8.3670699e-024       vsat=101530+dvsatnrf
+ a0=0.40094308+da0nrf      la0=-3.4388967e-009+dla0nrf
+ kvsat=1                   wa0=-4.4175841e-007+dwa0nrf
+ pa0=1.2490971e-013+dpa0nrf                          ags=6.478622+dagsnrf
+ lags=-2.7723817e-007+dlagsnrf                       wags=-2.2840519e-006
+ pags=8.3507413e-014+dpagsnrf                        a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.1                 dwg=0                     dwb=0
+ pclm=-0.12099972+dpclmnrf+0.00201949*ss_flagrf-0.00269265*ff_flagrf+0.00215412*sf_flagrf-0.00215412*fs_flagrf
+ lpclm=4.230048e-008-4.22598e-10*ss_flagrf+5.63463e-10*ff_flagrf-4.50771e-10*sf_flagrf+4.50771e-10*fs_flagrf
+ wpclm=8.0404227e-008-2.02272e-08*ss_flagrf+2.69696e-08*ff_flagrf-2.15756e-08*sf_flagrf+2.15756e-08*fs_flagrf
+ ppclm=-1.7082899e-014+dppclmnrf+4.23274e-15*ss_flagrf-5.64365e-15*ff_flagrf+4.51492e-15*sf_flagrf-4.51492e-15*fs_flagrf
+ pdiblc1=0                 pdiblc2=0.018624584       lpdiblc2=-1.110685e-009
+ wpdiblc2=4.0846591e-010   ppdiblc2=1.4174614e-016   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswnrf           rdw=45+drdswnrf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxnrf              xrcrg1=12
+ xrcrg2=1                  cgso=cgonrf               cgdo=cgonrf
+ cgbo=0                    cgdl=cglnrf               cgsl=cglnrf
+ clc=0                     cle=0.6                   cf=cfnrf
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.25635598+dkt1nrf   lkt1=-6.7706745e-009+dlkt1nrf
+ wkt1=-1.5116486e-008+dwkt1nrf                       pkt1=1.9315376e-015+dpkt1nrf
+ kt1l=0                    kt2=-0.035543769+dkt2nrf  lkt2=-1.567168e-009+dlkt2nrf
+ wkt2=6.566886e-009+dwkt2nrf                         pkt2=-1.4608393e-015+dpkt2nrf
+ ute=-1                    ua1=3.8485974e-009+dua1nrf
+ lua1=-1.6206912e-016+dlua1nrf                       wua1=-9.2334584e-016+dwua1nrf
+ pua1=3.7887376e-023+dpua1nrf                        ub1=-4.343838e-018+dub1nrf
+ lub1=2.1211141e-025+dlub1nrf                        wub1=1.2073009e-024+dwub1nrf
+ pub1=-6.6353287e-032+dpub1nrf                       uc1=4.932709e-12
+ luc1=-6.7227147e-019      wuc1=-1.0399171e-017      puc1=6.9546911e-024
+ prt=0                     at=120004.69+datnrf       lat=-0.0027872146+dlatnrf
+ wat=0.013700549+dwatnrf   pat=-3.3224603e-009+dpatnrf
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=0                   cjswd=0                   mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthnrf          wvth0=0+dwvthnrf          pvth0=0+dpvthnrf
+ lnfactor=0+dlnfactornrf   wnfactor=0+dwnfactornrf   pnfactor=0+dpnfactornrf
+ lvsat=0+dlvsatnrf         wvsat=0+dwvsatnrf         pvsat=0+dpvsatnrf
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noianrf
+ noib=noibnrf              noic=noicnrf              em=3e+8
+ ef=0.9                    lintnoi=-1e-8             rnoib=0
+ rnoia=rnoiax              tnoia=tnoiax              minr=1e-3
 
     2: type=n 
+ lmin=6.0e-008             lmax=1e-007-(dxlnrf+dlmisnrf)
+ wmin=1e-006-(dxwnrf+dwmisnrf)                       wmax=6.01e-006
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.953               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxnrf+toxmisnrf)
+ toxm=2e-009               dtox=2.4905e-010          epsrox=3.9
+ wint=0                    lint=2.8625e-10           ll=0.0050965
+ wl=0                      lln=-0.875                wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.46e-08+(dxlnrf+dlmisnrf)                      xw=1.6e-08+(dxwnrf+dwmisnrf)
+ dlc=2.8625e-10+ddlcnrf    dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.31703+(dvthnrf+vthmisnrf)+0.000709675*ss_flagrf+0.000791639*ff_flagrf-0.000633306*sf_flagrf+0.000633306*fs_flagrf
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=0.051791765+dk2nrf
+ lk2=-2.5535483e-009+dlk2nrf                         wk2=-5.7403941e-009+dwk2nrf
+ pk2=5.1475735e-016+dpk2nrf                          k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.002708028-1.24504e-05*ss_flagrf
+ lcit=2.3935693e-010+dlcitnrf+9.73247e-13*ss_flagrf  wcit=-3.8065734e-009+dwcitnrf+1.24704e-10*ss_flagrf
+ pcit=1.4431426e-016+dpcitnrf-9.74804e-18*ss_flagrf  voff=-0.14466798+dvoffnrf
+ lvoff=-1.4413201e-009+dlvoffnrf                     wvoff=8.8560978e-009+dwvoffnrf
+ pvoff=1.6645591e-016+dpvoffnrf                      nfactor=0.6+dnfactornrf
+ eta0=0.10605999+deta0nrf+0.000124504*ff_flagrf-9.96034e-05*sf_flagrf+9.96034e-05*fs_flagrf
+ leta0=1.6396139e-009+dleta0nrf-9.73251e-12*ff_flagrf+7.78603e-12*sf_flagrf-7.78603e-12*fs_flagrf
+ weta0=4.1459229e-008+dweta0nrf-1.24704e-09*ff_flagrf+9.97635e-10*sf_flagrf-9.97635e-10*fs_flagrf
+ peta0=-1.4876186e-015+dpeta0nrf+9.74803e-17*ff_flagrf-7.7984e-17*sf_flagrf+7.7984e-17*fs_flagrf
+ etab=-0.087221494         letab=1.752305e-009       wetab=1.3160831e-007
+ petab=-4.7455535e-015     u0=0.021510701+du0nrf+0.000171306*ff_flagrf+2.9881e-05*sf_flagrf-2.9881e-05*fs_flagrf
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.609634e-010+dlu0nrf-1.3391e-11*ff_flagrf-2.33579e-12*sf_flagrf+2.33579e-12*fs_flagrf
+ wu0=-3.051082e-009+dwu0nrf+1.62115e-10*ff_flagrf-2.99288e-10*sf_flagrf+2.99288e-10*fs_flagrf
+ pu0=-1.1504266e-016+dpu0nrf-1.26724e-17*ff_flagrf+2.33953e-17*sf_flagrf-2.33953e-17*fs_flagrf
+ ua=-2.0412421e-009        lua=1.5335468e-017        wua=6.8934927e-017
+ pua=-3.0511976e-024       ub=2.3110717e-018-2.49009e-21*ss_flagrf-2.01903e-20*ff_flagrf-3.48612e-21*sf_flagrf+3.48612e-21*fs_flagrf
+ lub=-9.0133403e-027+1.94649e-28*ss_flagrf+1.57828e-27*ff_flagrf+2.72509e-28*sf_flagrf-2.72509e-28*fs_flagrf
+ wub=-1.6167054e-025+2.49407e-26*ss_flagrf-1.87056e-26*ff_flagrf+3.4917e-26*sf_flagrf-3.4917e-26*fs_flagrf
+ pub=-1.6120843e-032-1.94961e-33*ss_flagrf+1.4622e-33*ff_flagrf-2.72945e-33*sf_flagrf+2.72945e-33*fs_flagrf
+ uc=1.6388909e-10          luc=4.9451673e-019        wuc=-3.8953131e-017
+ puc=-4.9530796e-024       vsat=101530+dvsatnrf      a0=0.22660787+da0nrf
+ la0=1.0188887e-008+dla0nrf                          kvsat=1
+ wa0=2.3775181e-006+dwa0nrf                          pa0=-9.5473132e-014+dpa0nrf
+ ags=3.5070566+dagsnrf     lags=-4.4950898e-008+dlagsnrf
+ wags=-1.8000132e-006      pags=4.5670112e-014+dpagsnrf
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.28290012          lketa=1.4297302e-008
+ wketa=6.9800554e-008      pketa=-5.4563093e-015     dwg=0
+ dwb=0                     pclm=0.37727644+dpclmnrf-0.013347*ss_flagrf+0.0157209*ff_flagrf+0.0242451*sf_flagrf-0.0365191*fs_flagrf
+ lpclm=3.3502325e-009+7.78598e-10*ss_flagrf-8.75923e-10*ff_flagrf-2.17762e-09*sf_flagrf+3.13707e-09*fs_flagrf
+ wpclm=-8.5826247e-008+1.33684e-07*ss_flagrf-1.57461e-07*ff_flagrf+8.85579e-08*sf_flagrf-7.60876e-08*fs_flagrf
+ ppclm=-4.0886629e-015+dppclmnrf-7.79843e-15*ss_flagrf+8.77324e-15*ff_flagrf-4.09418e-15*sf_flagrf+3.11937e-15*fs_flagrf
+ pdiblc1=0                 pdiblc2=-0.0083299598     lpdiblc2=9.9635172e-010
+ wpdiblc2=7.6481352e-009   ppdiblc2=-4.2417881e-016  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswnrf           rdw=45+drdswnrf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxnrf              xrcrg1=12
+ xrcrg2=1                  cgso=cgonrf               cgdo=cgonrf
+ cgbo=0                    cgdl=cglnrf               cgsl=cglnrf
+ clc=0                     cle=0.6                   cf=cfnrf
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.3174617+dkt1nrf    lkt1=-1.9940404e-009+dlkt1nrf
+ wkt1=3.196289e-008+dwkt1nrf                         pkt1=-1.7486573e-015+dpkt1nrf
+ kt1l=0                    kt2=-0.053058659+dkt2nrf  lkt2=-1.9802909e-010+dlkt2nrf
+ wkt2=-1.3720658e-008+dwkt2nrf                       pkt2=1.2503807e-016+dpkt2nrf
+ ute=-1                    ua1=1.8203262e-009+dua1nrf
+ lua1=-3.5191531e-018+dlua1nrf                       wua1=-1.3478993e-016+dwua1nrf
+ pua1=-2.3754039e-023+dpua1nrf                       ub1=-1.6749506e-018+dub1nrf
+ lub1=3.4844744e-027+dlub1nrf                        wub1=8.620125e-026+dwub1nrf
+ pub1=2.1283076e-032+dpub1nrf                        uc1=-7.249804e-11
+ luc1=5.3804901e-018       wuc1=1.2418745e-016       puc1=-3.5659453e-024
+ prt=0                     at=108778.84+datnrf       lat=-0.0019096901+dlatnrf
+ wat=-0.053623302+dwatnrf  pat=1.9402451e-009+dpatnrf
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=0                   cjswd=0                   mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthnrf-5.54751e-11*ss_flagrf-6.18816e-11*ff_flagrf+4.95053e-11*sf_flagrf-4.95053e-11*fs_flagrf
+ wvth0=0+dwvthnrf-7.1081e-09*ss_flagrf+3.11758e-09*ff_flagrf-2.49407e-09*sf_flagrf+2.49407e-09*fs_flagrf
+ pvth0=0+dpvthnrf+5.55638e-16*ss_flagrf-2.43701e-16*ff_flagrf+1.94961e-16*sf_flagrf-1.94961e-16*fs_flagrf
+ lnfactor=0+dlnfactornrf   wnfactor=0+dwnfactornrf   pnfactor=0+dpnfactornrf
+ lvsat=0+dlvsatnrf         wvsat=0+dwvsatnrf         pvsat=0+dpvsatnrf
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noianrf
+ noib=noibnrf              noic=noicnrf              em=3e+8
+ ef=0.9                    lintnoi=-1e-8             rnoib=0
+ rnoia=rnoiax              tnoia=tnoiax              minr=1e-3
 
     3: type=n 
+ lmin=1e-007-(dxlnrf+dlmisnrf)                       lmax=2.401e-007
+ wmin=0.6e-006             wmax=1e-006-(dxwnrf+dwmisnrf)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.953               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxnrf+toxmisnrf)
+ toxm=2e-009               dtox=2.4905e-010          epsrox=3.9
+ wint=0                    lint=2.8625e-10           ll=0.0050965
+ wl=0                      lln=-0.875                wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.46e-08+(dxlnrf+dlmisnrf)                      xw=1.6e-08+(dxwnrf+dwmisnrf)
+ dlc=2.8625e-10+ddlcnrf    dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.31703+(dvthnrf+vthmisnrf)
+ k1=0.24753                k2=-0.014768139+dk2nrf    kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lk2=3.6277153e-009+dlk2nrf                          wk2=8.527919e-009+dwk2nrf
+ pk2=-1.5945251e-015+dpk2nrf                         k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0013372461
+ lcit=1.6834112e-010+dlcitnrf                        wcit=-3.3679872e-011+dwcitnrf
+ pcit=3.0407722e-017+dpcitnrf                        voff=-0.12262774+dvoffnrf
+ lvoff=-2.6941796e-009+dlvoffnrf                     wvoff=-6.5595952e-009+dwvoffnrf
+ pvoff=8.9395462e-016+dpvoffnrf                      nfactor=0.6+dnfactornrf
+ eta0=0.20080854+deta0nrf  leta0=-1.5388287e-013+dleta0nrf
+ weta0=-5.2525972e-008+dweta0nrf                     peta0=2.1086036e-019+dpeta0nrf
+ etab=-0.027104036         letab=-6.1150773e-014     wetab=3.2596188e-008
+ petab=5.6524245e-020      u0=0.026585273+du0nrf     lu0=-1.1691365e-009+dlu0nrf
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-5.7881041e-009+dwu0nrf
+ pu0=7.2018811e-016+dpu0nrf                          ua=-1.2552238e-009
+ lua=-6.4938528e-017       wua=-2.3496527e-016       pua=3.9836923e-023
+ ub=2.1312214e-018         lub=-2.5904691e-026       wub=-9.2599217e-026
+ pub=9.9253067e-033        uc=1.1830572e-10          luc=2.3835917e-019
+ wuc=-3.5075238e-017       puc=-1.3756941e-024       vsat=101530+dvsatnrf
+ a0=0.46907808+da0nrf      la0=-4.8943247e-008+dla0nrf
+ kvsat=1                   wa0=-5.1098357e-007+dwa0nrf
+ pa0=1.7114213e-013+dpa0nrf                          ags=8.2030148+dagsnrf
+ lags=-4.9541641e-007+dlagsnrf                       wags=-4.036035e-006
+ pags=3.0517651e-013+dpagsnrf                        a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.068142305         lketa=-6.6665412e-009     wketa=-3.2367418e-008
+ pketa=6.7732059e-015      dwg=0                     dwb=0
+ pclm=-0.13577445+dpclmnrf-0.0454384*ss_flagrf+0.0605846*ff_flagrf-0.0484676*sf_flagrf+0.0484676*fs_flagrf
+ lpclm=1.7919195e-008+9.50844e-09*ss_flagrf-1.26779e-08*ff_flagrf+1.01423e-08*sf_flagrf-1.01423e-08*fs_flagrf
+ wpclm=9.5415348e-008+2.79901e-08*ss_flagrf-3.73201e-08*ff_flagrf+2.98561e-08*sf_flagrf-2.98561e-08*fs_flagrf
+ ppclm=7.688486e-015+dppclmnrf-5.8572e-15*ss_flagrf+7.8096e-15*ff_flagrf-6.24768e-15*sf_flagrf+6.24768e-15*fs_flagrf
+ pdiblc1=0                 pdiblc2=0.020037921       lpdiblc2=-9.0127218e-010
+ wpdiblc2=-1.0274844e-009  ppdiblc2=-7.1017271e-017  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswnrf           rdw=45+drdswnrf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxnrf              xrcrg1=12
+ xrcrg2=1                  cgso=cgonrf               cgdo=cgonrf
+ cgbo=0                    cgdl=cglnrf               cgsl=cglnrf
+ clc=0                     cle=0.6                   cf=cfnrf
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.27109399+dkt1nrf   lkt1=-3.7557307e-009+dlkt1nrf
+ wkt1=-1.4267116e-010+dwkt1nrf                       pkt1=-1.1316454e-015+dpkt1nrf
+ kt1l=0                    kt2=-0.036680085+dkt2nrf  lkt2=-1.0762958e-009+dlkt2nrf
+ wkt2=7.7213822e-009+dwkt2nrf                        pkt2=-1.9595654e-015+dpkt2nrf
+ ute=-1                    ua1=3.7096358e-009+dua1nrf
+ lua1=-1.9059356e-016+dlua1nrf                       wua1=-7.8216086e-016+dwua1nrf
+ pua1=6.6868207e-023+dpua1nrf                        ub1=-3.8934903e-018+dub1nrf
+ lub1=1.9286024e-025+dlub1nrf                        wub1=7.4974764e-025+dwub1nrf
+ pub1=-4.6794101e-032+dpub1nrf                       uc1=1.0314234e-11
+ luc1=-1.3145216e-018      wuc1=-1.58668e-017        puc1=7.6072172e-024
+ prt=0                     at=140905.08+datnrf       lat=-0.0081118748+dlatnrf
+ wat=-0.0075342512+dwatnrf pat=2.0873945e-009+dpatnrf
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=0                   cjswd=0                   mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthnrf          wvth0=0+dwvthnrf          pvth0=0+dpvthnrf
+ lnfactor=0+dlnfactornrf   wnfactor=0+dwnfactornrf   pnfactor=0+dpnfactornrf
+ lvsat=0+dlvsatnrf         wvsat=0+dwvsatnrf         pvsat=0+dpvsatnrf
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noianrf
+ noib=noibnrf              noic=noicnrf              em=3e+8
+ ef=0.9                    lintnoi=-1e-8             rnoib=0
+ rnoia=rnoiax              tnoia=tnoiax              minr=1e-3
 
     4: type=n 
+ lmin=6.0e-008             lmax=1e-007-(dxlnrf+dlmisnrf)
+ wmin=0.6e-006             wmax=1e-006-(dxwnrf+dwmisnrf)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.953               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxnrf+toxmisnrf)
+ toxm=2e-009               dtox=2.4905e-010          epsrox=3.9
+ wint=0                    lint=2.8625e-10           ll=0.0050965
+ wl=0                      lln=-0.875                wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.46e-08+(dxlnrf+dlmisnrf)                      xw=1.6e-08+(dxwnrf+dwmisnrf)
+ dlc=2.8625e-10+ddlcnrf    dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.31703+(dvthnrf+vthmisnrf)-0.015628*ss_flagrf+0.00810627*ff_flagrf-0.00648501*sf_flagrf+0.00648501*fs_flagrf
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=0.072603863+dk2nrf
+ lk2=-3.202154e-009+dlk2nrf                          wk2=-2.6885486e-008+dwk2nrf
+ pk2=1.1737408e-015+dpk2nrf                          k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.002846634+0.000280135*ss_flagrf+0.000339691*ff_flagrf-0.000271753*sf_flagrf+0.000271753*fs_flagrf
+ lcit=4.9539502e-010+dlcitnrf-2.18981e-11*ss_flagrf-2.65536e-11*ff_flagrf+2.12428e-11*sf_flagrf-2.12428e-11*fs_flagrf
+ wcit=1.8369632e-009+dwcitnrf-1.72563e-10*ss_flagrf-3.45126e-10*ff_flagrf+2.76101e-10*sf_flagrf-2.76101e-10*fs_flagrf
+ pcit=-1.1582045e-016+dpcitnrf+1.34892e-17*ss_flagrf+2.69784e-17*ff_flagrf-2.15827e-17*sf_flagrf+2.15827e-17*fs_flagrf
+ voff=-0.13551187+dvoffnrf+0.00254768*ff_flagrf-0.00203815*sf_flagrf+0.00203815*fs_flagrf
+ lvoff=-1.6870275e-009+dlvoffnrf-1.99152e-10*ff_flagrf+1.59321e-10*sf_flagrf-1.59321e-10*fs_flagrf
+ wvoff=-4.4650916e-010+dwvoffnrf-2.58844e-09*ff_flagrf+2.07076e-09*sf_flagrf-2.07076e-09*fs_flagrf
+ pvoff=4.1609469e-016+dpvoffnrf+2.02338e-16*ff_flagrf-1.6187e-16*sf_flagrf+1.6187e-16*fs_flagrf
+ nfactor=0.6+dnfactornrf   eta0=0.24672953+deta0nrf-0.00280135*ff_flagrf+0.00224108*sf_flagrf-0.00224108*fs_flagrf
+ leta0=-3.5897984e-009+dleta0nrf+2.18981e-10*ff_flagrf-1.75184e-10*sf_flagrf+1.75184e-10*fs_flagrf
+ weta0=-1.0146103e-007+dweta0nrf+1.72563e-09*ff_flagrf-1.3805e-09*sf_flagrf+1.3805e-09*fs_flagrf
+ peta0=3.8254642e-015+dpeta0nrf-1.34892e-16*ff_flagrf+1.07914e-16*sf_flagrf-1.07914e-16*fs_flagrf
+ etab=-0.01777963          letab=-7.2894994e-010     wetab=6.105538e-008
+ petab=-2.2245985e-015     u0=0.016820001+du0nrf+0.000500713*ff_flagrf-0.00040057*sf_flagrf+0.00040057*fs_flagrf
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-4.0578524e-010+dlu0nrf-3.91406e-11*ff_flagrf+3.13125e-11*sf_flagrf-3.13125e-11*fs_flagrf
+ wu0=1.7146691e-009+dwu0nrf-1.72563e-10*ff_flagrf+1.3805e-10*sf_flagrf-1.3805e-10*fs_flagrf
+ pu0=1.3369633e-016+dpu0nrf+1.34892e-17*ff_flagrf-1.07914e-17*sf_flagrf+1.07914e-17*fs_flagrf
+ ua=-1.7856988e-009        lua=-2.3471301e-017       wua=-1.9069709e-016
+ pua=3.637648e-023         ub=1.6750463e-018+2.20578e-20*ss_flagrf-3.0109e-20*ff_flagrf+2.40872e-20*sf_flagrf-2.40872e-20*fs_flagrf
+ lub=9.754519e-027-1.72425e-27*ss_flagrf+2.35362e-27*ff_flagrf-1.88288e-27*sf_flagrf+1.88288e-27*fs_flagrf
+ wub=4.8453132e-025-2e-33*ss_flagrf-8.6282e-27*ff_flagrf+6.90256e-27*sf_flagrf-6.90256e-27*fs_flagrf
+ pub=-3.5188988e-032-1.1e-39*ss_flagrf+6.74462e-34*ff_flagrf-5.39566e-34*sf_flagrf+5.39566e-34*fs_flagrf
+ uc=2.7329344e-10          luc=-1.1877031e-017       wuc=-1.5010795e-016
+ puc=7.6164132e-024        vsat=101530+dvsatnrf+2547.68*ff_flagrf-2038.15*sf_flagrf+2038.15*fs_flagrf
+ kvsat=1                   a0=2.1586468+da0nrf       la0=-1.8101683e-007+dla0nrf
+ wa0=4.145666e-007+dwa0nrf pa0=9.8791877e-014+dpa0nrf
+ ags=1.8653352+dagsnrf     wags=-1.3202432e-007      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.24125007          lketa=6.8652929e-009      wketa=2.7484109e-008
+ pketa=2.094612e-015       dwg=0                     dwb=0
+ pclm=-0.055739068+dpclmnrf+0.300307*ss_flagrf-0.353721*ff_flagrf+0.282977*sf_flagrf-0.282977*fs_flagrf
+ lpclm=1.166283e-008-1.75185e-08*ss_flagrf+1.97083e-08*ff_flagrf-1.57666e-08*sf_flagrf+1.57666e-08*fs_flagrf
+ wpclm=3.541175e-007-1.8499e-07*ss_flagrf+2.17892e-07*ff_flagrf-1.74314e-07*sf_flagrf+1.74314e-07*fs_flagrf
+ ppclm=-1.2534262e-014+dppclmnrf+1.07914e-14*ss_flagrf-1.21403e-14*ff_flagrf+9.71223e-15*sf_flagrf-9.71223e-15*fs_flagrf
+ pdiblc1=0                 pdiblc2=-0.0045152805     lpdiblc2=1.0180516e-009
+ wpdiblc2=3.772421e-009    ppdiblc2=-4.4622588e-016  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswnrf           rdw=45+drdswnrf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxnrf              xrcrg1=12
+ xrcrg2=1                  cgso=cgonrf               cgdo=cgonrf
+ cgbo=0                    cgdl=cglnrf               cgsl=cglnrf
+ clc=0                     cle=0.6                   cf=cfnrf
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.22643511+dkt1nrf   lkt1=-7.2467155e-009+dlkt1nrf
+ wkt1=-6.0520131e-008+dwkt1nrf                       pkt1=3.5880607e-015+dpkt1nrf
+ kt1l=0                    kt2=-0.015457962+dkt2nrf  lkt2=-2.7352291e-009+dlkt2nrf
+ wkt2=-5.1922967e-008+dwkt2nrf                       pkt2=2.7028333e-015+dpkt2nrf
+ ute=-1                    ua1=1.8067429e-009+dua1nrf
+ lua1=-4.1844414e-017+dlua1nrf                       wua1=-1.2098929e-016+dwua1nrf
+ pua1=1.5184425e-023+dpua1nrf                        ub1=-2.3420305e-018+dub1nrf
+ lub1=7.158263e-026+dlub1nrf                         wub1=7.6395449e-025+dwub1nrf
+ pub1=-4.790465e-032+dpub1nrf                        uc1=-2.5743983e-10
+ luc1=1.9615814e-017       wuc1=3.1208831e-016       puc1=-1.8029034e-023
+ prt=0                     at=33885.293+datnrf       lat=0.00025386213+dlatnrf
+ wat=0.022468542+dwatnrf   pat=-2.5792393e-010+dpatnrf
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=0                   cjswd=0                   mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthnrf+1.22164e-09*ss_flagrf-6.33665e-10*ff_flagrf+5.06931e-10*sf_flagrf-5.06931e-10*fs_flagrf
+ wvth0=0+dwvthnrf+9.49096e-09*ss_flagrf-4.31407e-09*ff_flagrf+3.45126e-09*sf_flagrf-3.45126e-09*fs_flagrf
+ pvth0=0+dpvthnrf-7.41907e-16*ss_flagrf+3.3723e-16*ff_flagrf-2.69784e-16*sf_flagrf+2.69784e-16*fs_flagrf
+ lnfactor=0+dlnfactornrf   wnfactor=0+dwnfactornrf   pnfactor=0+dpnfactornrf
+ lvsat=0+dlvsatnrf-0.000199152*ff_flagrf+0.000159321*sf_flagrf-0.000159321*fs_flagrf
+ wvsat=0+dwvsatnrf-0.00258844*ff_flagrf+0.00207076*sf_flagrf-0.00207076*fs_flagrf
+ pvsat=0+dpvsatnrf+2.02338e-10*ff_flagrf-1.6187e-10*sf_flagrf+1.6187e-10*fs_flagrf
+ lags=0+dlagsnrf           pags=0+dpagsnrf           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.15e-17         wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0017             pku0we=-1.4e-17
+ wku0we=-2.0e-10           lku0we=1.88e-10           k2we=0.00045
+ pk2we=-0.26e-17           wk2we=0.4e-10             lk2we=0.1e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noianrf              noib=noibnrf
+ noic=noicnrf              em=3e+8                   ef=0.9
+ lintnoi=-1e-8             rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
     } 
// 
model ndio_rf_f diode 
+ level=1                   is=1.35e-07               n=1
+ bv=9.03                   ibv=0.03                  isw=2.5e-13
+ cj=cjnrf                  pj=7.2e-4                 mj=0.32
+ fc=0                      cjsw=cjswnrf              area=3.08e-8
+ mjsw=0.05                 tlevc=1                   cta=0.0008
+ ctp=0.0004                tbv1=-1*-0.80e-03         tlev=1
+ xti=3                     eg=1.17                   vjsw=1.12
+ vj=0.7                    pta=0.0016                tnom=25
+ ptp=0.003                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model ndio_rf_g diode 
+ level=1                   is=1.35e-07               n=1
+ bv=9.03                   ibv=0.03                  isw=2.5e-13
+ cj=cjnrf                  pj=7.2e-4                 mj=0.32
+ fc=0                      cjsw=cjswgnrf             area=3.08e-8
+ mjsw=0.98                 tlevc=1                   cta=0.0008
+ ctp=0.0016                tbv1=-1*-0.80e-03         tlev=1
+ xti=3                     eg=1.17                   vjsw=1.15
+ vj=0.7                    pta=0.0016                tnom=25
+ ptp=0.0019                ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends nmos_rf
// 
inline subckt pmos_rf ( d g s b ) 
parameters lr=0.06e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf temp2=parp2rf 
+ fac1=0.836583 * temp1 * sigma + 0.547841 * temp2 * sigma fac2=0.836583 * temp1 
+ * sigma - 0.547841 * temp2 * sigma lef=lr - 1.09e-08 wef=wr + 1.6e-08 geo_fac=1 
+ / sqrt(nr * lef * wef * 1e12) vthmisprf=0.00215161 * geo_fac * fac1 * mismatchflag 
+ dlmisprf=0.00170787 * geo_fac * lef * fac2 * mismatchflag dwmisprf= - 0.00170787 
+ * geo_fac * wef * fac2 * mismatchflag toxmisprf=0.00170787 * geo_fac * toxprf 
+ * fac2 * mismatchflag lspace=0.24u ledge=0.45u ledgeeff=0.24u lsti=0.5u wsti=1.0u 
+ rod=316 rsti=605 ns=int(nr / 2 + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) 
+ * 2) dummyflag=1 sleff=ledge + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag 
+ * (ledgeeff - ledge) ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace 
+ - sleff) ldiod=(ns - 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge 
+ - lspace sdiofa=wr * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) 
+ ddiofa=wr * ldiod ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr 
+ + (2 - nodd) * wr * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge 
+ + lr / 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / 
+ (ledge + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 
+ 1 / (nr * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 
+ 1e6 - 0.003) + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) 
+ + 0.11307 * wr * 1e6 + 0.916 * lr * 1e6 + 2220.9 * lr / nr / wr + 0.8366) rsx=(0.0337 
+ * (lr + lspace) * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) 
+ rdx=0.01 * (lr + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / 
+ nd + 0.201 / (0.2 + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod 
+ * (lod + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti 
+ * wsti / 2) / ((lod - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 
+ * lspace) / 12 + rsti * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 
+ + 180 / (wr * nr * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 
+ * wr * 1e6 + 1.26) + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) 
+ * 1e6 + 0.05 * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) 
+ + 1.6 * nr * (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=3.163e05 / (lr * 1e6) 
+ + 5.918e07 rnoiax=0.02751 / (lr * 1e6) + 0.3577 
// *********************
 
 
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf ( di gi si bi ) pch_rf l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax sca=0 
+ scb=0 scc=0
 
model pch_rf bsim4  { 
     1: type=p 
+ lmin=1e-007-(dxlprf+dlmisprf)                       lmax=2.401e-007
+ wmin=1e-006-(dxwprf+dwmisprf)                       wmax=6.01e-006
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29576369+(dvthprf+vthmisprf)
+ lvth0=9.0719854e-010+dlvthprf                       kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.330e-8
+ k1=0.22699184             lk1=3.5259378e-009        k2=0.026943317+dk2prf
+ lk2=-3.9015228e-009+dlk2prf                         wk2=-3.6665798e-009+dwk2prf
+ pk2=2.3089123e-016+dpk2prf                          k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00012999806+dcitprf
+ lcit=4.0734852e-010+dlcitprf                        wcit=3.8305183e-010+dwcitprf
+ pcit=-1.100318e-016+dpcitprf                        voff=-0.11734135+dvoffprf
+ lvoff=-3.1031126e-009+dlvoffprf                     wvoff=-1.0274471e-008+dwvoffprf
+ pvoff=2.3925938e-015+dpvoffprf                      nfactor=0.52254+dnfactorprf
+ eta0=0.19395111+deta0prf  weta0=-3.9574329e-008+dweta0prf
+ etab=-0.31266109          letab=8.7696452e-009      wetab=1.476912e-007
+ petab=-4.0213308e-015     u0=0.0081272967+du0prf    lu0=-5.4879768e-011+dlu0prf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=-2.5836543e-010+dwu0prf
+ pu0=5.5757844e-017+dpu0prf                          ua=-2.8713742e-010
+ lua=7.0658019e-018        wua=-2.9874999e-016       pua=-3.8341918e-024
+ ub=1.3341522e-018         lub=-4.880481e-026        wub=1.0472447e-025
+ pub=2.9745564e-032        uc=5.7359538e-011         luc=-1.6793179e-018
+ wuc=8.0795147e-019        puc=-2.3657195e-025       vsat=76565.113+dvsatprf
+ lvsat=0.0028993829+dlvsatprf                        kvsat=1
+ wvsat=0.0093925879+dwvsatprf                        pvsat=-2.0270144e-009+dpvsatprf
+ a0=2.9898354+da0prf       la0=-1.6313268e-007+dla0prf
+ wa0=2.3461709e-007+dwa0prf                          pa0=-1.9234613e-014+dpa0prf
+ ags=4.2224855+dagsprf     wags=1.0531294e-007+dwagsprf
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.11067949          lketa=2.3047411e-009
+ wketa=-2.1771325e-008     pketa=4.6984696e-015      dwg=0
+ dwb=0                     pclm=2.4444577+dpclmprf   lpclm=-1.1114817e-007
+ wpclm=-8.6301362e-007     ppclm=8.0022223e-014      pdiblc1=0
+ pdiblc2=0.00097802378     lpdiblc2=6.0344759e-010   wpdiblc2=5.7247338e-009
+ ppdiblc2=-7.4742419e-016  pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswprf          rdw=110+drdswprf          prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxprf              xrcrg1=12                 xrcrg2=1
+ cgso=cgoprf               cgdo=cgoprf               cgbo=0
+ cgdl=cglprf               cgsl=cglprf               clc=0
+ cle=0.6                   cf=cfprf                  ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.23072588
+ lkt1=-7.9464265e-009      wkt1=1.2847325e-008       pkt1=-1.8823377e-015
+ kt1l=0                    kt2=-0.043763468          lkt2=-8.573255e-010
+ wkt2=-2.4807247e-008      pkt2=1.3293919e-015       ute=-1
+ lute=0+dluteprf           ua1=1.9204408e-009        lua1=-7.758166e-018
+ wua1=-3.0425567e-016      pua1=3.4472905e-023       ub1=-2.4001647e-018
+ lub1=-1.3938985e-026      wub1=1.1539672e-025       pub1=2.7724504e-033
+ uc1=-9.1643267e-011       luc1=-6.8709721e-018      wuc1=6.7878865e-017
+ puc1=-7.3443395e-024      prt=0                     at=170459.52
+ lat=-0.0075817218+dlatprf wat=0.044716009           pat=-8.4954082e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=0                   cjswd=0                   mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgprf         jtsswgd=jtsswgprf         njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsprf           lags=0+dlagsprf           wvth0=0+dwvthprf
+ pvth0=0+dpvthprf          lnfactor=0+dlnfactorprf   wnfactor=0+dwnfactorprf
+ pnfactor=0+dpnfactorprf   leta0=0+dleta0prf         peta0=0+dpeta0prf
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiaprf              noib=noibprf
+ noic=noicprf              em=3e+8                   ef=1.1
+ lintnoi=-1e-8             rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
 
 
     2: type=p 
+ lmin=6.0e-008             lmax=1e-007-(dxlprf+dlmisprf)
+ wmin=1e-006-(dxwprf+dwmisprf)                       wmax=6.01e-006
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29872784+(dvthprf+vthmisprf)-0.00256504*ff_flagrf-0.00205203*sf_flagrf+0.00205203*fs_flagrf
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=1.1502081e-009+dlvthprf+2.10289e-10*ff_flagrf+1.68231e-10*sf_flagrf-1.68231e-10*fs_flagrf
+ wvth0=1.4153925e-009+dwvthprf+2.60608e-09*ff_flagrf+2.08486e-09*sf_flagrf-2.08486e-09*fs_flagrf
+ pvth0=-1.1603812e-016+dpvthprf-2.13654e-16*ff_flagrf-1.70923e-16*sf_flagrf+1.70923e-16*fs_flagrf
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.016705963+dk2prf
+ lk2=-3.0622338e-009+dlk2prf                         wk2=-1.0726945e-009+dwk2prf
+ pk2=1.8236725e-017+dpk2prf                          k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00014675011+dcitprf
+ lcit=3.8465988e-010+dlcitprf                        wcit=-6.6510802e-010+dwcitprf
+ pcit=-2.4100516e-017+dpcitprf                       voff=-0.13554627+dvoffprf-0.00192378*ff_flagrf-0.00153902*sf_flagrf+0.00153902*fs_flagrf
+ lvoff=-1.6106189e-009+dlvoffprf+1.57717e-10*ff_flagrf+1.26174e-10*sf_flagrf-1.26174e-10*fs_flagrf
+ wvoff=2.2613071e-008+dwvoffprf+1.95456e-09*ff_flagrf+1.56365e-09*sf_flagrf-1.56365e-09*fs_flagrf
+ pvoff=-3.0362561e-016+dpvoffprf-1.60241e-16*ff_flagrf-1.28192e-16*sf_flagrf+1.28192e-16*fs_flagrf
+ nfactor=0.52254+dnfactorprf                         eta0=0.17100596+deta0prf-0.0032063*ss_flagrf+0.00884754*ff_flagrf+0.00707803*sf_flagrf-0.00707803*fs_flagrf
+ leta0=1.8811126e-009+dleta0prf+2.62862e-10*ss_flagrf-7.25347e-10*ff_flagrf-5.80278e-10*sf_flagrf+5.80278e-10*fs_flagrf
+ weta0=-6.7398703e-008+dweta0prf+3.2576e-09*ss_flagrf-7.81824e-09*ff_flagrf-6.25459e-09*sf_flagrf+6.25459e-09*fs_flagrf
+ peta0=2.2811256e-015+dpeta0prf-2.67067e-16*ss_flagrf+6.40962e-16*ff_flagrf+5.1277e-16*sf_flagrf-5.1277e-16*fs_flagrf
+ etab=-0.34775733          letab=1.164694e-008       wetab=1.8330063e-007
+ petab=-6.9406985e-015     u0=0.0074093674+du0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=3.9782258e-012+dlu0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ wu0=9.0777576e-010+dwu0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ pu0=-3.9845909e-017+dpu0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ ua=-3.1739587e-010        lua=9.5464802e-018        wua=-7.6376103e-016
+ pua=3.4288809e-023        ub=7.346529e-019          lub=3.4394381e-028
+ wub=1.2678476e-024        pub=-6.5610763e-032       uc=6.5388509e-011
+ luc=-2.3375571e-018       wuc=-1.0427362e-017       puc=6.8453272e-025
+ vsat=137687.82+dvsatprf   lvsat=-0.0021116397+dlvsatprf
+ kvsat=1                   wvsat=-0.023304207+dwvsatprf
+ pvsat=6.5356692e-010+dpvsatprf                      a0=-2.4572186+da0prf
+ la0=2.8343315e-007+dla0prf                          ags=4.2224855+dagsprf
+ wags=1.0531294e-007+dwagsprf                        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.23693636          lketa=1.2655658e-008      wketa=6.0180664e-008
+ pketa=-2.0202003e-015     dwg=0                     dwb=0
+ pclm=1.6519048+dpclmprf-0.119145*ff_flagrf-0.0953162*sf_flagrf+0.0953162*fs_flagrf
+ lpclm=-4.6172311e-008+9.76787e-09*ff_flagrf+7.8143e-09*sf_flagrf-7.8143e-09*fs_flagrf
+ wpclm=2.4337152e-007+3.90912e-08*ff_flagrf+3.1273e-08*sf_flagrf-3.1273e-08*fs_flagrf
+ ppclm=-1.0682549e-014-3.20481e-15*ff_flagrf-2.56385e-15*sf_flagrf+2.56385e-15*fs_flagrf
+ pdiblc1=0                 pdiblc2=0.0057736665      lpdiblc2=2.1028641e-010
+ wpdiblc2=-7.8604521e-010  ppdiblc2=-2.1365099e-016  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswprf          rdw=110+drdswprf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxprf              xrcrg1=12
+ xrcrg2=1                  cgso=cgoprf               cgdo=cgoprf
+ cgbo=0                    cgdl=cglprf               cgsl=cglprf
+ clc=0                     cle=0.6                   cf=cfprf
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.27609462           lkt1=-4.2269617e-009      wkt1=-2.1886485e-008
+ pkt1=9.6524418e-016       kt1l=0                    kt2=-0.055277267
+ lkt2=8.661024e-011        wkt2=-9.2573803e-009      pkt2=5.4567146e-017
+ ute=-1                    lute=0+dluteprf           ua1=1.3880396e-009
+ lua1=3.5889685e-017       wua1=3.7082419e-016       pua1=-2.0872167e-023
+ ub1=-2.2253259e-018       lub1=-2.8272798e-026      wub1=2.8202664e-025
+ pub1=-1.088837e-032       uc1=-2.292058e-010        luc1=4.4068173e-018
+ wuc1=-4.6717596e-017      puc1=2.0506222e-024       prt=0
+ at=157087.06              lat=-0.0064854075+dlatprf wat=-0.13928046
+ pat=6.589174e-009         jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=0                   cjswd=0
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=0                  cjswgd=0
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgprf         jtsswgd=jtsswgprf
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             pa0=0+dpa0prf             wa0=0+dwa0prf
+ pags=0+dpagsprf           lags=0+dlagsprf           lnfactor=0+dlnfactorprf
+ wnfactor=0+dwnfactorprf   pnfactor=0+dpnfactorprf   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiaprf              noib=noibprf              noic=noicprf
+ em=3e+8                   ef=1.1                    lintnoi=-1e-8
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
 
 
     3: type=p 
+ lmin=1e-007-(dxlprf+dlmisprf)                       lmax=2.401e-007
+ wmin=0.6e-006             wmax=1e-006-(dxwprf+dwmisprf)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29576369+(dvthprf+vthmisprf)
+ lvth0=9.0719854e-010+dlvthprf                       kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.330e-8
+ k1=0.22699184             lk1=3.5259378e-009        k2=0.03091297+dk2prf
+ lk2=-4.2504968e-009+dlk2prf                         wk2=-7.6997473e-009+dwk2prf
+ pk2=5.8544885e-016+dpk2prf                          k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-8.6885462e-005+dcitprf
+ lcit=3.3946216e-010+dlcitprf                        wcit=3.3924943e-010+dwcitprf
+ pcit=-4.105926e-017+dpcitprf                        voff=-0.13057397+dvoffprf
+ lvoff=-6.9873453e-010+dlvoffprf                     wvoff=3.169867e-009+dwvoffprf
+ pvoff=-5.0254392e-017+dpvoffprf                     nfactor=0.52254+dnfactorprf
+ eta0=0.1704+deta0prf      weta0=-1.56464e-008+dweta0prf
+ etab=-0.27655807          letab=1.2221516e-008      wetab=1.1101053e-007
+ petab=-7.5284313e-015     u0=0.0076055944+du0prf    lu0=-7.5738254e-015+dlu0prf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=2.7168411e-010+dwu0prf
+ pu0=7.6950066e-021+dpu0prf                          ua=-7.9656463e-010
+ lua=-7.6768419e-019       wua=2.1882806e-016        pua=4.1246301e-024
+ ub=1.9380097e-018         lub=-2.5328244e-026       wub=-5.0879468e-025
+ pub=5.8933735e-033        uc=1.3013354e-010         luc=-6.4929155e-018
+ wuc=-7.3130435e-017       puc=4.6540432e-024        vsat=79356.857+dvsatprf
+ lvsat=0.0022968966+dlvsatprf                        kvsat=1
+ wvsat=0.0065561759+dwvsatprf                        pvsat=-1.4148883e-009+dpvsatprf
+ a0=4.971014+da0prf        la0=-3.4348122e-007+dla0prf
+ wa0=-1.7782604e-006+dwa0prf                         pa0=1.6399951e-013+dpa0prf
+ ags=6.1193988+dagsprf     lags=7.8995813e-013+dlagsprf
+ wags=-1.8219509e-006+dwagsprf                       pags=-8.0259746e-019+dpagsprf
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.12546103          lketa=5.4947443e-009
+ wketa=-6.7532846e-009     pketa=1.4574264e-015      dwg=0
+ dwb=0                     pclm=0.61031361+dpclmprf  lpclm=6.0767635e-008
+ wpclm=1.0004768e-006      ppclm=-9.4644237e-014     pdiblc1=0
+ pdiblc2=0.006016015       lpdiblc2=-3.358036e-010   wpdiblc2=6.0613476e-010
+ ppdiblc2=2.0685502e-016   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswprf          rdw=110+drdswprf          prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxprf              xrcrg1=12                 xrcrg2=1
+ cgso=cgoprf               cgdo=cgoprf               cgbo=0
+ cgdl=cglprf               cgsl=cglprf               clc=0
+ cle=0.6                   cf=cfprf                  ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.16893655
+ lkt1=-1.5260094e-008      wkt1=-4.9930633e-008      pkt1=5.548348e-015
+ kt1l=0                    kt2=-0.076688374          lkt2=6.3262708e-010
+ wkt2=8.6444572e-009       pkt2=-1.8439993e-016      ute=-1
+ lute=0+dluteprf           ua1=2.1379915e-009        lua1=-2.2372423e-017
+ wua1=-5.2528714e-016      pua1=4.932099e-023        ub1=-3.8122845e-018
+ lub1=1.3997821e-025       wub1=1.5501104e-024       pub1=-1.5360742e-031
+ uc1=-5.2955612e-011       luc1=-2.6542572e-017      wuc1=2.8572208e-017
+ puc1=1.2642006e-023       prt=0                     at=184411.39
+ lat=-0.012973923+dlatprf  wat=0.030540915           pat=-3.0169314e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=0                   cjswd=0                   mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgprf         jtsswgd=jtsswgprf         njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wvth0=0+dwvthprf          pvth0=0+dpvthprf          lnfactor=0+dlnfactorprf
+ wnfactor=0+dwnfactorprf   pnfactor=0+dpnfactorprf   leta0=0+dleta0prf
+ peta0=0+dpeta0prf         saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiaprf
+ noib=noibprf              noic=noicprf              em=3e+8
+ ef=1.1                   lintnoi=-1e-8             rnoib=0
+ rnoia=rnoiax              tnoia=tnoiax              minr=1e-3
 
 
 
     4: type=p 
+ lmin=6.0e-008             lmax=1e-007-(dxlprf+dlmisprf)
+ wmin=0.6e-006             wmax=1e-006-(dxwprf+dwmisprf)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29540698+(dvthprf+vthmisprf)-0.0159726*ss_flagrf-0.00177473*ff_flagrf-0.00141979*sf_flagrf+0.00141979*fs_flagrf
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=8.7795407e-010+dlvthprf+1.30948e-09*ss_flagrf+1.45498e-10*ff_flagrf+1.16398e-10*sf_flagrf-1.16398e-10*fs_flagrf
+ wvth0=-1.9586003e-009+dwvthprf+1.62282e-08*ss_flagrf+1.80313e-09*ff_flagrf+1.4425e-09*sf_flagrf-1.4425e-09*fs_flagrf
+ pvth0=1.6057193e-016+dpvthprf-1.33043e-15*ss_flagrf-1.47826e-16*ff_flagrf-1.18261e-16*sf_flagrf+1.18261e-16*fs_flagrf
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.016174181+dk2prf
+ lk2=-3.0421667e-009+dlk2prf                         wk2=-5.324044e-010+dwk2prf
+ pk2=-2.1514249e-018+dpk2prf                         k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00062909018+dcitprf
+ lcit=3.8391373e-010+dlcitprf                        wcit=1.2314572e-010+dwcitprf
+ pcit=-2.334243e-017+dpcitprf                        voff=-0.10938425+dvoffprf-0.00354947*ff_flagrf-0.00283957*sf_flagrf+0.00283957*fs_flagrf
+ lvoff=-2.4359313e-009+dlvoffprf+2.90995e-10*ff_flagrf+2.32796e-10*sf_flagrf-2.32796e-10*fs_flagrf
+ wvoff=-3.9675416e-009+dwvoffprf+3.60626e-09*ff_flagrf+2.88501e-09*sf_flagrf-2.88501e-09*fs_flagrf
+ pvoff=5.3489177e-016+dpvoffprf-2.95651e-16*ff_flagrf-2.36521e-16*sf_flagrf+2.36521e-16*fs_flagrf
+ nfactor=0.52254+dnfactorprf                         eta0=0.10118848+deta0prf-0.0053242*ss_flagrf+0.00292716*ff_flagrf+0.00234173*sf_flagrf-0.00234173*fs_flagrf
+ leta0=5.6741682e-009+dleta0prf+4.36493e-10*ss_flagrf-2.39977e-10*ff_flagrf-1.91981e-10*sf_flagrf+1.91981e-10*fs_flagrf
+ weta0=3.5358559e-009+dweta0prf+5.40939e-09*ss_flagrf-1.80313e-09*ff_flagrf-1.4425e-09*sf_flagrf+1.4425e-09*fs_flagrf
+ peta0=-1.5726189e-015+dpeta0prf-4.43477e-16*ss_flagrf+1.47826e-16*ff_flagrf+1.18261e-16*sf_flagrf-1.18261e-16*fs_flagrf
+ etab=-0.19164554          letab=5.260132e-009       wetab=2.4691051e-008
+ petab=-4.5170152e-016     u0=0.007993289+du0prf+0.000354947*ss_flagrf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-3.1791941e-011+dlu0prf-2.90995e-11*ss_flagrf
+ wu0=3.1451146e-010+dwu0prf-3.60626e-10*ss_flagrf    pu0=-3.5034197e-018+dpu0prf+2.95651e-17*ss_flagrf
+ ua=-1.6703285e-009        lua=7.0866099e-017        wua=6.1081852e-016
+ pua=-2.8011924e-023       ub=2.901488e-018          lub=-1.0431709e-025
+ wub=-9.3365687e-025       pub=4.072485e-032         uc=7.905756e-011
+ luc=-2.3055534e-018       wuc=-2.4315118e-017       puc=6.5201705e-025
+ vsat=142324.79+dvsatprf   lvsat=-0.0028654031+dlvsatprf
+ kvsat=1                   wvsat=-0.028015368+dwvsatprf
+ pvsat=1.4193905e-009+dpvsatprf                      a0=-2.9278421+da0prf
+ la0=3.040907e-007+dla0prf wa0=4.7815343e-007+dwa0prf
+ pa0=-2.0988067e-014+dpa0prf                         ags=6.1194084+dagsprf
+ wags=-1.8219607e-006+dwagsprf                       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.19346001          lketa=1.1069505e-008      wketa=1.6008697e-008
+ pketa=-4.0866915e-016     dwg=0                     dwb=0
+ pclm=2.2176108+dpclmprf-0.08067*ff_flagrf-0.0645358*sf_flagrf+0.0645358*fs_flagrf
+ lpclm=-7.1003406e-008+6.61357e-09*ff_flagrf+5.29083e-09*sf_flagrf-5.29083e-09*fs_flagrf
+ wpclm=-3.313857e-007-1e-14*ff_flagrf+1.9e-13*sf_flagrf-1.9e-13*fs_flagrf
+ ppclm=1.4545844e-014+1e-21*ff_flagrf+1e-21*sf_flagrf-1e-21*fs_flagrf
+ pdiblc1=0                 pdiblc2=0.0036947056      lpdiblc2=-1.4549569e-010
+ wpdiblc2=1.3261792e-009   ppdiblc2=1.4782362e-016   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswprf          rdw=110+drdswprf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxprf              xrcrg1=12
+ xrcrg2=1                  cgso=cgoprf               cgdo=cgoprf
+ cgbo=0                    cgdl=cglprf               cgsl=cglprf
+ clc=0                     cle=0.6                   cf=cfprf
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.32553899           lkt1=-2.4213564e-009      wkt1=2.8348995e-008
+ pkt1=-8.6925076e-016      kt1l=0                    kt2=-0.070439129
+ lkt2=1.2029518e-010       wkt2=6.1470714e-009       pkt2=2.034325e-017
+ ute=-1                    lute=0+dluteprf           ua1=1.5842866e-009
+ lua1=2.302196e-017        wua1=1.7143716e-016       pua1=-7.7985591e-024
+ ub1=-1.3227127e-018       lub1=-6.4124354e-026      wub1=-6.3502833e-025
+ pub1=2.5536811e-032       uc1=-7.3502816e-010       luc1=2.9375781e-017
+ wuc1=4.6719792e-016       puc1=-2.3317845e-023      prt=0
+ at=26160                  wat=-0.00625856           lat=0+dlatprf
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=0                   cjswd=0                   mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgprf         jtsswgd=jtsswgprf         njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsprf           lags=0+dlagsprf           lnfactor=0+dlnfactorprf
+ wnfactor=0+dwnfactorprf   pnfactor=0+dpnfactorprf   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiaprf              noib=noibprf              noic=noicprf
+ em=3e+8                   ef=1.1                    lintnoi=-1e-8
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3 
     } 
 
// 
model pdio_rf_f diode 
+ level=1                   is=1.73e-07               n=1
+ bv=9.59                   ibv=0.03                  isw=1.86e-13
+ cj=cjprf                  pj=7.2e-4                 mj=0.31
+ fc=0                      cjsw=cjswprf              area=3.08e-8
+ mjsw=0.063                tlevc=1                   cta=0.00085
+ ctp=0.0002                tbv1=-1*-7.9e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.96
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.003                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_g diode 
+ level=1                   is=1.73e-07               n=1
+ bv=9.59                   ibv=0.03                  isw=1.86e-13
+ cj=cjprf                  pj=7.2e-4                 mj=0.31
+ fc=0                      cjsw=cjswgprf             area=3.08e-8
+ mjsw=0.98                 tlevc=1                   cta=0.00085
+ ctp=0.0024                tbv1=-1*-7.9e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.42
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.0004                ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf
// 
inline subckt pmos_rf_nw ( d g s b ) 
parameters lr=0.06e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf temp2=parp2rf 
+ fac1=0.836583 * temp1 * sigma + 0.547841 * temp2 * sigma fac2=0.836583 * temp1 
+ * sigma - 0.547841 * temp2 * sigma lef=lr - 1.09e-08 wef=wr + 1.6e-08 geo_fac=1 
+ / sqrt(nr * lef * wef * 1e12) vthmisprf=0.00215161 * geo_fac * fac1 * mismatchflag 
+ dlmisprf=0.00170787 * geo_fac * lef * fac2 * mismatchflag dwmisprf= - 0.00170787 
+ * geo_fac * wef * fac2 * mismatchflag toxmisprf=0.00170787 * geo_fac * toxprf 
+ * fac2 * mismatchflag lspace=0.24u ledge=0.45u ledgeeff=0.24u lsti=0.5u wsti=1.0u 
+ rod=316 rsti=605 ns=int(nr / 2 + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) 
+ * 2) dummyflag=1 sleff=ledge + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag 
+ * (ledgeeff - ledge) ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace 
+ - sleff) ldiod=(ns - 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge 
+ - lspace sdiofa=wr * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) 
+ ddiofa=wr * ldiod ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr 
+ + (2 - nodd) * wr * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge 
+ + lr / 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / 
+ (ledge + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 
+ 1 / (nr * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 
+ 1e6 - 0.003) + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) 
+ + 0.11307 * wr * 1e6 + 0.916 * lr * 1e6 + 2220.9 * lr / nr / wr + 0.8366) rsx=(0.0337 
+ * (lr + lspace) * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) 
+ rdx=0.01 * (lr + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / 
+ nd + 0.201 / (0.2 + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod 
+ * (lod + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti 
+ * wsti / 2) / ((lod - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 
+ * lspace) / 12 + rsti * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 
+ + 180 / (wr * nr * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 
+ * wr * 1e6 + 1.26) + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) 
+ * 1e6 + 0.05 * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) 
+ + 1.6 * nr * (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=3.163e05 / (lr * 1e6) 
+ + 5.918e07 rnoiax=0.02751 / (lr * 1e6) + 0.3577 
// *********************
 
 
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf_nw ( di gi si bi ) pch_rf l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax sca=0 
+ scb=0 scc=0
 
model pch_rf bsim4  { 
     1: type=p 
+ lmin=1e-007-(dxlprf+dlmisprf)                       lmax=2.401e-007
+ wmin=1e-006-(dxwprf+dwmisprf)                       wmax=6.01e-006
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29576369+(dvthprf+vthmisprf)
+ lvth0=9.0719854e-010+dlvthprf                       kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.330e-8
+ k1=0.22699184             lk1=3.5259378e-009        k2=0.026943317+dk2prf
+ lk2=-3.9015228e-009+dlk2prf                         wk2=-3.6665798e-009+dwk2prf
+ pk2=2.3089123e-016+dpk2prf                          k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00012999806+dcitprf
+ lcit=4.0734852e-010+dlcitprf                        wcit=3.8305183e-010+dwcitprf
+ pcit=-1.100318e-016+dpcitprf                        voff=-0.11734135+dvoffprf
+ lvoff=-3.1031126e-009+dlvoffprf                     wvoff=-1.0274471e-008+dwvoffprf
+ pvoff=2.3925938e-015+dpvoffprf                      nfactor=0.52254+dnfactorprf
+ eta0=0.19395111+deta0prf  weta0=-3.9574329e-008+dweta0prf
+ etab=-0.31266109          letab=8.7696452e-009      wetab=1.476912e-007
+ petab=-4.0213308e-015     u0=0.0081272967+du0prf    lu0=-5.4879768e-011+dlu0prf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=-2.5836543e-010+dwu0prf
+ pu0=5.5757844e-017+dpu0prf                          ua=-2.8713742e-010
+ lua=7.0658019e-018        wua=-2.9874999e-016       pua=-3.8341918e-024
+ ub=1.3341522e-018         lub=-4.880481e-026        wub=1.0472447e-025
+ pub=2.9745564e-032        uc=5.7359538e-011         luc=-1.6793179e-018
+ wuc=8.0795147e-019        puc=-2.3657195e-025       vsat=76565.113+dvsatprf
+ lvsat=0.0028993829+dlvsatprf                        kvsat=1
+ wvsat=0.0093925879+dwvsatprf                        pvsat=-2.0270144e-009+dpvsatprf
+ a0=2.9898354+da0prf       la0=-1.6313268e-007+dla0prf
+ wa0=2.3461709e-007+dwa0prf                          pa0=-1.9234613e-014+dpa0prf
+ ags=4.2224855+dagsprf     wags=1.0531294e-007+dwagsprf
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.11067949          lketa=2.3047411e-009
+ wketa=-2.1771325e-008     pketa=4.6984696e-015      dwg=0
+ dwb=0                     pclm=2.4444577+dpclmprf   lpclm=-1.1114817e-007
+ wpclm=-8.6301362e-007     ppclm=8.0022223e-014      pdiblc1=0
+ pdiblc2=0.00097802378     lpdiblc2=6.0344759e-010   wpdiblc2=5.7247338e-009
+ ppdiblc2=-7.4742419e-016  pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswprf          rdw=110+drdswprf          prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxprf              xrcrg1=12                 xrcrg2=1
+ cgso=cgoprf               cgdo=cgoprf               cgbo=0
+ cgdl=cglprf               cgsl=cglprf               clc=0
+ cle=0.6                   cf=cfprf                  ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.23072588
+ lkt1=-7.9464265e-009      wkt1=1.2847325e-008       pkt1=-1.8823377e-015
+ kt1l=0                    kt2=-0.043763468          lkt2=-8.573255e-010
+ wkt2=-2.4807247e-008      pkt2=1.3293919e-015       ute=-1
+ lute=0+dluteprf           ua1=1.9204408e-009        lua1=-7.758166e-018
+ wua1=-3.0425567e-016      pua1=3.4472905e-023       ub1=-2.4001647e-018
+ lub1=-1.3938985e-026      wub1=1.1539672e-025       pub1=2.7724504e-033
+ uc1=-9.1643267e-011       luc1=-6.8709721e-018      wuc1=6.7878865e-017
+ puc1=-7.3443395e-024      prt=0                     at=170459.52
+ lat=-0.0075817218+dlatprf wat=0.044716009           pat=-8.4954082e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=0                   cjswd=0                   mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgprf         jtsswgd=jtsswgprf         njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsprf           lags=0+dlagsprf           wvth0=0+dwvthprf
+ pvth0=0+dpvthprf          lnfactor=0+dlnfactorprf   wnfactor=0+dwnfactorprf
+ pnfactor=0+dpnfactorprf   leta0=0+dleta0prf         peta0=0+dpeta0prf
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiaprf              noib=noibprf
+ noic=noicprf              em=3e+8                   ef=1.1
+ lintnoi=-1e-8             rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
 
 
     2: type=p 
+ lmin=6.0e-008             lmax=1e-007-(dxlprf+dlmisprf)
+ wmin=1e-006-(dxwprf+dwmisprf)                       wmax=6.01e-006
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29872784+(dvthprf+vthmisprf)-0.00256504*ff_flagrf-0.00205203*sf_flagrf+0.00205203*fs_flagrf
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=1.1502081e-009+dlvthprf+2.10289e-10*ff_flagrf+1.68231e-10*sf_flagrf-1.68231e-10*fs_flagrf
+ wvth0=1.4153925e-009+dwvthprf+2.60608e-09*ff_flagrf+2.08486e-09*sf_flagrf-2.08486e-09*fs_flagrf
+ pvth0=-1.1603812e-016+dpvthprf-2.13654e-16*ff_flagrf-1.70923e-16*sf_flagrf+1.70923e-16*fs_flagrf
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.016705963+dk2prf
+ lk2=-3.0622338e-009+dlk2prf                         wk2=-1.0726945e-009+dwk2prf
+ pk2=1.8236725e-017+dpk2prf                          k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00014675011+dcitprf
+ lcit=3.8465988e-010+dlcitprf                        wcit=-6.6510802e-010+dwcitprf
+ pcit=-2.4100516e-017+dpcitprf                       voff=-0.13554627+dvoffprf-0.00192378*ff_flagrf-0.00153902*sf_flagrf+0.00153902*fs_flagrf
+ lvoff=-1.6106189e-009+dlvoffprf+1.57717e-10*ff_flagrf+1.26174e-10*sf_flagrf-1.26174e-10*fs_flagrf
+ wvoff=2.2613071e-008+dwvoffprf+1.95456e-09*ff_flagrf+1.56365e-09*sf_flagrf-1.56365e-09*fs_flagrf
+ pvoff=-3.0362561e-016+dpvoffprf-1.60241e-16*ff_flagrf-1.28192e-16*sf_flagrf+1.28192e-16*fs_flagrf
+ nfactor=0.52254+dnfactorprf                         eta0=0.17100596+deta0prf-0.0032063*ss_flagrf+0.00884754*ff_flagrf+0.00707803*sf_flagrf-0.00707803*fs_flagrf
+ leta0=1.8811126e-009+dleta0prf+2.62862e-10*ss_flagrf-7.25347e-10*ff_flagrf-5.80278e-10*sf_flagrf+5.80278e-10*fs_flagrf
+ weta0=-6.7398703e-008+dweta0prf+3.2576e-09*ss_flagrf-7.81824e-09*ff_flagrf-6.25459e-09*sf_flagrf+6.25459e-09*fs_flagrf
+ peta0=2.2811256e-015+dpeta0prf-2.67067e-16*ss_flagrf+6.40962e-16*ff_flagrf+5.1277e-16*sf_flagrf-5.1277e-16*fs_flagrf
+ etab=-0.34775733          letab=1.164694e-008       wetab=1.8330063e-007
+ petab=-6.9406985e-015     u0=0.0074093674+du0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=3.9782258e-012+dlu0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ wu0=9.0777576e-010+dwu0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ pu0=-3.9845909e-017+dpu0prf+0.0*ff_flagrf+0.0*sf_flagrf+0.0*fs_flagrf
+ ua=-3.1739587e-010        lua=9.5464802e-018        wua=-7.6376103e-016
+ pua=3.4288809e-023        ub=7.346529e-019          lub=3.4394381e-028
+ wub=1.2678476e-024        pub=-6.5610763e-032       uc=6.5388509e-011
+ luc=-2.3375571e-018       wuc=-1.0427362e-017       puc=6.8453272e-025
+ vsat=137687.82+dvsatprf   lvsat=-0.0021116397+dlvsatprf
+ kvsat=1                   wvsat=-0.023304207+dwvsatprf
+ pvsat=6.5356692e-010+dpvsatprf                      a0=-2.4572186+da0prf
+ la0=2.8343315e-007+dla0prf                          ags=4.2224855+dagsprf
+ wags=1.0531294e-007+dwagsprf                        a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.23693636          lketa=1.2655658e-008      wketa=6.0180664e-008
+ pketa=-2.0202003e-015     dwg=0                     dwb=0
+ pclm=1.6519048+dpclmprf-0.119145*ff_flagrf-0.0953162*sf_flagrf+0.0953162*fs_flagrf
+ lpclm=-4.6172311e-008+9.76787e-09*ff_flagrf+7.8143e-09*sf_flagrf-7.8143e-09*fs_flagrf
+ wpclm=2.4337152e-007+3.90912e-08*ff_flagrf+3.1273e-08*sf_flagrf-3.1273e-08*fs_flagrf
+ ppclm=-1.0682549e-014-3.20481e-15*ff_flagrf-2.56385e-15*sf_flagrf+2.56385e-15*fs_flagrf
+ pdiblc1=0                 pdiblc2=0.0057736665      lpdiblc2=2.1028641e-010
+ wpdiblc2=-7.8604521e-010  ppdiblc2=-2.1365099e-016  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswprf          rdw=110+drdswprf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxprf              xrcrg1=12
+ xrcrg2=1                  cgso=cgoprf               cgdo=cgoprf
+ cgbo=0                    cgdl=cglprf               cgsl=cglprf
+ clc=0                     cle=0.6                   cf=cfprf
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.27609462           lkt1=-4.2269617e-009      wkt1=-2.1886485e-008
+ pkt1=9.6524418e-016       kt1l=0                    kt2=-0.055277267
+ lkt2=8.661024e-011        wkt2=-9.2573803e-009      pkt2=5.4567146e-017
+ ute=-1                    lute=0+dluteprf           ua1=1.3880396e-009
+ lua1=3.5889685e-017       wua1=3.7082419e-016       pua1=-2.0872167e-023
+ ub1=-2.2253259e-018       lub1=-2.8272798e-026      wub1=2.8202664e-025
+ pub1=-1.088837e-032       uc1=-2.292058e-010        luc1=4.4068173e-018
+ wuc1=-4.6717596e-017      puc1=2.0506222e-024       prt=0
+ at=157087.06              lat=-0.0064854075+dlatprf wat=-0.13928046
+ pat=6.589174e-009         jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=0                   cjswd=0
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=0                  cjswgd=0
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgprf         jtsswgd=jtsswgprf
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             pa0=0+dpa0prf             wa0=0+dwa0prf
+ pags=0+dpagsprf           lags=0+dlagsprf           lnfactor=0+dlnfactorprf
+ wnfactor=0+dwnfactorprf   pnfactor=0+dpnfactorprf   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiaprf              noib=noibprf              noic=noicprf
+ em=3e+8                   ef=1.1                    lintnoi=-1e-8
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
 
 
     3: type=p 
+ lmin=1e-007-(dxlprf+dlmisprf)                       lmax=2.401e-007
+ wmin=0.6e-006             wmax=1e-006-(dxwprf+dwmisprf)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29576369+(dvthprf+vthmisprf)
+ lvth0=9.0719854e-010+dlvthprf                       kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.330e-8
+ k1=0.22699184             lk1=3.5259378e-009        k2=0.03091297+dk2prf
+ lk2=-4.2504968e-009+dlk2prf                         wk2=-7.6997473e-009+dwk2prf
+ pk2=5.8544885e-016+dpk2prf                          k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-8.6885462e-005+dcitprf
+ lcit=3.3946216e-010+dlcitprf                        wcit=3.3924943e-010+dwcitprf
+ pcit=-4.105926e-017+dpcitprf                        voff=-0.13057397+dvoffprf
+ lvoff=-6.9873453e-010+dlvoffprf                     wvoff=3.169867e-009+dwvoffprf
+ pvoff=-5.0254392e-017+dpvoffprf                     nfactor=0.52254+dnfactorprf
+ eta0=0.1704+deta0prf      weta0=-1.56464e-008+dweta0prf
+ etab=-0.27655807          letab=1.2221516e-008      wetab=1.1101053e-007
+ petab=-7.5284313e-015     u0=0.0076055944+du0prf    lu0=-7.5738254e-015+dlu0prf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=2.7168411e-010+dwu0prf
+ pu0=7.6950066e-021+dpu0prf                          ua=-7.9656463e-010
+ lua=-7.6768419e-019       wua=2.1882806e-016        pua=4.1246301e-024
+ ub=1.9380097e-018         lub=-2.5328244e-026       wub=-5.0879468e-025
+ pub=5.8933735e-033        uc=1.3013354e-010         luc=-6.4929155e-018
+ wuc=-7.3130435e-017       puc=4.6540432e-024        vsat=79356.857+dvsatprf
+ lvsat=0.0022968966+dlvsatprf                        kvsat=1
+ wvsat=0.0065561759+dwvsatprf                        pvsat=-1.4148883e-009+dpvsatprf
+ a0=4.971014+da0prf        la0=-3.4348122e-007+dla0prf
+ wa0=-1.7782604e-006+dwa0prf                         pa0=1.6399951e-013+dpa0prf
+ ags=6.1193988+dagsprf     lags=7.8995813e-013+dlagsprf
+ wags=-1.8219509e-006+dwagsprf                       pags=-8.0259746e-019+dpagsprf
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.12546103          lketa=5.4947443e-009
+ wketa=-6.7532846e-009     pketa=1.4574264e-015      dwg=0
+ dwb=0                     pclm=0.61031361+dpclmprf  lpclm=6.0767635e-008
+ wpclm=1.0004768e-006      ppclm=-9.4644237e-014     pdiblc1=0
+ pdiblc2=0.006016015       lpdiblc2=-3.358036e-010   wpdiblc2=6.0613476e-010
+ ppdiblc2=2.0685502e-016   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswprf          rdw=110+drdswprf          prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxprf              xrcrg1=12                 xrcrg2=1
+ cgso=cgoprf               cgdo=cgoprf               cgbo=0
+ cgdl=cglprf               cgsl=cglprf               clc=0
+ cle=0.6                   cf=cfprf                  ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.16893655
+ lkt1=-1.5260094e-008      wkt1=-4.9930633e-008      pkt1=5.548348e-015
+ kt1l=0                    kt2=-0.076688374          lkt2=6.3262708e-010
+ wkt2=8.6444572e-009       pkt2=-1.8439993e-016      ute=-1
+ lute=0+dluteprf           ua1=2.1379915e-009        lua1=-2.2372423e-017
+ wua1=-5.2528714e-016      pua1=4.932099e-023        ub1=-3.8122845e-018
+ lub1=1.3997821e-025       wub1=1.5501104e-024       pub1=-1.5360742e-031
+ uc1=-5.2955612e-011       luc1=-2.6542572e-017      wuc1=2.8572208e-017
+ puc1=1.2642006e-023       prt=0                     at=184411.39
+ lat=-0.012973923+dlatprf  wat=0.030540915           pat=-3.0169314e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=0                   cjswd=0                   mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgprf         jtsswgd=jtsswgprf         njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wvth0=0+dwvthprf          pvth0=0+dpvthprf          lnfactor=0+dlnfactorprf
+ wnfactor=0+dwnfactorprf   pnfactor=0+dpnfactorprf   leta0=0+dleta0prf
+ peta0=0+dpeta0prf         saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiaprf
+ noib=noibprf              noic=noicprf              em=3e+8
+ ef=1.1                    lintnoi=-1e-8             rnoib=0
+ rnoia=rnoiax              tnoia=tnoiax              minr=1e-3
 
 
 
     4: type=p 
+ lmin=6.0e-008             lmax=1e-007-(dxlprf+dlmisprf)
+ wmin=0.6e-006             wmax=1e-006-(dxwprf+dwmisprf)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=0
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxprf+toxmisprf)
+ toxm=2.2e-009             dtox=3.2067e-010          epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlprf+dlmisprf)                      xw=1.6e-08+(dxwprf+dwmisprf)
+ dlc=1.25625e-09+ddlcprf   dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.29540698+(dvthprf+vthmisprf)-0.0159726*ss_flagrf-0.00177473*ff_flagrf-0.00141979*sf_flagrf+0.00141979*fs_flagrf
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=8.7795407e-010+dlvthprf+1.30948e-09*ss_flagrf+1.45498e-10*ff_flagrf+1.16398e-10*sf_flagrf-1.16398e-10*fs_flagrf
+ wvth0=-1.9586003e-009+dwvthprf+1.62282e-08*ss_flagrf+1.80313e-09*ff_flagrf+1.4425e-09*sf_flagrf-1.4425e-09*fs_flagrf
+ pvth0=1.6057193e-016+dpvthprf-1.33043e-15*ss_flagrf-1.47826e-16*ff_flagrf-1.18261e-16*sf_flagrf+1.18261e-16*fs_flagrf
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.016174181+dk2prf
+ lk2=-3.0421667e-009+dlk2prf                         wk2=-5.324044e-010+dwk2prf
+ pk2=-2.1514249e-018+dpk2prf                         k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00062909018+dcitprf
+ lcit=3.8391373e-010+dlcitprf                        wcit=1.2314572e-010+dwcitprf
+ pcit=-2.334243e-017+dpcitprf                        voff=-0.10938425+dvoffprf-0.00354947*ff_flagrf-0.00283957*sf_flagrf+0.00283957*fs_flagrf
+ lvoff=-2.4359313e-009+dlvoffprf+2.90995e-10*ff_flagrf+2.32796e-10*sf_flagrf-2.32796e-10*fs_flagrf
+ wvoff=-3.9675416e-009+dwvoffprf+3.60626e-09*ff_flagrf+2.88501e-09*sf_flagrf-2.88501e-09*fs_flagrf
+ pvoff=5.3489177e-016+dpvoffprf-2.95651e-16*ff_flagrf-2.36521e-16*sf_flagrf+2.36521e-16*fs_flagrf
+ nfactor=0.52254+dnfactorprf                         eta0=0.10118848+deta0prf-0.0053242*ss_flagrf+0.00292716*ff_flagrf+0.00234173*sf_flagrf-0.00234173*fs_flagrf
+ leta0=5.6741682e-009+dleta0prf+4.36493e-10*ss_flagrf-2.39977e-10*ff_flagrf-1.91981e-10*sf_flagrf+1.91981e-10*fs_flagrf
+ weta0=3.5358559e-009+dweta0prf+5.40939e-09*ss_flagrf-1.80313e-09*ff_flagrf-1.4425e-09*sf_flagrf+1.4425e-09*fs_flagrf
+ peta0=-1.5726189e-015+dpeta0prf-4.43477e-16*ss_flagrf+1.47826e-16*ff_flagrf+1.18261e-16*sf_flagrf-1.18261e-16*fs_flagrf
+ etab=-0.19164554          letab=5.260132e-009       wetab=2.4691051e-008
+ petab=-4.5170152e-016     u0=0.007993289+du0prf+0.000354947*ss_flagrf
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-3.1791941e-011+dlu0prf-2.90995e-11*ss_flagrf
+ wu0=3.1451146e-010+dwu0prf-3.60626e-10*ss_flagrf    pu0=-3.5034197e-018+dpu0prf+2.95651e-17*ss_flagrf
+ ua=-1.6703285e-009        lua=7.0866099e-017        wua=6.1081852e-016
+ pua=-2.8011924e-023       ub=2.901488e-018          lub=-1.0431709e-025
+ wub=-9.3365687e-025       pub=4.072485e-032         uc=7.905756e-011
+ luc=-2.3055534e-018       wuc=-2.4315118e-017       puc=6.5201705e-025
+ vsat=142324.79+dvsatprf   lvsat=-0.0028654031+dlvsatprf
+ kvsat=1                   wvsat=-0.028015368+dwvsatprf
+ pvsat=1.4193905e-009+dpvsatprf                      a0=-2.9278421+da0prf
+ la0=3.040907e-007+dla0prf wa0=4.7815343e-007+dwa0prf
+ pa0=-2.0988067e-014+dpa0prf                         ags=6.1194084+dagsprf
+ wags=-1.8219607e-006+dwagsprf                       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.19346001          lketa=1.1069505e-008      wketa=1.6008697e-008
+ pketa=-4.0866915e-016     dwg=0                     dwb=0
+ pclm=2.2176108+dpclmprf-0.08067*ff_flagrf-0.0645358*sf_flagrf+0.0645358*fs_flagrf
+ lpclm=-7.1003406e-008+6.61357e-09*ff_flagrf+5.29083e-09*sf_flagrf-5.29083e-09*fs_flagrf
+ wpclm=-3.313857e-007-1e-14*ff_flagrf+1.9e-13*sf_flagrf-1.9e-13*fs_flagrf
+ ppclm=1.4545844e-014+1e-21*ff_flagrf+1e-21*sf_flagrf-1e-21*fs_flagrf
+ pdiblc1=0                 pdiblc2=0.0036947056      lpdiblc2=-1.4549569e-010
+ wpdiblc2=1.3261792e-009   ppdiblc2=1.4782362e-016   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswprf          rdw=110+drdswprf
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxprf              xrcrg1=12
+ xrcrg2=1                  cgso=cgoprf               cgdo=cgoprf
+ cgbo=0                    cgdl=cglprf               cgsl=cglprf
+ clc=0                     cle=0.6                   cf=cfprf
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.32553899           lkt1=-2.4213564e-009      wkt1=2.8348995e-008
+ pkt1=-8.6925076e-016      kt1l=0                    kt2=-0.070439129
+ lkt2=1.2029518e-010       wkt2=6.1470714e-009       pkt2=2.034325e-017
+ ute=-1                    lute=0+dluteprf           ua1=1.5842866e-009
+ lua1=2.302196e-017        wua1=1.7143716e-016       pua1=-7.7985591e-024
+ ub1=-1.3227127e-018       lub1=-6.4124354e-026      wub1=-6.3502833e-025
+ pub1=2.5536811e-032       uc1=-7.3502816e-010       luc1=2.9375781e-017
+ wuc1=4.6719792e-016       puc1=-2.3317845e-023      prt=0
+ at=26160                  wat=-0.00625856           lat=0+dlatprf
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=0                   cjswd=0                   mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=0                  cjswgd=0                  mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgprf         jtsswgd=jtsswgprf         njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsprf           lags=0+dlagsprf           lnfactor=0+dlnfactorprf
+ wnfactor=0+dwnfactorprf   pnfactor=0+dpnfactorprf   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiaprf              noib=noibprf              noic=noicprf
+ em=3e+8                   ef=1.1                    lintnoi=-1e-8
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
     }  
 
// 
model pdio_rf_f diode 
+ level=1                   is=1.73e-07               n=1
+ bv=9.59                   ibv=0.03                  isw=1.86e-13
+ cj=cjprf                  pj=7.2e-4                 mj=0.31
+ fc=0                      cjsw=cjswprf              area=3.08e-8
+ mjsw=0.063                tlevc=1                   cta=0.00085
+ ctp=0.0002                tbv1=-1*-7.9e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.96
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.003                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_g diode 
+ level=1                   is=1.73e-07               n=1
+ bv=9.59                   ibv=0.03                  isw=1.86e-13
+ cj=cjprf                  pj=7.2e-4                 mj=0.31
+ fc=0                      cjsw=cjswgprf             area=3.08e-8
+ mjsw=0.98                 tlevc=1                   cta=0.00085
+ ctp=0.0024                tbv1=-1*-7.9e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.42
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.0004                ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf_nw
// 
endsection rf_mos
 

 
// *************************************************************************************************
// 
//  1.8V IO MOS MODEL
// 
// 
// 
//               .lib RF_MOS_25ud18
// 
//               Model name               nr               lr (um)           wr (um)
//                                    low   high        low     high     low   high
//             -------------------------------------------------------------------
//               nmos_rf_18        1     32         0.26    0.38     1.0   10.0
//             -------------------------------------------------------------------
//               pmos_rf_18        1     32         0.26    0.38     1.0   10.0
//             -------------------------------------------------------------------
//               pmos_rf_18_nw     1     32         0.26    0.38     1.0    10.0
//             -------------------------------------------------------------------
//             **nr: Finger number
//             **wr: Width per finger
// 
// *************************************************************************************************

section rf_mos_18
inline subckt nmos_rf_18 ( d g s b ) 
parameters lr=0.28e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parn1rf_18 
+ temp2=parn2rf_18 fac1=0.308877 * temp1 * sigma + 0.951102 * temp2 * sigma 
+ fac2=0.308877 * temp1 * sigma - 0.951102 * temp2 * sigma lef=lr - 1.5e-08 wef=wr 
+ + 7e-09 geo_fac=1 / sqrt(nr * lef * wef * 1e12) vthmisnrf_18=0.00762502 * 
+ geo_fac * fac1 * mismatchflag dlmisnrf_18=0.00261377 * geo_fac * lef * fac2 
+ * mismatchflag dwmisnrf_18= - 0.00261377 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisnrf_18=0.00261377 * geo_fac * toxnrf_18 * fac2 * mismatchflag lspace=0.31u 
+ ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u rod=835 rsti=1200 ns=int(nr / 2 
+ + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) * 2) dummyflag=1 sleff=ledge 
+ + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag * (ledgeeff - ledge) 
+ ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace - sleff) ldiod=(ns - 
+ 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge - lspace sdiofa=wr 
+ * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) ddiofa=wr * ldiod 
+ ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr + (2 - nodd) * wr 
+ * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge + lr / 
+ 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / (ledge 
+ + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 1 / (nr 
+ * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 1e6 - 0.003) 
+ + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) + 0.11307 
+ * wr * 1e6 + 0.916 * lr * 1e6 + 298.4 * lr / nr / wr) rsx=(0.0337 * (lr + lspace) 
+ * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) rdx=0.01 * (lr 
+ + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / nd + 0.201 / (0.2 
+ + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod * (lod + 4 * ledge 
+ - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti * wsti / 2) / ((lod 
+ - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti 
+ * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=2.4 + 260 / (wr * nr 
+ * 1e6) + 45 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) 
+ + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) * 1e6 + 0.05 
+ * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) + 1.6 * nr * 
+ (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.273e5 / (lr * 1e6) + 8.395e6 rnoiax=0.0353 
+ / (lr * 1e6) + 0.4701 
// *********************
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( sb si ) ndio_rf_18_f area=sdiofa pj=sdiofp
ddd ( db di ) ndio_rf_18_f area=ddiofa pj=ddiofp
dsg ( sb si ) ndio_rf_18_g area=1e-15 pj=sdiogp
ddg ( db di ) ndio_rf_18_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
nmos_rf_18 ( di gi si bi ) nch_rf_18 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax 
+ sca=0 scb=0 scc=0
 
model nch_rf_18 bsim4  { 
     1: type=n 
+ lmin=2.8e-007-(dxlnrf_18+dlmisnrf_18)       lmax=3.801e-007
+ wmin=1.0e-006             wmax=10.01e-006           version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxnrf_18+toxmisnrf_18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlnrf_18+dlmisnrf_18)         xw=7e-09+(dxwnrf_18+dwmisnrf_18)
+ dlc=0+dlcnrf_18       dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.75758999+(dvthnrf_18+vthmisnrf_18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-7.1826805e-008+dlvthnrf_18
+ wvth0=-1.7752407e-007+dwvthnrf_18               pvth0=5.0901156e-014+dpvthnrf_18
+ k1=0.3969                 k2=0.055612502+dk2nrf_18
+ lk2=4.2281593e-009+dlk2nrf_18                   wk2=-1.958867e-008+dwk2nrf_18
+ pk2=8.9889258e-015+dpk2nrf_18                   k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00096605776+dcitnrf_18
+ lcit=4.9825603e-010+dlcitnrf_18                 wcit=3.2583577e-009+dwcitnrf_18
+ pcit=-7.9492407e-016+dpcitnrf_18                voff=-0.28241537
+ lvoff=6.7071684e-008      wvoff=2.2169505e-008      pvoff=-1.2996033e-014
+ nfactor=0.55              eta0=-0.029791305+deta0nrf_18
+ leta0=1.3891218e-007+dleta0nrf_18               weta0=-1.4835653e-007+dweta0nrf_18
+ peta0=5.4150132e-014+dpeta0nrf_18               etab=-0.15951067
+ letab=1.9881793e-008      wetab=1.471697e-008       petab=-5.3716941e-015
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.035918993+du0nrf_18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=4.930933e-010+dlu0nrf_18
+ wu0=-9.7467457e-009+dwu0nrf_18                  pu0=1.8411048e-015+dpu0nrf_18
+ ua=-1.7531437e-009        lua=1.8283067e-016        wua=5.2680573e-016
+ pua=-1.8411048e-022       ub=3.4759835e-018         lub=3.1993406e-026
+ wub=-1.4158254e-024       pub=3.5739094e-031        uc=3.0985397e-010
+ luc=-5.2042135e-017       wuc=-1.7366116e-016       puc=3.6822103e-023
+ vsat=98400                a0=1.4604901              la0=-1.2581024e-007
+ kvsat=0                   wa0=-6.2533714e-007       pa0=9.7470332e-014
+ ags=1.788067              lags=-5.288762e-007       wags=-7.3618457e-007
+ pags=1.6245048e-013       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.17618618
+ lketa=4.2280329e-008      wketa=6.8910233e-008      pketa=-1.6569948e-014
+ dwg=0                     dwb=0                     pclm=1.121951
+ lpclm=-2.4932051e-007     wpclm=7.0539343e-008      ppclm=-2.1660057e-014
+ pdiblc1=0                 pdiblc2=0.00053499993     lpdiblc2=2.0427245e-017
+ wpdiblc2=4.0868029e-017   ppdiblc2=-1.0830028e-023  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgonrf_18        cgdo=cgonrf_18        cgbo=0
+ cgdl=cglnrf_18        cgsl=cglnrf_18        clc=0
+ cle=0.6                   cf=cfnrf_18           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.27489651
+ lkt1=-2.1725919e-008      wkt1=-1.0110635e-007      pkt1=2.3826052e-014
+ kt1l=0                    kt2=-0.17637098           lkt2=3.7960245e-008
+ wkt2=1.8289336e-007       pkt2=-5.2583044e-014      ute=-1.2773213
+ lute=-3.6660924e-008      wute=-4.9713442e-007      pute=1.7328046e-013
+ ua1=4.3820418e-011        lua1=3.4724096e-016       wua1=1.3903184e-015
+ pua1=-3.8424909e-022      ub1=-1.2604713e-018       lub1=-2.0864449e-025
+ wub1=4.7444467e-025       pub1=-1.7317226e-031      uc1=1.5592657e-010
+ luc1=-4.6285203e-017      wuc1=-1.6785235e-016      puc1=4.6609196e-023
+ prt=0                     at=86777.305              lat=-0.020447564
+ wat=-0.13217729           pat=4.0071105e-008        fnoimod=1
+ tnoimod=1                 noia=noianrf_18       noib=noibnrf_18
+ noic=noicnrf_18           em=1.12e+8              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=0                   cjswd=0                   mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=0                  cjswgd=0                  mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
     2: type=n 
+ lmin=2.6e-007             lmax=2.8e-007-(dxlnrf_18+dlmisnrf_18)
+ wmin=1.0e-006             wmax=10.01e-006           version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxnrf_18+toxmisnrf_18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlnrf_18+dlmisnrf_18)         xw=7e-09+(dxwnrf_18+dwmisnrf_18)
+ dlc=0+dlcnrf_18       dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.75073439+(dvthnrf_18+vthmisnrf_18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-7.001007e-008+dlvthnrf_18
+ wvth0=-1.7746801e-007+dwvthnrf_18               pvth0=5.0886298e-014+dpvthnrf_18
+ k1=0.3969                 k2=-0.050932169+dk2nrf_18
+ lk2=3.2462497e-008+dlk2nrf_18                   wk2=1.4331819e-008+dwk2nrf_18
+ pk2=-3.6347364e-021+dpk2nrf_18                  k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00091415354+dcitnrf_18
+ lcit=3.6094685e-017+dlcitnrf_18                 wcit=2.5864438e-010+dwcitnrf_18
+ pcit=-3.6347344e-023+dpcitnrf_18                voff=0.034762207
+ lvoff=-1.6980375e-008     wvoff=-1.7774786e-007     pvoff=3.998207e-014
+ nfactor=0.55              eta0=-0.96274464+deta0nrf_18
+ leta0=3.8614481e-007+dleta0nrf_18               weta0=1.1532608e-006+dweta0nrf_18
+ peta0=-2.9077845e-013+dpeta0nrf_18              etab=-0.084484983
+ letab=-1.2984999e-014     wetab=-5.5535737e-009     petab=4.5835914e-028
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.037779722+du0nrf_18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 wu0=-2.7991803e-009+dwu0nrf_18
+ ua=-1.0632167e-009        wua=-1.6795082e-016       ub=3.7337771e-018
+ lub=-3.6321894e-026       wub=-1.4387773e-024       pub=3.634732e-031
+ uc=1.1346843e-010         luc=3.3915377e-023        wuc=-3.4709775e-017
+ puc=-1.4538941e-029       vsat=81952.333            lvsat=0.0043586317
+ kvsat=0                   wvsat=0.1645918           pvsat=-4.3616827e-008
+ a0=-2.8349068             la0=1.0124699e-006        wa0=1.3458454e-005
+ pa0=-3.6347343e-012       ags=-0.20769228           lags=7.2643858e-015
+ wags=-1.2316361e-007      pags=-7.2694716e-020      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.016637831         lketa=1.5868031e-014      wketa=6.382114e-009
+ pketa=3.6347353e-021      dwg=0                     dwb=0
+ pclm=0.18111889           wpclm=-1.1196721e-008     pdiblc1=0
+ pdiblc2=0.00053500013     lpdiblc2=-3.2462505e-017  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgonrf_18        cgdo=cgonrf_18        cgbo=0
+ cgdl=cglnrf_18        cgsl=cglnrf_18        clc=0
+ cle=0.6                   cf=cfnrf_18           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.35688111
+ wkt1=-1.1196721e-008      kt1l=0                    kt2=-0.033124827
+ lkt2=1.4778373e-014       wkt2=-1.5533273e-008      pkt2=1.4538942e-020
+ ute=-1.4156644            wute=1.567541e-007        ua1=1.3541635e-009
+ lua1=3.6321924e-023       wua1=-5.9676816e-017      pua1=-3.6347356e-028
+ ub1=-2.047809e-018        wub1=-1.7903557e-025      uc1=-1.8734497e-011
+ luc1=-2.0203939e-023      wuc1=8.0313851e-018       puc1=7.2694712e-030
+ prt=0                     at=9616.6919              lat=-1.8160965e-009
+ wat=0.019034356           pat=1.8173678e-014        fnoimod=1
+ tnoimod=1                 noia=noianrf_18       noib=noibnrf_18
+ noic=noicnrf_18       em=1.12e+8              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=0                     cjd=0                     mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=0                   cjswd=0                   mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=0                  cjswgd=0                  mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lu0=0+dlu0nrf_18      pu0=0+dpu0nrf_18      saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=8.5e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=1.5e-2            pkvth0we=-11e-17          wkvth0we=-3e-10
+ lkvth0we=+5.83e-9         ku0we=-0.002              pku0we=-5e-17
+ wku0we=-0.9e-9            lku0we=-2e-10             k2we=0.0040
+ pk2we=-2e-17              lk2we=0e-10               wk2we=0.4e-9
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
     } 

// 
model ndio_rf_18_f diode 
+ level=1                   is=1.32e-07               n=1
+ bv=9.2                    ibv=0.03                  isw=6.273e-13
+ cj=cjnrf_18           pj=8.4e-4                 mj=0.31
+ fc=0                      cjsw=cjswnrf_18       area=3.92e-8
+ mjsw=0.105                tlevc=1                   cta=0.00085
+ ctp=0.0003                tbv1=-1*-9.3e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.49
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.001                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model ndio_rf_18_g diode 
+ level=1                   is=1.32e-07               n=1
+ bv=9.2                    ibv=0.03                  isw=6.273e-13
+ cj=cjnrf_18           pj=8.4e-4                 mj=0.31
+ fc=0                      cjsw=cjswgnrf_18      area=3.92e-8
+ mjsw=0.56                 tlevc=1                   cta=0.00085
+ ctp=0.00168               tbv1=-1*-9.3e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=1
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.0025                ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends nmos_rf_18
// 
inline subckt pmos_rf_18 ( d g s b ) 
parameters lr=0.28e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf_18 
+ temp2=parp2rf_18 fac1=0.955472 * temp1 * sigma + 0.295081 * temp2 * sigma 
+ fac2=0.955472 * temp1 * sigma - 0.295081 * temp2 * sigma lef=lr - 1.5e-08 wef=wr 
+ + 7e-09 geo_fac=1 / sqrt(nr * lef * wef * 1e12) vthmisprf_18=0.00615610 * 
+ geo_fac * fac1 * mismatchflag dlmisprf_18=0.00242520 * geo_fac * lef * fac2 
+ * mismatchflag dwmisprf_18= - 0.00242520 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisprf_18=0.00242520 * geo_fac * toxprf_18 * fac2 * mismatchflag lspace=0.31u 
+ ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u rod=316 rsti=605 ns=int(nr / 2 
+ + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) * 2) dummyflag=1 sleff=ledge 
+ + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag * (ledgeeff - ledge) 
+ ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace - sleff) ldiod=(ns - 
+ 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge - lspace sdiofa=wr 
+ * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) ddiofa=wr * ldiod 
+ ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr + (2 - nodd) * wr 
+ * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge + lr / 
+ 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / (ledge 
+ + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 1 / (nr 
+ * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 1e6 - 0.003) 
+ + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) + 0.11307 
+ * wr * 1e6 + 0.916 * lr * 1e6 + 325.8 * lr / nr / wr) rsx=(0.0337 * (lr + lspace) 
+ * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) rdx=0.01 * (lr 
+ + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / nd + 0.201 / (0.2 
+ + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod * (lod + 4 * ledge 
+ - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti * wsti / 2) / ((lod 
+ - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti 
+ * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 + 180 / (wr * nr 
+ * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) 
+ + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) * 1e6 + 0.05 
+ * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) + 1.6 * nr * 
+ (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.91e6 / (lr * 1e6) + 2.818e7 rnoiax=0.0064 
+ / (lr * 1e6) + 0.4993 
// *********************
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_18_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_18_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_18_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_18_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf_18 ( di gi si bi ) pch_rf_18 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax 
+ sca=0 scb=0 scc=0
 
model pch_rf_18 bsim4  { 
     1: type=p 
+ lmin=2.8e-007-(dxlprf_18+dlmisprf_18)       lmax=3.801e-007
+ wmin=1.0e-006             wmax=10.01e-006           version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxprf_18+toxmisprf_18)
+ toxm=5.9e-009             dtox=3.946e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlprf_18+dlmisprf_18)         xw=7e-09+(dxwprf_18+dwmisprf_18)
+ dlc=0                     dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.51953178+(dvthprf_18+vthmisprf_18)
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-2.7831591e-008+dlvthprf_18
+ wvth0=-5.2749074e-008+dwvthprf_18               pvth0=1.7364001e-014+dpvthprf_18
+ k1=0.7812                 k2=-0.031348028+dk2rf_18
+ lk2=-2.0071717e-008       wk2=8.4236856e-009        pk2=1.2956407e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0015244856+dcitprf_18                     lcit=-4.0586038e-010+dlcitprf_18
+ wcit=9.157824e-010+dwcitprf_18                  pcit=-1.9743359e-016+dpcitprf_18
+ voff=0.022401486          lvoff=-2.4184781e-008     wvoff=-6.4219905e-008
+ pvoff=2.3652779e-014      nfactor=0.63002+dnfactorprf_18
+ eta0=-0.30800551          leta0=2.5564493e-007+dleta0prf_18
+ weta0=3.7581797e-007      peta0=-1.093833e-013+dpeta0prf_18
+ etab=-0.019529696         letab=4.295128e-009       wetab=-3.7229096e-008
+ petab=5.4150136e-015      ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.010944428+du0prf_18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.2060999e-009+dlu0prf_18
+ wu0=2.9592934e-010+dwu0prf_18                   pu0=-6.7146177e-017+dpu0prf_18
+ ua=8.9444711e-010         lua=3.671035e-017         wua=-8.8854265e-016
+ pua=1.4854466e-022        ub=-2.300535e-020         lub=5.8681521e-025
+ wub=9.5782351e-025        pub=-2.7183372e-031       uc=3.1736134e-010
+ luc=-7.0850755e-017       wuc=-1.4426417e-016       puc=3.8230005e-023
+ vsat=110000+dvsatprf_18                         a0=1.8055231
+ la0=-3.8725178e-007+dla0prf_18                  kvsat=1
+ wa0=-3.855031e-007+dwa0prf_18                   pa0=1.9710652e-013+dpa0prf_18
+ ags=-2.3468771            lags=1.2757685e-006       wags=1.8553163e-006
+ pags=-7.4979923e-013      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.21869348
+ lketa=5.2505521e-008      wketa=3.4573804e-008      pketa=-7.6784935e-015
+ dwg=0                     dwb=0                     pclm=0.23800278
+ lpclm=1.3682117e-007      wpclm=-5.51369e-007       ppclm=1.6385622e-013
+ pdiblc1=0                 pdiblc2=9.9948008e-006    lpdiblc2=1.081278e-015
+ wpdiblc2=5.2064753e-014   ppdiblc2=-1.0830029e-020  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-009
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgoprf_18        cgdo=cgoprf_18        cgbo=0
+ cgdl=cglprf_18        cgsl=cglprf_18        clc=0
+ cle=0.6                   cf=cfprf_18           ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.42197489           lkt1=2.2032744e-008+dlkt1prf_18
+ wkt1=3.6774552e-008       pkt1=-7.5377107e-015      kt1l=0
+ kt2=-0.071770308          lkt2=9.5940238e-009       wkt2=-6.033913e-008
+ pkt2=2.0143853e-014       ute=-1                    ua1=2.3158011e-009
+ lua1=1.6213259e-016       wua1=-5.9342622e-016      pua1=2.1660057e-022
+ ub1=-3.4418439e-018       lub1=-4.9771136e-025      wub1=1.7107358e-024
+ pub1=-4.5334499e-031      uc1=-1.1426572e-010       luc1=2.9220414e-017
+ wuc1=-6.5388872e-017      puc1=1.7328052e-023       prt=0
+ at=87311.954              lat=-0.016125355          wat=-0.049153607
+ pat=6.4980171e-009        fnoimod=1                 tnoimod=1
+ noia=noiaprf_18       noib=noibprf_18       noic=noicprf_18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=0
+ cjd=0                     mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=0
+ cjswd=0                   mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=0
+ cjswgd=0                  mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lnfactor=0+dlnfactorprf_18
+ wnfactor=0+dwnfactorprf_18                      pnfactor=0+dpnfactorprf_18
+ lvsat=0+dlvsatprf_18  wvsat=0+dwvsatprf_18  pvsat=0+dpvsatprf_18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
 
 
     2: type=p 
+ lmin=2.6e-007             lmax=2.8e-007-(dxlprf_18+dlmisprf_18)
+ wmin=1.0e-006             wmax=10.01e-006           version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxprf_18+toxmisprf_18)
+ toxm=5.9e-009             dtox=3.946e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlprf_18+dlmisprf_18)         xw=7e-09+(dxwprf_18+dwmisprf_18)
+ dlc=0                     dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.78111691+(dvthprf_18+vthmisprf_18)
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=4.1488467e-008+dlvthprf_18
+ wvth0=1.9670666e-007+dwvthprf_18                pvth0=-4.8741768e-014+dpvthprf_18
+ k1=0.7812                 k2=0.029116042+dk2rf_18
+ lk2=-3.6094696e-008       wk2=-1.2384705e-007       pk2=3.6347385e-014
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-7.0622123e-006+dcitprf_18                  lcit=-2.0668625e-016+dlcitprf_18
+ wcit=1.7074995e-010+dwcitprf_18                 pcit=1.1994629e-023+dpcitprf_18
+ voff=-0.083938932         lvoff=3.9954293e-009      wvoff=1.7591159e-007
+ pvoff=-3.9982066e-014     nfactor=-0.70463084+dnfactorprf_18
+ lnfactor=3.5368247e-007+dlnfactorprf_18         wnfactor=1.0972784e-006+dwnfactorprf_18
+ pnfactor=-2.9077878e-013+dpnfactorprf_18        eta0=-0.52744574
+ leta0=3.1379659e-007+dleta0prf_18               weta0=-7.8097278e-008
+ peta0=1.0904243e-014+dpeta0prf_18               etab=-0.0033216565
+ letab=-2.5266285e-015     wetab=-1.6795092e-008     petab=2.5443148e-021
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.011409557+du0prf_18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.0828408e-009+dlu0prf_18
+ wu0=4.1573426e-009+dwu0prf_18                   pu0=-1.0904207e-015+dpu0prf_18
+ ua=1.0329755e-009         lua=3.3915377e-022        wua=-3.2799621e-016
+ pua=-1.4538943e-028       ub=2.1913917e-018         wub=-6.7964097e-026
+ uc=4.9999941e-011         luc=1.4437877e-023        wuc=5.9342621e-023
+ puc=-1.4538942e-029       vsat=-815.40556+dvsatprf_18
+ kvsat=1                   lvsat=0.029366083+dlvsatprf_18
+ wvsat=0.030175163+dwvsatprf_18                  pvsat=-7.9964183e-009+dpvsatprf_18
+ a0=3.4726559              la0=-8.2904195e-007+dla0prf_18
+ wa0=3.3758113e-006+dwa0prf_18                   pa0=-7.9964179e-013+dpa0prf_18
+ ags=2.4673447             lags=-3.2462501e-013      wags=-9.7411474e-007
+ pags=1.906774e-026        a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.15676575
+ lketa=3.6094671e-008      wketa=1.4275823e-007      pketa=-3.6347367e-014
+ dwg=0                     dwb=0                     pclm=0.75430949
+ lpclm=-1.0828408e-013     wpclm=6.6955947e-008      ppclm=1.0904207e-019
+ pdiblc1=0                 pdiblc2=9.9988811e-006    wpdiblc2=1.1196721e-014
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-009          cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgoprf_18        cgdo=cgoprf_18
+ cgbo=0                    cgdl=cglprf_18        cgsl=cglprf_18
+ clc=0                     cle=0.6                   cf=cfprf_18
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.33883246
+ wkt1=8.3303605e-009       kt1l=0                    kt2=-0.035566443
+ lkt2=-3.6321941e-016      wkt2=1.5675396e-008       pkt2=3.6347361e-021
+ ute=-1                    ua1=2.9276222e-009        wua1=2.2393442e-016
+ ub1=-5.32e-018            uc1=-4.0000495e-012       luc1=1.2303973e-023
+ wuc1=2.499668e-023        puc1=-6.1790505e-030      prt=0
+ at=26461.559              lat=-3.268973e-010        wat=-0.0246328
+ pat=3.271262e-015         fnoimod=1                 tnoimod=1
+ noia=noiaprf_18       noib=noibprf_18       noic=noicprf_18
+ em=3e+7                   ef=1.15                  jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=0
+ cjd=0                     mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=0
+ cjswd=0                   mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=0
+ cjswgd=0                  mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lkt1=0+dlkt1prf_18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
     }  
 
// 
model pdio_rf_18_f diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_18           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswprf_18       area=3.92e-8
+ mjsw=0.085                tlevc=1                   cta=0.00085
+ ctp=0.0003                tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.001                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_18_g diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_18           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswgprf_18      area=3.92e-8
+ mjsw=0.5                  tlevc=1                   cta=0.00085
+ ctp=0.00155               tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.9
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.00134               ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf_18
// 
inline subckt pmos_rf_18_nw ( d g s b ) 
parameters lr=0.28e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf_18 
+ temp2=parp2rf_18 fac1=0.955472 * temp1 * sigma + 0.295081 * temp2 * sigma 
+ fac2=0.955472 * temp1 * sigma - 0.295081 * temp2 * sigma lef=lr - 1.5e-08 wef=wr 
+ + 7e-09 geo_fac=1 / sqrt(nr * lef * wef * 1e12) vthmisprf_18=0.00615610 * 
+ geo_fac * fac1 * mismatchflag dlmisprf_18=0.00242520 * geo_fac * lef * fac2 
+ * mismatchflag dwmisprf_18= - 0.00242520 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisprf_18=0.00242520 * geo_fac * toxprf_18 * fac2 * mismatchflag lspace=0.31u 
+ ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u rod=316 rsti=605 ns=int(nr / 2 
+ + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) * 2) dummyflag=1 sleff=ledge 
+ + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag * (ledgeeff - ledge) 
+ ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace - sleff) ldiod=(ns - 
+ 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge - lspace sdiofa=wr 
+ * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) ddiofa=wr * ldiod 
+ ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr + (2 - nodd) * wr 
+ * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge + lr / 
+ 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / (ledge 
+ + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 1 / (nr 
+ * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 1e6 - 0.003) 
+ + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) + 0.11307 
+ * wr * 1e6 + 0.916 * lr * 1e6 + 325.8 * lr / nr / wr) rsx=(0.0337 * (lr + lspace) 
+ * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) rdx=0.01 * (lr 
+ + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / nd + 0.201 / (0.2 
+ + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod * (lod + 4 * ledge 
+ - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti * wsti / 2) / ((lod 
+ - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti 
+ * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 + 180 / (wr * nr 
+ * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) 
+ + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) * 1e6 + 0.05 
+ * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) + 1.6 * nr * 
+ (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.91e6 / (lr * 1e6) + 2.818e7 rnoiax=0.0064 
+ / (lr * 1e6) + 0.4993 
// *********************
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_18_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_18_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_18_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_18_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf_18_nw ( di gi si bi ) pch_rf_18 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax 
+ sca=0 scb=0 scc=0
 
model pch_rf_18 bsim4  { 
     1: type=p 
+ lmin=2.8e-007-(dxlprf_18+dlmisprf_18)       lmax=3.801e-007
+ wmin=1.0e-006             wmax=10.01e-006           version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxprf_18+toxmisprf_18)
+ toxm=5.9e-009             dtox=3.946e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlprf_18+dlmisprf_18)         xw=7e-09+(dxwprf_18+dwmisprf_18)
+ dlc=0                     dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.51953178+(dvthprf_18+vthmisprf_18)
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=-2.7831591e-008+dlvthprf_18
+ wvth0=-5.2749074e-008+dwvthprf_18               pvth0=1.7364001e-014+dpvthprf_18
+ k1=0.7812                 k2=-0.031348028+dk2rf_18
+ lk2=-2.0071717e-008       wk2=8.4236856e-009        pk2=1.2956407e-015
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0015244856+dcitprf_18                     lcit=-4.0586038e-010+dlcitprf_18
+ wcit=9.157824e-010+dwcitprf_18                  pcit=-1.9743359e-016+dpcitprf_18
+ voff=0.022401486          lvoff=-2.4184781e-008     wvoff=-6.4219905e-008
+ pvoff=2.3652779e-014      nfactor=0.63002+dnfactorprf_18
+ eta0=-0.30800551          leta0=2.5564493e-007+dleta0prf_18
+ weta0=3.7581797e-007      peta0=-1.093833e-013+dpeta0prf_18
+ etab=-0.019529696         letab=4.295128e-009       wetab=-3.7229096e-008
+ petab=5.4150136e-015      ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.010944428+du0prf_18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.2060999e-009+dlu0prf_18
+ wu0=2.9592934e-010+dwu0prf_18                   pu0=-6.7146177e-017+dpu0prf_18
+ ua=8.9444711e-010         lua=3.671035e-017         wua=-8.8854265e-016
+ pua=1.4854466e-022        ub=-2.300535e-020         lub=5.8681521e-025
+ wub=9.5782351e-025        pub=-2.7183372e-031       uc=3.1736134e-010
+ luc=-7.0850755e-017       wuc=-1.4426417e-016       puc=3.8230005e-023
+ vsat=110000+dvsatprf_18                         a0=1.8055231
+ la0=-3.8725178e-007+dla0prf_18                  kvsat=1
+ wa0=-3.855031e-007+dwa0prf_18                   pa0=1.9710652e-013+dpa0prf_18
+ ags=-2.3468771            lags=1.2757685e-006       wags=1.8553163e-006
+ pags=-7.4979923e-013      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.21869348
+ lketa=5.2505521e-008      wketa=3.4573804e-008      pketa=-7.6784935e-015
+ dwg=0                     dwb=0                     pclm=0.23800278
+ lpclm=1.3682117e-007      wpclm=-5.51369e-007       ppclm=1.6385622e-013
+ pdiblc1=0                 pdiblc2=9.9948008e-006    lpdiblc2=1.081278e-015
+ wpdiblc2=5.2064753e-014   ppdiblc2=-1.0830029e-020  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-009
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgoprf_18        cgdo=cgoprf_18        cgbo=0
+ cgdl=cglprf_18        cgsl=cglprf_18        clc=0
+ cle=0.6                   cf=cfprf_18           ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.42197489           lkt1=2.2032744e-008+dlkt1prf_18
+ wkt1=3.6774552e-008       pkt1=-7.5377107e-015      kt1l=0
+ kt2=-0.071770308          lkt2=9.5940238e-009       wkt2=-6.033913e-008
+ pkt2=2.0143853e-014       ute=-1                    ua1=2.3158011e-009
+ lua1=1.6213259e-016       wua1=-5.9342622e-016      pua1=2.1660057e-022
+ ub1=-3.4418439e-018       lub1=-4.9771136e-025      wub1=1.7107358e-024
+ pub1=-4.5334499e-031      uc1=-1.1426572e-010       luc1=2.9220414e-017
+ wuc1=-6.5388872e-017      puc1=1.7328052e-023       prt=0
+ at=87311.954              lat=-0.016125355          wat=-0.049153607
+ pat=6.4980171e-009        fnoimod=1                 tnoimod=1
+ noia=noiaprf_18       noib=noibprf_18       noic=noicprf_18
+ em=3e+7                ef=1.15                 jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=0
+ cjd=0                     mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=0
+ cjswd=0                   mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=0
+ cjswgd=0                  mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lnfactor=0+dlnfactorprf_18
+ wnfactor=0+dwnfactorprf_18                      pnfactor=0+dpnfactorprf_18
+ lvsat=0+dlvsatprf_18  wvsat=0+dwvsatprf_18  pvsat=0+dpvsatprf_18
+ saref=4.6e-7              sbref=4.6e-7              wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=5.0e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=-0.57e-2          pkvth0we=-0.0e-17
+ wkvth0we=-2.2e-10         lkvth0we=-2.48e-9         ku0we=-0.0150
+ pku0we=-0e-17             wku0we=-1.2e-9            lku0we=-1.0e-10
+ k2we=0.0125               pk2we=-6e-16              lk2we=-6e-10
+ wk2we=-0.1e-9             rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
 
 
     2: type=p 
+ lmin=2.6e-007             lmax=2.8e-007-(dxlprf_18+dlmisprf_18)
+ wmin=1.0e-006             wmax=10.01e-006           version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxprf_18+toxmisprf_18)
+ toxm=5.9e-009             dtox=3.946e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlprf_18+dlmisprf_18)         xw=7e-09+(dxwprf_18+dwmisprf_18)
+ dlc=0                     dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.78111691+(dvthprf_18+vthmisprf_18)
+ kvth0=+1.1e-09            pkvth0=0                  wkvth0=+3.00e-007
+ lkvth0=-1.5e-7            lvth0=4.1488467e-008+dlvthprf_18
+ wvth0=1.9670666e-007+dwvthprf_18                pvth0=-4.8741768e-014+dpvthprf_18
+ k1=0.7812                 k2=0.029116042+dk2rf_18
+ lk2=-3.6094696e-008       wk2=-1.2384705e-007       pk2=3.6347385e-014
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-7.0622123e-006+dcitprf_18                  lcit=-2.0668625e-016+dlcitprf_18
+ wcit=1.7074995e-010+dwcitprf_18                 pcit=1.1994629e-023+dpcitprf_18
+ voff=-0.083938932         lvoff=3.9954293e-009      wvoff=1.7591159e-007
+ pvoff=-3.9982066e-014     nfactor=-0.70463084+dnfactorprf_18
+ lnfactor=3.5368247e-007+dlnfactorprf_18         wnfactor=1.0972784e-006+dwnfactorprf_18
+ pnfactor=-2.9077878e-013+dpnfactorprf_18        eta0=-0.52744574
+ leta0=3.1379659e-007+dleta0prf_18               weta0=-7.8097278e-008
+ peta0=1.0904243e-014+dpeta0prf_18               etab=-0.0033216565
+ letab=-2.5266285e-015     wetab=-1.6795092e-008     petab=2.5443148e-021
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.011409557+du0prf_18
+ ku0=3.9e-9                pku0=2.0e-15              wku0=1.1e-06
+ lku0=+1.5e-8              lu0=1.0828408e-009+dlu0prf_18
+ wu0=4.1573426e-009+dwu0prf_18                   pu0=-1.0904207e-015+dpu0prf_18
+ ua=1.0329755e-009         lua=3.3915377e-022        wua=-3.2799621e-016
+ pua=-1.4538943e-028       ub=2.1913917e-018         wub=-6.7964097e-026
+ uc=4.9999941e-011         luc=1.4437877e-023        wuc=5.9342621e-023
+ puc=-1.4538942e-029       vsat=-815.40556+dvsatprf_18
+ kvsat=1                   lvsat=0.029366083+dlvsatprf_18
+ wvsat=0.030175163+dwvsatprf_18                  pvsat=-7.9964183e-009+dpvsatprf_18
+ a0=3.4726559              la0=-8.2904195e-007+dla0prf_18
+ wa0=3.3758113e-006+dwa0prf_18                   pa0=-7.9964179e-013+dpa0prf_18
+ ags=2.4673447             lags=-3.2462501e-013      wags=-9.7411474e-007
+ pags=1.906774e-026        a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.15676575
+ lketa=3.6094671e-008      wketa=1.4275823e-007      pketa=-3.6347367e-014
+ dwg=0                     dwb=0                     pclm=0.75430949
+ lpclm=-1.0828408e-013     wpclm=6.6955947e-008      ppclm=1.0904207e-019
+ pdiblc1=0                 pdiblc2=9.9988811e-006    wpdiblc2=1.1196721e-014
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ bgidl=2.041e-009          cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgoprf_18        cgdo=cgoprf_18
+ cgbo=0                    cgdl=cglprf_18        cgsl=cglprf_18
+ clc=0                     cle=0.6                   cf=cfprf_18
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.33883246
+ wkt1=8.3303605e-009       kt1l=0                    kt2=-0.035566443
+ lkt2=-3.6321941e-016      wkt2=1.5675396e-008       pkt2=3.6347361e-021
+ ute=-1                    ua1=2.9276222e-009        wua1=2.2393442e-016
+ ub1=-5.32e-018            uc1=-4.0000495e-012       luc1=1.2303973e-023
+ wuc1=2.499668e-023        puc1=-6.1790505e-030      prt=0
+ at=26461.559              lat=-3.268973e-010        wat=-0.0246328
+ pat=3.271262e-015         fnoimod=1                 tnoimod=1
+ noia=noiaprf_18       noib=noibprf_18       noic=noicprf_18
+ em=3e+7                ef=1.15                   jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=0
+ cjd=0                     mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=0
+ cjswd=0                   mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=0
+ cjswgd=0                  mjswgs=0.5                mjswgd=0.5
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.00134            tcjswg=0.00155
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-6.56e-09             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lkt1=0+dlkt1prf_18    saref=4.6e-7
+ sbref=4.6e-7              wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=5.0e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=-0.57e-2          pkvth0we=-0.0e-17         wkvth0we=-2.2e-10
+ lkvth0we=-2.48e-9         ku0we=-0.0150             pku0we=-0e-17
+ wku0we=-1.2e-9            lku0we=-1.0e-10           k2we=0.0125
+ pk2we=-6e-16              lk2we=-6e-10              wk2we=-0.1e-9
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
     }  
 
// 
model pdio_rf_18_f diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_18           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswprf_18       area=3.92e-8
+ mjsw=0.085                tlevc=1                   cta=0.00085
+ ctp=0.0003                tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.001                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_18_g diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_18           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswgprf_18      area=3.92e-8
+ mjsw=0.5                  tlevc=1                   cta=0.00085
+ ctp=0.00155               tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.9
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.00134               ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf_18_nw
// 
endsection rf_mos_18
 
// *************************************************************************************************
// 
//  2.5V IO MOS MODEL
// 
// 
// 
//               .lib RF_MOS_25
// 
//               Model name           nr               lr (um)           wr (um)
//                                low   high        low     high     low    high
//             -------------------------------------------------------------------
//               nmos_rf_25        1     32         0.28    0.5     1.0    10.0
//             -------------------------------------------------------------------
//               pmos_rf_25        1     32         0.28    0.5     1.0    10.0
//             -------------------------------------------------------------------
//               pmos_rf_25_nw     1     32         0.28    0.5     1.0    10.0
//             -------------------------------------------------------------------
//             **nr: Finger number
//             **wr: Width per finger
// 
// *************************************************************************************************

section rf_mos_25
 
inline subckt nmos_rf_25 ( d g s b ) 
parameters lr=0.28e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parn1rf_25 temp2=parn2rf_25 
+ fac1=0.308877 * temp1 * sigma + 0.951102 * temp2 * sigma fac2=0.308877 * temp1 
+ * sigma - 0.951102 * temp2 * sigma lef=lr - 1.5e-08 wef=wr + 7e-09 geo_fac=1 / 
+ sqrt(nr * lef * wef * 1e12) vthmisnrf_25=0.00762502 * geo_fac * fac1 * mismatchflag 
+ dlmisnrf_25=0.00261377 * geo_fac * lef * fac2 * mismatchflag dwmisnrf_25= - 0.00261377 
+ * geo_fac * wef * fac2 * mismatchflag toxmisnrf_25=0.00261377 * geo_fac * toxnrf_25 
+ * fac2 * mismatchflag lspace=0.31u ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u 
+ rod=835 rsti=1200 ns=int(nr / 2 + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 
+ 2) * 2) dummyflag=1 sleff=ledge + dummyflag * (ledgeeff - ledge) sreff=ledge + 
+ dummyflag * (ledgeeff - ledge) ldios=(ns - 2) * lspace + sleff + sreff + nodd 
+ * (lspace - sleff) ldiod=(ns - 1) * lspace + nodd * sleff lod=nr * (lr + lspace) 
+ + 2 * ledge - lspace sdiofa=wr * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 
+ - dummyflag) ddiofa=wr * ldiod ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) 
+ sdiogp=wr * nr + (2 - nodd) * wr * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag 
+ sax=1 / (log((ledge + lr / 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) 
+ * (lr + lspace)) / (ledge + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr 
+ * (lr + lspace)) + 1 / (nr * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 
+ + 0.54) / (lr * 1e6 - 0.003) + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * 
+ wr * 1e6 + 0.02906) + 0.11307 * wr * 1e6 + 0.916 * lr * 1e6 + 298.4 * lr / nr 
+ / wr) rsx=(0.0337 * (lr + lspace) * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 
+ 1.68) / (wr * 1e6) rdx=0.01 * (lr + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr 
+ * 1e6 + 1.41) / nd + 0.201 / (0.2 + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 
+ / lr) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * 
+ wr / 12 + rsti * wsti / 2) / ((lod - 2 * ledge + lspace + 3e-6) * (rod * (lod 
+ + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) + wr * (rod * wr / 12 + rsti 
+ * wsti / 2)) rdbx=2.4 + 260 / (wr * nr * 1e6) + 45 / nr cgsx=(0.52 * nr * (lr 
+ + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 
+ * nr * (lr + lspace) * 1e6 + 0.05 * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr 
+ * wr / (lr + lspace) + 1.6 * nr * (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.273e5 
+ / (lr * 1e6) + 8.395e6 rnoiax=0.0353 / (lr * 1e6) + 0.4701 
// *********************
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( sb si ) ndio_rf_25_f area=sdiofa pj=sdiofp
ddd ( db di ) ndio_rf_25_f area=ddiofa pj=ddiofp
dsg ( sb si ) ndio_rf_25_g area=1e-15 pj=sdiogp
ddg ( db di ) ndio_rf_25_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
nmos_rf_25 ( di gi si bi ) nch_rf_25 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax sca=0 
+ scb=0 scc=0
 
model nch_rf_25 bsim4  { 
     1: type=n 
+ lmin=2.8e-007             lmax=5.001e-007           wmin=1.0e-006
+ wmax=10.01e-006           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxnrf_25+toxmisnrf_25)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlnrf_25+dlmisnrf_25)                 xw=7e-09+(dxwnrf_25+dwmisnrf_25)
+ dlc=0+dlcnrf_25           dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.54080508+(dvthnrf_25+vthmisnrf_25)
+ lvth0=7.2996882e-009+dlvthnrf_25                    wvth0=-9.3072744e-009+dwvthnrf_25
+ pvth0=-1.0497976e-014+dpvthnrf_25                   k1=0.3969
+ k2=0.079107675+dk2nrf_25  lk2=-4.3475788e-009+dlk2nrf_25
+ wk2=-2.2045294e-008+dwk2nrf_25                      pk2=9.8855938e-015+dpk2nrf_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.83e-009
+ wkvth0we=-2.999993e-010   pkvth0we=-1.1000041e-016  k2we=0.0040000001
+ lk2we=-4.0759284e-017     wk2we=3.9999984e-010      pk2we=-1.9999956e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00030758564+dcitnrf_25
+ lcit=2.5791371e-010+dlcitnrf_25                     wcit=1.1039722e-009+dwcitnrf_25
+ pcit=-8.5733644e-018+dpcitnrf_25                    voff=-0.096741231
+ lvoff=-6.9937722e-010     wvoff=-3.2610455e-008     pvoff=6.9986522e-015
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-2.0000001e-010
+ wku0we=-8.9999998e-010    pku0we=-5.0000021e-017    u0=0.024873764+du0nrf_25
+ lu0=4.5246017e-009+dlu0nrf_25                       wu0=1.5290522e-009+dwu0nrf_25
+ pu0=-2.2745614e-015+dpu0nrf_25                      ua=-1.395046e-009
+ lua=5.2125004e-017        wua=1.6620133e-016        pua=-5.2489879e-023
+ ub=2.6000557e-018         lub=3.5170704e-025        wub=-5.248463e-027
+ pub=-1.5746964e-031       uc=1.0300908e-010         luc=2.3456252e-017
+ wuc=-8.0651463e-018       puc=-2.3620444e-023       vsat=98400
+ a0=1.3964808              la0=-1.0244687e-007       wa0=-3.8226302e-007
+ pa0=8.7482869e-015        ags=0.47186932            lags=-4.8464047e-008
+ wags=3.0808479e-007       pags=-2.1870783e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.056756985         lketa=-1.3113283e-009     wketa=-1.2438859e-008
+ pketa=1.3122471e-014      dwg=0                     dwb=0
+ pclm=0.61731648           lpclm=-6.5128908e-008     wpclm=-6.0707222e-008
+ ppclm=2.6244939e-014      pdiblc1=0                 pdiblc2=0.0012490413
+ lpdiblc2=-2.6062508e-010  wpdiblc2=-7.190394e-010   ppdiblc2=2.6244938e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgonrf_25            cgdo=cgonrf_25
+ cgbo=0                    cgdl=cglnrf_25            cgsl=cglnrf_25
+ clc=0                     cle=0.6                   cf=cfnrf_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.37847456           lkt1=1.6080071e-008       wkt1=4.0868008e-008
+ pkt1=-2.7994593e-014      kt1l=0                    kt2=-0.067191633
+ lkt2=-1.890216e-009       wkt2=5.5794486e-009       pkt2=1.2136535e-014
+ ute=-1.8068876            lute=1.5663077e-007       wute=6.3025468e-007
+ pute=-2.3821657e-013      ua1=7.4572584e-010        lua1=9.1045476e-017
+ wua1=9.330177e-016        pua1=-2.1733434e-022      ub1=-6.7427997e-019
+ lub1=-4.2260431e-025      wub1=-1.2377067e-024      pub1=4.5176298e-031
+ uc1=1.8276753e-010        luc1=-5.6082156e-017      wuc1=-1.9488123e-016
+ puc1=5.6474737e-023       prt=0                     at=-19241.287
+ lat=0.018249221           wat=0.0495105             pat=-2.6244939e-008
+ fnoimod=1                 tnoimod=1                 noia=noianrf_25
+ noib=noibnrf_25           noic=noicnrf_25           em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=0                   cjswd=0
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=0                  cjswgd=0
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
     } 

// 
model ndio_rf_25_f diode 
+ level=1                   is=1.32e-7                n=1
+ bv=9.2                    ibv=0.03                  isw=6.273e-13
+ cj=cjnrf_25               pj=8.4e-4                 mj=0.31
+ fc=0                      cjsw=cjswnrf_25           area=3.92e-8
+ mjsw=0.105                tlevc=1                   cta=8.5e-4
+ ctp=3e-4                  tbv1=-1*-9.3e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.49
+ vj=0.7                    pta=1.55e-3               tnom=25
+ ptp=1e-3                  ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model ndio_rf_25_g diode 
+ level=1                   is=1.32e-7                n=1
+ bv=9.2                    ibv=0.03                  isw=6.273e-13
+ cj=cjnrf_25               pj=8.4e-4                 mj=0.31
+ fc=0                      cjsw=cjswgnrf_25          area=3.92e-8
+ mjsw=0.56                 tlevc=1                   cta=8.5e-4
+ ctp=1.68e-3               tbv1=-1*-9.3e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=1
+ vj=0.7                    pta=1.55e-3               tnom=25
+ ptp=2.5e-3                ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends nmos_rf_25
// 
inline subckt pmos_rf_25 ( d g s b ) 
parameters lr=0.28e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf_25 temp2=parp2rf_25 
+ fac1=0.955472 * temp1 * sigma + 0.295081 * temp2 * sigma fac2=0.955472 * temp1 
+ * sigma - 0.295081 * temp2 * sigma lef=lr - 1.5e-08 wef=wr + 7e-09 geo_fac=1 / 
+ sqrt(nr * lef * wef * 1e12) vthmisprf_25=0.00615610 * geo_fac * fac1 * mismatchflag 
+ dlmisprf_25=0.00242520 * geo_fac * lef * fac2 * mismatchflag dwmisprf_25= - 0.00242520 
+ * geo_fac * wef * fac2 * mismatchflag toxmisprf_25=0.00242520 * geo_fac * toxprf_25 
+ * fac2 * mismatchflag lspace=0.31u ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u 
+ rod=316 rsti=605 ns=int(nr / 2 + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) 
+ * 2) dummyflag=1 sleff=ledge + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag 
+ * (ledgeeff - ledge) ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace 
+ - sleff) ldiod=(ns - 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge 
+ - lspace sdiofa=wr * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) 
+ ddiofa=wr * ldiod ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr 
+ + (2 - nodd) * wr * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge 
+ + lr / 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / 
+ (ledge + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 
+ 1 / (nr * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 
+ 1e6 - 0.003) + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) 
+ + 0.11307 * wr * 1e6 + 0.916 * lr * 1e6 + 325.8 * lr / nr / wr) rsx=(0.0337 * 
+ (lr + lspace) * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) 
+ rdx=0.01 * (lr + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / 
+ nd + 0.201 / (0.2 + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod 
+ * (lod + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti 
+ * wsti / 2) / ((lod - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 
+ * lspace) / 12 + rsti * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 
+ + 180 / (wr * nr * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 
+ * wr * 1e6 + 1.26) + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) 
+ * 1e6 + 0.05 * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) 
+ + 1.6 * nr * (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.91e6 / (lr * 1e6) 
+ + 2.818e7 rnoiax=0.0064 / (lr * 1e6) + 0.4993 
// *********************
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_25_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_25_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_25_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_25_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf_25 ( di gi si bi ) pch_rf_25 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax sca=0 
+ scb=0 scc=0
 
model pch_rf_25 bsim4  { 
     1: type=p 
+ lmin=2.8e-007             lmax=5.001e-007           wmin=1.0e-006
+ wmax=10.01e-006           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxprf_25+toxmisprf_25)
+ toxm=5.9e-009             dtox=3.946e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlprf_25+dlmisprf_25)                 xw=7e-09+(dxwprf_25+dwmisprf_25)
+ dlc=0+dlcprf_25           dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63687343+(dvthprf_25+vthmisprf_25)
+ lvth0=1.499811e-008+dlvthprf_25                     wvth0=-2.4548517e-008+dwvthprf_25
+ pvth0=7.0707978e-015+dpvthprf_25                    k1=0.7812
+ k2=-0.070814345+dk2rf_25  lk2=-5.666512e-009        wk2=-1.1731268e-008
+ pk2=8.6521989e-015        k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         web=-250
+ wec=-3500                 scref=1e-006              kvth0we=-0.0057000002
+ lkvth0we=-2.4799999e-009  wkvth0we=-2.2000013e-010  pkvth0we=8.7483124e-023
+ k2we=0.012500001          lk2we=-6.000002e-010      wk2we=-1.000013e-010
+ pk2we=-5.9999947e-016     xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-8.0693753e-005+dcitprf_25                      lcit=1.8003009e-010+dlcitprf_25
+ wcit=-8.0939428e-010+dwcitprf_25                    pcit=4.322559e-016+dpcitprf_25
+ voff=-0.15687838          lvoff=4.1252371e-008      wvoff=-6.3205491e-009
+ pvoff=2.5195142e-015      nfactor=0.63002+dnfactorprf_25
+ eta0=0.39239156           weta0=7.6137704e-008      etab=-0.0077622222
+ wetab=-2.2393442e-008     ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.014999998
+ lku0we=-1.0000071e-010    wku0we=-1.200002e-009     pku0we=8.748313e-022
+ u0=0.017107818+du0prf_25  lu0=-1.0435375e-009+dlu0prf_25
+ wu0=-7.8726945e-012+dwu0prf_25                      pu0=4.3741566e-017+dpu0prf_25
+ ua=2.6580301e-009         lua=-6.0699744e-016       wua=-5.1968007e-016
+ pua=1.3909818e-023        ub=-4.2391949e-020        lub=5.9389132e-025
+ wub=2.2127542e-025        pub=-2.993664e-033        uc=1.0231614e-010
+ luc=7.6407415e-018        wuc=-7.8387521e-018       puc=-1.1565271e-023
+ vsat=110000+dvsatprf_25   a0=1.126991               la0=-1.3958757e-007+dla0prf_25
+ wa0=-5.308413e-007+dwa0prf_25                       pa0=2.5015496e-013+dpa0prf_25
+ ags=0.055509929           lags=3.9889717e-007       wags=2.3672255e-007
+ pags=-1.590125e-013       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.069239834
+ lketa=-2.0450595e-009     wketa=7.8084883e-009      pketa=2.0908468e-015
+ dwg=0                     dwb=0                     pclm=0.30705568
+ lpclm=1.1161686e-007      wpclm=1.1685458e-007      ppclm=-8.0045385e-014
+ pdiblc1=0                 pdiblc2=1.0002551e-005    lpdiblc2=-1.7476574e-015
+ wpdiblc2=-2.554252e-014   ppdiblc2=1.7496626e-020   pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgoprf_25            cgdo=cgoprf_25            cgbo=0
+ cgdl=cglprf_25            cgsl=cglprf_25            clc=0
+ cle=0.6                   cf=cfprf_25               ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.29394346           lkt1=-2.4698728e-008
+ wkt1=-1.8390627e-008      pkt1=1.259758e-014        kt1l=0
+ kt2=-0.0085048726         lkt2=-1.349786e-008       wkt2=-3.247399e-008
+ pkt2=9.973077e-015        ute=-1                    ua1=2.76e-009
+ ub1=-4.5426131e-018       lub1=-9.5930616e-026      wub1=8.07602e-025
+ pub1=-1.2370115e-031      uc1=-2.2935105e-010       luc1=7.1226561e-017
+ wuc1=1.3548031e-016       puc1=-5.59892e-023        prt=0
+ at=195341.79              lat=-0.055556248          wat=-0.012176432
+ pat=-6.9986514e-009       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=0                   cjswd=0
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=0                  cjswgd=0
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorprf_25                          wnfactor=0+dwnfactorprf_25
+ pnfactor=0+dpnfactorprf_25                          lvsat=0+dlvsatprf_25
+ wvsat=0+dwvsatprf_25      pvsat=0+dpvsatprf_25      leta0=0+dleta0prf_25
+ peta0=0+dpeta0prf_25      fnoimod=1                 noia=noiaprf_25
+ noib=noibprf_25           noic=noicprf_25           em=3e+7                
+ ef=1.15           tnoimod=1                 rnoib=0
+ rnoia=rnoiax              tnoia=tnoiax              minr=1e-3
 
     }  
 
// 
model pdio_rf_25_f diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_25               pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswprf_25           area=3.92e-8
+ mjsw=0.085                tlevc=1                   cta=8.5e-4
+ ctp=3e-4                  tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=1.55e-3               tnom=25
+ ptp=1e-3                  ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_25_g diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_25               pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswgprf_25          area=3.92e-8
+ mjsw=0.5                  tlevc=1                   cta=8.5e-4
+ ctp=1.55e-3               tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.9
+ vj=0.7                    pta=1.55e-3               tnom=25
+ ptp=1.34e-3               ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf_25
// 
inline subckt pmos_rf_25_nw ( d g s b ) 
parameters lr=0.28e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf_25 temp2=parp2rf_25 
+ fac1=0.955472 * temp1 * sigma + 0.295081 * temp2 * sigma fac2=0.955472 * temp1 
+ * sigma - 0.295081 * temp2 * sigma lef=lr - 1.5e-08 wef=wr + 7e-09 geo_fac=1 / 
+ sqrt(nr * lef * wef * 1e12) vthmisprf_25=0.00615610 * geo_fac * fac1 * mismatchflag 
+ dlmisprf_25=0.00242520 * geo_fac * lef * fac2 * mismatchflag dwmisprf_25= - 0.00242520 
+ * geo_fac * wef * fac2 * mismatchflag toxmisprf_25=0.00242520 * geo_fac * toxprf_25 
+ * fac2 * mismatchflag lspace=0.31u ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u 
+ rod=316 rsti=605 ns=int(nr / 2 + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) 
+ * 2) dummyflag=1 sleff=ledge + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag 
+ * (ledgeeff - ledge) ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace 
+ - sleff) ldiod=(ns - 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge 
+ - lspace sdiofa=wr * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) 
+ ddiofa=wr * ldiod ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr 
+ + (2 - nodd) * wr * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge 
+ + lr / 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / 
+ (ledge + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 
+ 1 / (nr * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 
+ 1e6 - 0.003) + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) 
+ + 0.11307 * wr * 1e6 + 0.916 * lr * 1e6 + 325.8 * lr / nr / wr) rsx=(0.0337 * 
+ (lr + lspace) * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) 
+ rdx=0.01 * (lr + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / 
+ nd + 0.201 / (0.2 + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod 
+ * (lod + 4 * ledge - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti 
+ * wsti / 2) / ((lod - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 
+ * lspace) / 12 + rsti * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 
+ + 180 / (wr * nr * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 
+ * wr * 1e6 + 1.26) + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) 
+ * 1e6 + 0.05 * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) 
+ + 1.6 * nr * (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.91e6 / (lr * 1e6) 
+ + 2.818e7 rnoiax=0.0064 / (lr * 1e6) + 0.4993 
// *********************
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_25_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_25_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_25_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_25_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf_25_nw ( di gi si bi ) pch_rf_25 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax sca=0 
+ scb=0 scc=0
 
model pch_rf_25 bsim4  { 
     1: type=p 
+ lmin=2.8e-007             lmax=5.001e-007           wmin=1.0e-006
+ wmax=10.01e-006           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxprf_25+toxmisprf_25)
+ toxm=5.9e-009             dtox=3.946e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlprf_25+dlmisprf_25)                 xw=7e-09+(dxwprf_25+dwmisprf_25)
+ dlc=0+dlcprf_25           dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.63687343+(dvthprf_25+vthmisprf_25)
+ lvth0=1.499811e-008+dlvthprf_25                     wvth0=-2.4548517e-008+dwvthprf_25
+ pvth0=7.0707978e-015+dpvthprf_25                    k1=0.7812
+ k2=-0.070814345+dk2rf_25  lk2=-5.666512e-009        wk2=-1.1731268e-008
+ pk2=8.6521989e-015        k3=-3.442                 k3b=3
+ w0=0                      dvt0=6.767                dvt1=0.2284
+ dvt2=0.000377             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.288                minv=0
+ voffl=-2.31e-009          dvtp0=0                   dvtp1=4.55
+ lpe0=0                    lpeb=4.44089e-021         web=-250
+ wec=-3500                 scref=1e-006              kvth0we=-0.0057000002
+ lkvth0we=-2.4799999e-009  wkvth0we=-2.2000013e-010  pkvth0we=8.7483124e-023
+ k2we=0.012500001          lk2we=-6.000002e-010      wk2we=-1.000013e-010
+ pk2we=-5.9999947e-016     xj=9.5e-008               ngate=1.842e+020
+ ndep=7.81e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-8.0693753e-005+dcitprf_25                      lcit=1.8003009e-010+dlcitprf_25
+ wcit=-8.0939428e-010+dwcitprf_25                    pcit=4.322559e-016+dpcitprf_25
+ voff=-0.15687838          lvoff=4.1252371e-008      wvoff=-6.3205491e-009
+ pvoff=2.5195142e-015      nfactor=0.63002+dnfactorprf_25
+ eta0=0.39239156           weta0=7.6137704e-008      etab=-0.0077622222
+ wetab=-2.2393442e-008     ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.014999998
+ lku0we=-1.0000071e-010    wku0we=-1.200002e-009     pku0we=8.748313e-022
+ u0=0.017107818+du0prf_25  lu0=-1.0435375e-009+dlu0prf_25
+ wu0=-7.8726945e-012+dwu0prf_25                      pu0=4.3741566e-017+dpu0prf_25
+ ua=2.6580301e-009         lua=-6.0699744e-016       wua=-5.1968007e-016
+ pua=1.3909818e-023        ub=-4.2391949e-020        lub=5.9389132e-025
+ wub=2.2127542e-025        pub=-2.993664e-033        uc=1.0231614e-010
+ luc=7.6407415e-018        wuc=-7.8387521e-018       puc=-1.1565271e-023
+ vsat=110000+dvsatprf_25   a0=1.126991               la0=-1.3958757e-007+dla0prf_25
+ wa0=-5.308413e-007+dwa0prf_25                       pa0=2.5015496e-013+dpa0prf_25
+ ags=0.055509929           lags=3.9889717e-007       wags=2.3672255e-007
+ pags=-1.590125e-013       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.069239834
+ lketa=-2.0450595e-009     wketa=7.8084883e-009      pketa=2.0908468e-015
+ dwg=0                     dwb=0                     pclm=0.30705568
+ lpclm=1.1161686e-007      wpclm=1.1685458e-007      ppclm=-8.0045385e-014
+ pdiblc1=0                 pdiblc2=1.0002551e-005    lpdiblc2=-1.7476574e-015
+ wpdiblc2=-2.554252e-014   ppdiblc2=1.7496626e-020   pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgoprf_25            cgdo=cgoprf_25            cgbo=0
+ cgdl=cglprf_25            cgsl=cglprf_25            clc=0
+ cle=0.6                   cf=cfprf_25               ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.29394346           lkt1=-2.4698728e-008
+ wkt1=-1.8390627e-008      pkt1=1.259758e-014        kt1l=0
+ kt2=-0.0085048726         lkt2=-1.349786e-008       wkt2=-3.247399e-008
+ pkt2=9.973077e-015        ute=-1                    ua1=2.76e-009
+ ub1=-4.5426131e-018       lub1=-9.5930616e-026      wub1=8.07602e-025
+ pub1=-1.2370115e-031      uc1=-2.2935105e-010       luc1=7.1226561e-017
+ wuc1=1.3548031e-016       puc1=-5.59892e-023        prt=0
+ at=195341.79              lat=-0.055556248          wat=-0.012176432
+ pat=-6.9986514e-009       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=0                   cjswd=0
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=0                  cjswgd=0
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorprf_25                          wnfactor=0+dwnfactorprf_25
+ pnfactor=0+dpnfactorprf_25                          lvsat=0+dlvsatprf_25
+ wvsat=0+dwvsatprf_25      pvsat=0+dpvsatprf_25      leta0=0+dleta0prf_25
+ peta0=0+dpeta0prf_25      fnoimod=1                 noia=noiaprf_25
+ noib=noibprf_25           noic=noicprf_25           em=3e+7                
+ ef=1.15           tnoimod=1                 rnoib=0
+ rnoia=rnoiax              tnoia=tnoiax              minr=1e-3
 
     }  
 
// 
model pdio_rf_25_f diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_25               pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswprf_25           area=3.92e-8
+ mjsw=0.085                tlevc=1                   cta=8.5e-4
+ ctp=3e-4                  tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=1.55e-3               tnom=25
+ ptp=1e-3                  ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_25_g diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_25               pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswgprf_25          area=3.92e-8
+ mjsw=0.5                  tlevc=1                   cta=8.5e-4
+ ctp=1.55e-3               tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.9
+ vj=0.7                    pta=1.55e-3               tnom=25
+ ptp=1.34e-3               ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf_25_nw
// 
endsection rf_mos_25
 
// *************************************************************************************************
// 
//  3.3V IO MOS MODEL
// 
// 
// 
//               .lib RF_MOS_25od33
// 
//               Model name               nr               lr (um)           wr (um)
//                                    low   high        low     high     low   high
//             -------------------------------------------------------------------
//               nmos_rf_33        1     32         0.5    0.7     1.0     10.0
//             -------------------------------------------------------------------
//               pmos_rf_33        1     32         0.4    0.7     1.0     10.0
//             -------------------------------------------------------------------
//               pmos_rf_33_nw     1     32         0.4    0.7     1.0     10.0
//             -------------------------------------------------------------------
//             **nr: Finger number
//             **wr: Width per finger
// 
// *************************************************************************************************

section rf_mos_33
 
inline subckt nmos_rf_33 ( d g s b ) 
parameters lr=0.50e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parn1rf_33 
+ temp2=parn2rf_33 fac1=0.308877 * temp1 * sigma + 0.951102 * temp2 * sigma 
+ fac2=0.308877 * temp1 * sigma - 0.951102 * temp2 * sigma lef=lr - 1.5e-08 wef=wr 
+ + 7e-09 geo_fac=1 / sqrt(nr * lef * wef * 1e12) vthmisnrf_33=0.00762502 * 
+ geo_fac * fac1 * mismatchflag dlmisnrf_33=0.00261377 * geo_fac * lef * fac2 
+ * mismatchflag dwmisnrf_33= - 0.00261377 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisnrf_33=0.00261377 * geo_fac * toxnrf_33 * fac2 * mismatchflag lspace=0.31u 
+ ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u rod=835 rsti=1200 ns=int(nr / 2 
+ + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) * 2) dummyflag=1 sleff=ledge 
+ + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag * (ledgeeff - ledge) 
+ ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace - sleff) ldiod=(ns - 
+ 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge - lspace sdiofa=wr 
+ * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) ddiofa=wr * ldiod 
+ ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr + (2 - nodd) * wr 
+ * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge + lr / 
+ 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / (ledge 
+ + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 1 / (nr 
+ * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 1e6 - 0.003) 
+ + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) + 0.11307 
+ * wr * 1e6 + 0.916 * lr * 1e6 + 298.4 * lr / nr / wr) rsx=(0.0337 * (lr + lspace) 
+ * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) rdx=0.01 * (lr 
+ + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / nd + 0.201 / (0.2 
+ + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod * (lod + 4 * ledge 
+ - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti * wsti / 2) / ((lod 
+ - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti 
+ * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=2.4 + 260 / (wr * nr 
+ * 1e6) + 45 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) 
+ + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) * 1e6 + 0.05 
+ * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) + 1.6 * nr * 
+ (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.273e5 / (lr * 1e6) + 8.395e6 rnoiax=0.0353 
+ / (lr * 1e6) + 0.4701 
// *********************
 
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( sb si ) ndio_rf_33_f area=sdiofa pj=sdiofp
ddd ( db di ) ndio_rf_33_f area=ddiofa pj=ddiofp
dsg ( sb si ) ndio_rf_33_g area=1e-15 pj=sdiogp
ddg ( db di ) ndio_rf_33_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
nmos_rf_33 ( di gi si bi ) nch_rf_33 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax 
+ sca=0 scb=0 scc=0
 
model nch_rf_33 bsim4  { 
     1: type=n 
+ lmin=5.0e-007             lmax=7.001e-007           wmin=1.0e-006
+ wmax=10.01e-006           version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=0                permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=(toxnrf_33+toxmisnrf_33)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxlnrf_33+dlmisnrf_33)         xw=7e-09+(dxwnrf_33+dwmisnrf_33)
+ dlc=0                     dwc=0                     xpart=0
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.51835546+(dvthnrf_33+vthmisnrf_33)
+ lvth0=2.8030349e-009+dlvthnrf_33                wvth0=1.3299478e-008+dwvthnrf_33
+ pvth0=-5.9698404e-015+dpvthnrf_33               k1=0.3969
+ k2=0.053813106+dk2nrf_33                        lk2=5.8249963e-009+dlk2nrf_33
+ wk2=3.4263363e-009+dwk2nrf_33                   pk2=-3.581889e-016+dpk2nrf_33
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0

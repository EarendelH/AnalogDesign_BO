+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.014999997       lkvth0we=5.830002e-009
+ wkvth0we=-2.9999738e-010  pkvth0we=-1.1000167e-016  k2we=0.0039999993
+ lk2we=3.8911854e-016      wk2we=4.0000061e-010      pk2we=-2.0000327e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00017598793+dcitnrf_33
+ lcit=5.9822311e-010+dlcitnrf_33                 wcit=6.1701358e-010+dwcitnrf_33
+ pcit=-3.512649e-016+dpcitnrf_33                 voff=-0.12867452
+ lvoff=1.2178973e-008      wvoff=-4.5363959e-010     pvoff=-5.9698404e-015
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0019999998       lku0we=-2.0000011e-010
+ wku0we=-9.0000013e-010    pku0we=-4.9999929e-017    u0=0.022366067+du0nrf_33
+ lu0=4.4000517e-009+dlu0nrf_33                   wu0=4.0543019e-009+dwu0nrf_33
+ pu0=-2.1491385e-015+dpu0nrf_33                  ua=-1.23e-009
+ ub=2.2702412e-018         lub=3.9689504e-025        wub=3.2687481e-025
+ pub=-2.0297396e-031       uc=1.1366521e-010         luc=1.9190146e-023
+ wuc=-1.8795893e-017       puc=-7.6152066e-030       vsat=98400
+ a0=1.0519669              la0=4.852062e-008         wa0=-3.5337596e-008
+ pa0=-1.4327589e-013       ags=0.38184035            lags=-4.8055152e-009
+ wags=3.9874398e-007       pags=-2.6267199e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.032523443         lketa=-6.0650332e-009     wketa=-3.6842038e-008
+ pketa=1.7909453e-014      dwg=0                     dwb=0
+ pclm=0.79746027           lpclm=-1.102064e-007      wpclm=-2.42112e-007
+ ppclm=7.1637957e-014      pdiblc1=0                 pdiblc2=0.00053500043
+ lpdiblc2=-1.9306425e-016  wpdiblc2=-3.9692982e-016  ppdiblc2=1.7768818e-022
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgonrf_33        cgdo=cgonrf_33
+ cgbo=0                    cgdl=cglnrf_33        cgsl=cglnrf_33
+ clc=0                     cle=0.6                   cf=cfnrf_33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.3081728            lkt1=-2.8105798e-008      wkt1=-2.9925867e-008
+ pkt1=1.6500581e-014       kt1l=0                    kt2=-0.1044547
+ lkt2=2.8666642e-008       wkt2=4.3103358e-008       pkt2=-1.863422e-014
+ ute=-0.67163211           lute=-3.2251693e-007      wute=-5.1294765e-007
+ pute=2.4428519e-013       ua1=1.8796597e-009        lua1=-2.2994657e-016
+ wua1=-2.0885374e-016      pua1=1.0590469e-022       ub1=-1.7803663e-018
+ lub1=4.5700691e-026       wub1=-1.238778e-025       pub1=-1.9820101e-032
+ uc1=-1.4350137e-010       luc1=7.2288646e-017       wuc1=1.3367155e-016
+ puc1=-7.2794656e-023      prt=0                     at=47234.039
+ lat=-0.019669935          wat=-0.017430155          pat=1.1939653e-008
+ fnoimod=1                 tnoimod=1                 noia=noianrf_33
+ noib=noibnrf_33       noic=noicnrf_33       em=1.12e+8
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=0                   cjswd=0
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=0                  cjswgd=0
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.01163u             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=1e-006               kvth0=-3.5e-008           lkvth0=2.5e-006
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-009             lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-008             lku0=7e-007
+ wku0=2.08e-006            pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-009
+ tku0=0                    rnoib=0                   rnoia=rnoiax
+ tnoia=tnoiax              minr=1e-3
 
     } 

// 
model ndio_rf_33_f diode 
+ level=1                   is=1.32e-07               n=1
+ bv=9.2                    ibv=0.03                  isw=6.273e-13
+ cj=cjnrf_33           pj=8.4e-4                 mj=0.31
+ fc=0                      cjsw=cjswnrf_33       area=3.92e-8
+ mjsw=0.105                tlevc=1                   cta=0.00085
+ ctp=0.0003                tbv1=-1*-9.3e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.49
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.001                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model ndio_rf_33_g diode 
+ level=1                   is=1.32e-07               n=1
+ bv=9.2                    ibv=0.03                  isw=6.273e-13
+ cj=cjnrf_33           pj=8.4e-4                 mj=0.31
+ fc=0                      cjsw=cjswgnrf_33      area=3.92e-8
+ mjsw=0.56                 tlevc=1                   cta=0.00085
+ ctp=0.00168               tbv1=-1*-9.3e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=1
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.0025                ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends nmos_rf_33
// 
inline subckt pmos_rf_33 ( d g s b ) 
parameters lr=0.40e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf_33 
+ temp2=parp2rf_33 fac1=0.955472 * temp1 * sigma + 0.295081 * temp2 * sigma 
+ fac2=0.955472 * temp1 * sigma - 0.295081 * temp2 * sigma lef=lr - 1.5e-08 wef=wr 
+ + 7e-09 geo_fac=1 / sqrt(nr * lef * wef * 1e12) vthmisprf_33=0.00615610 * 
+ geo_fac * fac1 * mismatchflag dlmisprf_33=0.00242520 * geo_fac * lef * fac2 
+ * mismatchflag dwmisprf_33= - 0.00242520 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisprf_33=0.00242520 * geo_fac * toxprf_33 * fac2 * mismatchflag lspace=0.31u 
+ ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u rod=316 rsti=605 ns=int(nr / 2 
+ + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) * 2) dummyflag=1 sleff=ledge 
+ + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag * (ledgeeff - ledge) 
+ ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace - sleff) ldiod=(ns - 
+ 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge - lspace sdiofa=wr 
+ * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) ddiofa=wr * ldiod 
+ ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr + (2 - nodd) * wr 
+ * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge + lr / 
+ 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / (ledge 
+ + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 1 / (nr 
+ * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 1e6 - 0.003) 
+ + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) + 0.11307 
+ * wr * 1e6 + 0.916 * lr * 1e6 + 325.8 * lr / nr / wr) rsx=(0.0337 * (lr + lspace) 
+ * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) rdx=0.01 * (lr 
+ + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / nd + 0.201 / (0.2 
+ + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod * (lod + 4 * ledge 
+ - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti * wsti / 2) / ((lod 
+ - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti 
+ * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 + 180 / (wr * nr 
+ * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) 
+ + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) * 1e6 + 0.05 
+ * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) + 1.6 * nr * 
+ (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.91e6 / (lr * 1e6) + 2.818e7 rnoiax=0.0064 
+ / (lr * 1e6) + 0.4993 
// *********************
 
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_33_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_33_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_33_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_33_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf_33 ( di gi si bi ) pch_rf_33 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax 
+ sca=0 scb=0 scc=0
 
model pch_rf_33 bsim4  { 
     1: type=p 
+ lmin=4.0e-007             lmax=7.001e-007           wmin=1.0e-006
+ wmax=10.01e-006           xl=-1.5e-08+(dxlprf_33+dlmisprf_33)
+ xw=7e-09+(dxwprf_33+dwmisprf_33)            version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxprf_33+toxmisprf_33)
+ toxm=5.9e-09              dtox=3.946e-10            epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ dlc=0                     dwc=0                     xpart=0
+ toxref=3e-09              dlcig=2.5e-09             vth0=-0.68556017+(dvthprf_33+vthmisprf_33)
+ lvth0=4.5214208e-08+dlvthprf_33                 wvth0=2.4479033e-08+dwvthprf_33
+ pvth0=-2.3356815e-14+dpvthprf_33                k1=0.7812
+ k2=-0.092633649+dk2rf_33                        lk2=5.9893104e-09+dlk2rf_33
+ wk2=1.0240771e-08+dwk2rf_33                     pk2=-3.0852141e-15+dpk2rf_33
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-09
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-21          web=-250                  wec=-3500
+ scref=1e-06               kvth0we=-0.0057000009     lkvth0we=-2.4799993e-09
+ wkvth0we=-2.1999934e-10   pkvth0we=-5.373388e-22    k2we=0.0125
+ lk2we=-5.9999983e-10      wk2we=-1.0000025e-10      pk2we=-5.999999e-16
+ xj=9.5e-08                ngate=1.842e+20           ndep=7.81e+17
+ nsd=1e+20                 phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0010061472+dcitprf_33
+ lcit=6.9263584e-10+dlcitprf_33                  wcit=1.2253733e-10+dwcitprf_33
+ pcit=-8.393807e-17+dpcitprf_33                  voff=-0.19417457
+ lvoff=6.4337516e-08       wvoff=3.1236727e-08       pvoff=-2.0727229e-14
+ nfactor=0.63002+dnfactorprf_33                  lnfactor=0+dlnfactorprf_33
+ wnfactor=0+dwnfactorprf_33                      pnfactor=0+dpnfactorprf_33
+ eta0=0.556015             leta0=0+dleta0prf_33  weta0=-8.8631105e-08
+ peta0=0+dpeta0prf_33  etab=-0.0224125           wetab=-7.6406125e-09
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015000001        lku0we=-1.0000013e-10
+ wku0we=-1.1999995e-09     pku0we=-2.5043595e-29     u0=0.020204235+du0prf_33
+ lu0=-3.3240033e-09+dlu0prf_33                   wu0=-3.1259647e-09+dwu0prf_33
+ pu0=2.340171e-15+dpu0prf_33                     ua=3.4743084e-09
+ lua=-1.2979439e-15        wua=-1.3416722e-15        pua=7.096928e-22
+ ub=-4.5604274e-19         lub=9.4578823e-25         wub=6.3782171e-25
+ pub=-3.5735382e-31        uc=4.1168227e-11          luc=2.4830651e-17
+ wuc=5.37372e-17           puc=-2.8875512e-23        vsat=110000+dvsatprf_33
+ lvsat=0+dlvsatprf_33  wvsat=0+dwvsatprf_33  pvsat=0+dpvsatprf_33
+ a0=-0.18593711            la0=4.6747626e-07+dla0prf_33
+ wa0=7.9127733e-07+dwa0prf_33                    pa0=-3.6115831e-13+dpa0prf_33
+ ags=0.47416521            lags=1.3093227e-07        wags=-1.8486332e-07
+ pags=1.1082817e-13        a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.16312009
+ lketa=3.6719899e-08       wketa=7.0037991e-08       pketa=-1.4814544e-14
+ dwg=0                     dwb=0                     pclm=0.72441341
+ lpclm=-1.7427318e-07      wpclm=-3.0342467e-07      ppclm=2.078459e-13
+ pdiblc1=0                 pdiblc2=9.9598752e-06     lpdiblc2=2.748547e-14
+ wpdiblc2=1.7432134e-14    ppdiblc2=-1.1941012e-20   pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+08          pscbe2=1e-20              fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-07           alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-09
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgoprf_33        cgdo=cgoprf_33        cgbo=0
+ cgdl=cglprf_33        cgsl=cglprf_33        clc=0
+ cle=0.6                   cf=cfprf_33           ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.31220625           lkt1=-1.2188719e-08
+ kt1l=0                    kt2=-0.036252785          lkt2=-6.6768413e-09
+ wkt2=-4.5318425e-09       pkt2=3.1043111e-15        ute=-1
+ ua1=2.6585229e-09         lua1=-6.8199474e-17       wua1=1.0218746e-16
+ pua1=6.867687e-23         ub1=-3.7406251e-18        lub1=-2.1877184e-25
+ uc1=4.8045864e-11         luc1=-6.1441675e-17       wuc1=-1.4385838e-16
+ puc1=7.7607715e-23        prt=0                     at=222230.68
+ lat=-0.076734189          wat=-0.039253567          pat=1.4327546e-08
+ fnoimod=1                 tnoimod=1                 noia=noiaprf_33
+ noib=noibprf_33       noic=noicprf_33       em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=0                   cjswd=0
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=0                  cjswgd=0
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-08         jtsswgd=2.148e-08
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-08             dmci=9.25e-08             dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.00656u             rshg=15.882               gbmin=1e-12
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-07             sbref=4.6e-07             wlod=0
+ kvth0=1.1e-09             lkvth0=-1.5e-07           wkvth0=3e-07
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-09               lku0=1.5e-08              wku0=1.1e-06
+ pku0=2e-15                llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-09              tku0=0
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
     }  
 
// 
model pdio_rf_33_f diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_33           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswprf_33       area=3.92e-8
+ mjsw=0.085                tlevc=1                   cta=0.00085
+ ctp=0.0003                tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.001                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_33_g diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_33           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswgprf_33      area=3.92e-8
+ mjsw=0.5                  tlevc=1                   cta=0.00085
+ ctp=0.00155               tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.9
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.00134               ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf_33
// 
inline subckt pmos_rf_33_nw ( d g s b ) 
parameters lr=0.40e-6 wr=1.0e-6 nr=4 mismatchflag=0 sigma=1 temp1=parp1rf_33 
+ temp2=parp2rf_33 fac1=0.955472 * temp1 * sigma + 0.295081 * temp2 * sigma 
+ fac2=0.955472 * temp1 * sigma - 0.295081 * temp2 * sigma lef=lr - 1.5e-08 wef=wr 
+ + 7e-09 geo_fac=1 / sqrt(nr * lef * wef * 1e12) vthmisprf_33=0.00615610 * 
+ geo_fac * fac1 * mismatchflag dlmisprf_33=0.00242520 * geo_fac * lef * fac2 
+ * mismatchflag dwmisprf_33= - 0.00242520 * geo_fac * wef * fac2 * mismatchflag 
+ toxmisprf_33=0.00242520 * geo_fac * toxprf_33 * fac2 * mismatchflag lspace=0.31u 
+ ledge=0.73u ledgeeff=0.31u lsti=0.5u wsti=1.0u rod=316 rsti=605 ns=int(nr / 2 
+ + 1) nd=int((nr + 1) / 2) nodd=(nr - int(nr / 2) * 2) dummyflag=1 sleff=ledge 
+ + dummyflag * (ledgeeff - ledge) sreff=ledge + dummyflag * (ledgeeff - ledge) 
+ ldios=(ns - 2) * lspace + sleff + sreff + nodd * (lspace - sleff) ldiod=(ns - 
+ 1) * lspace + nodd * sleff lod=nr * (lr + lspace) + 2 * ledge - lspace sdiofa=wr 
+ * ldios sdiofp=2 * ldios + (2 - nodd) * wr * (1 - dummyflag) ddiofa=wr * ldiod 
+ ddiofp=2 * ldiod + nodd * wr * (1 - dummyflag) sdiogp=wr * nr + (2 - nodd) * wr 
+ * dummyflag ddiogp=wr * nr + nodd * wr * dummyflag sax=1 / (log((ledge + lr / 
+ 2 + nr * (lr + lspace)) * (ledge + lr / 2 + (nr - 1) * (lr + lspace)) / (ledge 
+ + lspace + 3 * lr / 2) / (ledge + lr / 2)) / (2 * nr * (lr + lspace)) + 1 / (nr 
+ * (ledge + lr / 2))) - lr / 2 rgx=((1.333 * (wr * 1e6 + 0.54) / (lr * 1e6 - 0.003) 
+ + 61.5 * lr * 1e6 + 8.53) / nr + nr * (0.00150 * wr * 1e6 + 0.02906) + 0.11307 
+ * wr * 1e6 + 0.916 * lr * 1e6 + 325.8 * lr / nr / wr) rsx=(0.0337 * (lr + lspace) 
+ * 1e6 * (2 * ns + 1 / ns - 3) + 4.056 / ns + 1.68) / (wr * 1e6) rdx=0.01 * (lr 
+ + lspace) * 1e6 * (nd + 2 / nd) + 0.2687 * (wr * 1e6 + 1.41) / nd + 0.201 / (0.2 
+ + (nd - 1) * (lr + lspace) * 1e6) rbx=(1 + 1e-8 / lr) * (rod * (lod + 4 * ledge 
+ - 2 * lspace) / 12 + rsti * lsti / 2) * (rod * wr / 12 + rsti * wsti / 2) / ((lod 
+ - 2 * ledge + lspace + 3e-6) * (rod * (lod + 4 * ledge - 2 * lspace) / 12 + rsti 
+ * lsti / 2) + wr * (rod * wr / 12 + rsti * wsti / 2)) rdbx=0.4 + 180 / (wr * nr 
+ * 1e6) + 28 / nr cgsx=(0.52 * nr * (lr + lspace) * 1e6 / (0.022 * wr * 1e6 + 1.26) 
+ + 0.27 * wr * 1e6 + 0.1) * 1e-15 cgdx=(0.15 * nr * (lr + lspace) * 1e6 + 0.05 
+ * nr + 0.1) * 1e-15 cdsx=(0.1 + 0.0455 * nr * wr / (lr + lspace) + 1.6 * nr * 
+ (lr + lspace) / (wr + 9.8e-6)) * 1e-15 tnoiax=1.91e6 / (lr * 1e6) + 2.818e7 rnoiax=0.0064 
+ / (lr * 1e6) + 0.4993 
// *********************
 
// *********************
rg ( g gi ) resistor r=rgx
rs ( s si ) resistor r=rsx
rd ( d di ) resistor r=rdx
// *********************
cgs_m ( gi si ) capacitor c=cgsx
cgd_m ( gi di ) capacitor c=cgdx
cds_m ( di si ) capacitor c=cdsx
// **** Diodes  ****************
dss ( si sb ) pdio_rf_33_f area=sdiofa pj=sdiofp
ddd ( di db ) pdio_rf_33_f area=ddiofa pj=ddiofp
dsg ( si sb ) pdio_rf_33_g area=1e-15 pj=sdiogp
ddg ( di db ) pdio_rf_33_g area=1e-15 pj=ddiogp
// ****************************************************************************
rb ( b bi ) resistor r=rbx
rdb ( db bi ) resistor r=rdbx
rsb ( sb bi ) resistor r=rdbx
 
pmos_rf_33_nw ( di gi si bi ) pch_rf_33 l=lr w=wr m=nr ad=0 as=0 pd=0 ps=0 sa=sax sb=sax 
+ sca=0 scb=0 scc=0
 
model pch_rf_33 bsim4  { 
     1: type=p 
+ lmin=4.0e-007             lmax=7.001e-007           wmin=1.0e-006
+ wmax=10.01e-006           xl=-1.5e-08+(dxlprf_33+dlmisprf_33)
+ xw=7e-09+(dxwprf_33+dwmisprf_33)            version=4.5
+ rgeomod=1                 binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=0
+ igbmod=0                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=0                permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ wpemod=1                  tnom=25                   toxe=(toxprf_33+toxmisprf_33)
+ toxm=5.9e-09              dtox=3.946e-10            epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ dlc=0                     dwc=0                     xpart=0
+ toxref=3e-09              dlcig=2.5e-09             vth0=-0.68556017+(dvthprf_33+vthmisprf_33)
+ lvth0=4.5214208e-08+dlvthprf_33                 wvth0=2.4479033e-08+dwvthprf_33
+ pvth0=-2.3356815e-14+dpvthprf_33                k1=0.7812
+ k2=-0.092633649+dk2rf_33                        lk2=5.9893104e-09+dlk2rf_33
+ wk2=1.0240771e-08+dwk2rf_33                     pk2=-3.0852141e-15+dpk2rf_33
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-09
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-21          web=-250                  wec=-3500
+ scref=1e-06               kvth0we=-0.0057000009     lkvth0we=-2.4799993e-09
+ wkvth0we=-2.1999934e-10   pkvth0we=-5.373388e-22    k2we=0.0125
+ lk2we=-5.9999983e-10      wk2we=-1.0000025e-10      pk2we=-5.999999e-16
+ xj=9.5e-08                ngate=1.842e+20           ndep=7.81e+17
+ nsd=1e+20                 phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0010061472+dcitprf_33
+ lcit=6.9263584e-10+dlcitprf_33                  wcit=1.2253733e-10+dwcitprf_33
+ pcit=-8.393807e-17+dpcitprf_33                  voff=-0.19417457
+ lvoff=6.4337516e-08       wvoff=3.1236727e-08       pvoff=-2.0727229e-14
+ nfactor=0.63002+dnfactorprf_33                  lnfactor=0+dlnfactorprf_33
+ wnfactor=0+dwnfactorprf_33                      pnfactor=0+dpnfactorprf_33
+ eta0=0.556015             leta0=0+dleta0prf_33  weta0=-8.8631105e-08
+ peta0=0+dpeta0prf_33  etab=-0.0224125           wetab=-7.6406125e-09
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015000001        lku0we=-1.0000013e-10
+ wku0we=-1.1999995e-09     pku0we=-2.5043595e-29     u0=0.020204235+du0prf_33
+ lu0=-3.3240033e-09+dlu0prf_33                   wu0=-3.1259647e-09+dwu0prf_33
+ pu0=2.340171e-15+dpu0prf_33                     ua=3.4743084e-09
+ lua=-1.2979439e-15        wua=-1.3416722e-15        pua=7.096928e-22
+ ub=-4.5604274e-19         lub=9.4578823e-25         wub=6.3782171e-25
+ pub=-3.5735382e-31        uc=4.1168227e-11          luc=2.4830651e-17
+ wuc=5.37372e-17           puc=-2.8875512e-23        vsat=110000+dvsatprf_33
+ lvsat=0+dlvsatprf_33  wvsat=0+dwvsatprf_33  pvsat=0+dpvsatprf_33
+ a0=-0.18593711            la0=4.6747626e-07+dla0prf_33
+ wa0=7.9127733e-07+dwa0prf_33                    pa0=-3.6115831e-13+dpa0prf_33
+ ags=0.47416521            lags=1.3093227e-07        wags=-1.8486332e-07
+ pags=1.1082817e-13        a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.16312009
+ lketa=3.6719899e-08       wketa=7.0037991e-08       pketa=-1.4814544e-14
+ dwg=0                     dwb=0                     pclm=0.72441341
+ lpclm=-1.7427318e-07      wpclm=-3.0342467e-07      ppclm=2.078459e-13
+ pdiblc1=0                 pdiblc2=9.9598752e-06     lpdiblc2=2.748547e-14
+ wpdiblc2=1.7432134e-14    ppdiblc2=-1.1941012e-20   pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+08          pscbe2=1e-20              fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-07           alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-09
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgoprf_33        cgdo=cgoprf_33        cgbo=0
+ cgdl=cglprf_33        cgsl=cglprf_33        clc=0
+ cle=0.6                   cf=cfprf_33           ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.31220625           lkt1=-1.2188719e-08
+ kt1l=0                    kt2=-0.036252785          lkt2=-6.6768413e-09
+ wkt2=-4.5318425e-09       pkt2=3.1043111e-15        ute=-1
+ ua1=2.6585229e-09         lua1=-6.8199474e-17       wua1=1.0218746e-16
+ pua1=6.867687e-23         ub1=-3.7406251e-18        lub1=-2.1877184e-25
+ uc1=4.8045864e-11         luc1=-6.1441675e-17       wuc1=-1.4385838e-16
+ puc1=7.7607715e-23        prt=0                     at=222230.68
+ lat=-0.076734189          wat=-0.039253567          pat=1.4327546e-08
+ fnoimod=1                 tnoimod=1                 noia=noiaprf_33
+ noib=noibprf_33       noic=noicprf_33       em=3e+7
+ ef=1.15                   jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=0                     cjd=0
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=0                   cjswd=0
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=0                  cjswgd=0
+ mjswgs=0.5                mjswgd=0.5                tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.00134            tcjswg=0.00155            xtis=3
+ xtid=3                    jtsswgs=2.148e-08         jtsswgd=2.148e-08
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-08             dmci=9.25e-08             dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.00656u             rshg=15.882               gbmin=1e-12
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-07             sbref=4.6e-07             wlod=0
+ kvth0=1.1e-09             lkvth0=-1.5e-07           wkvth0=3e-07
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-09               lku0=1.5e-08              wku0=1.1e-06
+ pku0=2e-15                llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-09              tku0=0
+ rnoib=0                   rnoia=rnoiax              tnoia=tnoiax
+ minr=1e-3
 
     }  
 
// 
model pdio_rf_33_f diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_33           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswprf_33       area=3.92e-8
+ mjsw=0.085                tlevc=1                   cta=0.00085
+ ctp=0.0003                tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.001                 ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 

// 
model pdio_rf_33_g diode 
+ level=1                   is=1.38e-07               n=1
+ bv=10                     ibv=0.03                  isw=4.11e-13
+ cj=cjprf_33           pj=8.4e-4                 mj=0.32
+ fc=0                      cjsw=cjswgprf_33      area=3.92e-8
+ mjsw=0.5                  tlevc=1                   cta=0.00085
+ ctp=0.00155               tbv1=-1*-9.0e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.9
+ vj=0.7                    pta=0.00155               tnom=25
+ ptp=0.00134               ns=1                      nz=1
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
ends pmos_rf_33_nw
// 
endsection rf_mos_33 

section stat_mis 
statistics { 
 mismatch { 
  vary parn1 dist=gauss std=1/1 
  vary parn2 dist=gauss std=1/1 
  vary parp1 dist=gauss std=1/1 
  vary parp2 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis 
 
section stat_mis_hvt 
statistics { 
 mismatch { 
  vary parn1_hvt dist=gauss std=1/1 
  vary parn2_hvt dist=gauss std=1/1 
  vary parp1_hvt dist=gauss std=1/1 
  vary parp2_hvt dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_hvt 
 
section stat_mis_lvt 
statistics { 
 mismatch { 
  vary parn1_lvt dist=gauss std=1/1 
  vary parn2_lvt dist=gauss std=1/1 
  vary parp1_lvt dist=gauss std=1/1 
  vary parp2_lvt dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_lvt 
 
section stat_mis_18 
statistics { 
 mismatch { 
  vary parn1_18 dist=gauss std=1/1 
  vary parn2_18 dist=gauss std=1/1 
  vary parp1_18 dist=gauss std=1/1 
  vary parp2_18 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_18 
 
section stat_mis_25 
statistics { 
 mismatch { 
  vary parn1_25 dist=gauss std=1/1 
  vary parn2_25 dist=gauss std=1/1 
  vary parp1_25 dist=gauss std=1/1 
  vary parp2_25 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_25 
 
section stat_mis_25ud18 
statistics { 
 mismatch { 
  vary parn1_25ud18 dist=gauss std=1/1 
  vary parn2_25ud18 dist=gauss std=1/1 
  vary parp1_25ud18 dist=gauss std=1/1 
  vary parp2_25ud18 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_25ud18 
 
section stat_mis_25od33 
statistics { 
 mismatch { 
  vary parn1_25od33 dist=gauss std=1/1 
  vary parn2_25od33 dist=gauss std=1/1 
  vary parp1_25od33 dist=gauss std=1/1 
  vary parp2_25od33 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_25od33 
 
section stat_mis_33 
statistics { 
 mismatch { 
  vary parn1_33 dist=gauss std=1/1 
  vary parn2_33 dist=gauss std=1/1 
  vary parp1_33 dist=gauss std=1/1 
  vary parp2_33 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_33 
 
section stat_mis_na 
statistics { 
 mismatch { 
  vary parn1_na dist=gauss std=1/1 
  vary parn2_na dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_na 
 
section stat_mis_na25 
statistics { 
 mismatch { 
  vary parn1_na25 dist=gauss std=1/1 
  vary parn2_na25 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_na25 
 
section stat_mis_na25od33 
statistics { 
 mismatch { 
  vary parn1_na25od33 dist=gauss std=1/1 
  vary parn2_na25od33 dist=gauss std=1/1 
  vary parp1_na25od33 dist=gauss std=1/1 
  vary parp2_na25od33 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_na25od33 
 
section stat_mis_na33 
statistics { 
 mismatch { 
  vary parn1_na33 dist=gauss std=1/1 
  vary parn2_na33 dist=gauss std=1/1 
  vary parp1_na33 dist=gauss std=1/1 
  vary parp2_na33 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_na33 
 
 
section stat_mis_bip 
statistics { 
 mismatch { 
  vary par_bjtp1 dist=gauss std=1/1 
  vary par_bjtp2 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_bip


section stat_mis_bip_npn 
statistics { 
 mismatch { 
  vary par_bjtn1 dist=gauss std=1/1 
  vary par_bjtn2 dist=gauss std=1/1 
  } 
 } 
endsection stat_mis_bip_npn



section noiseflag
parameters noiseflagn=0
parameters noiseflagp=0
endsection noiseflag
 
 
 

section noiseflag_hvt
parameters noiseflagn_hvt=0
parameters noiseflagp_hvt=0
endsection noiseflag_hvt
 
 
 

section noiseflag_lvt
parameters noiseflagn_lvt=0
parameters noiseflagp_lvt=0
endsection noiseflag_lvt
 
 
 

section noiseflag_18
parameters noiseflagn_18=0
parameters noiseflagp_18=0
endsection noiseflag_18
 
 
 

section noiseflag_25
parameters noiseflagn_25=0
parameters noiseflagp_25=0
endsection noiseflag_25
 
 
 

section noiseflag_25ud18
parameters noiseflagn_25ud18=0
parameters noiseflagp_25ud18=0
endsection noiseflag_25ud18
 
 
 

section noiseflag_25od33
parameters noiseflagn_25od33=0
parameters noiseflagp_25od33=0
endsection noiseflag_25od33
 
 
 

section noiseflag_33
parameters noiseflagn_33=0
parameters noiseflagp_33=0
endsection noiseflag_33
 
 
 

section noiseflag_na
parameters noiseflagn_na=0
parameters noiseflagp_na=0
endsection noiseflag_na
 
 
 

section noiseflag_na25
parameters noiseflagn_na25=0
parameters noiseflagp_na25=0
endsection noiseflag_na25
 
 
 

section noiseflag_na25od33
parameters noiseflagn_na25od33=0
parameters noiseflagp_na25od33=0
endsection noiseflag_na25od33
 
 
 

section noiseflag_na33
parameters noiseflagn_na33=0
parameters noiseflagp_na33=0
endsection noiseflag_na33
 
 
 

section noiseflag_res
parameters rnoiseflag_res=0    
endsection noiseflag_res



section noiseflag_disres
parameters rnoiseflag_disres=0    
endsection noiseflag_disres




section post_simu
parameters ccoflag=0
parameters rgflag=0
endsection post_simu
 

section post_simu_hvt
parameters ccoflag_hvt=0
parameters rgflag_hvt=0
endsection post_simu_hvt
 

section post_simu_lvt
parameters ccoflag_lvt=0
parameters rgflag_lvt=0
endsection post_simu_lvt
 

section post_simu_18
parameters ccoflag_18=0
parameters rgflag_18=0
endsection post_simu_18
 

section post_simu_25
parameters ccoflag_25=0
parameters rgflag_25=0
endsection post_simu_25
 

section post_simu_25ud18
parameters ccoflag_25ud18=0
parameters rgflag_25ud18=0
endsection post_simu_25ud18
 

section post_simu_25od33
parameters ccoflag_25od33=0
parameters rgflag_25od33=0
endsection post_simu_25od33
 

section post_simu_33
parameters ccoflag_33=0
parameters rgflag_33=0
endsection post_simu_33
 

section post_simu_na
parameters ccoflag_na=0
parameters rgflag_na=0
endsection post_simu_na
 

section post_simu_na25
parameters ccoflag_na25=0
parameters rgflag_na25=0
endsection post_simu_na25
 

section post_simu_na25od33
parameters ccoflag_na25od33=0
parameters rgflag_na25od33=0
endsection post_simu_na25od33
 

section post_simu_na33
parameters ccoflag_na33=0
parameters rgflag_na33=0
endsection post_simu_na33
 
// **************************     COMMON STATISTICAL LIBRARY      ***************************

section stat
parameters random1=0
parameters random2=0
parameters random3=0
parameters random4=0
parameters random5=0
parameters random6=0
parameters random7=0
parameters random8=0
parameters random9=0
parameters random10=0
parameters par1=random1
parameters par2=random2
parameters par3=random3
parameters par4=random4
parameters par5=random5
parameters par6=random6
parameters par7=random7
parameters par8=random8
parameters par9=random9
parameters par10=random10

statistics {
    process {
        vary random1 dist=gauss std=1/3
        vary random2 dist=gauss std=1/3
        vary random3 dist=gauss std=1/3
        vary random4 dist=gauss std=1/3
        vary random5 dist=gauss std=1/3
        vary random6 dist=gauss std=1/3
        vary random7 dist=gauss std=1/3
        vary random8 dist=gauss std=1/3
        vary random9 dist=gauss std=1/3
        vary random10 dist=gauss std=1/3
        }
    }
endsection stat
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu
parameters a1=par1 * 6.0316e+000 * 3 / 2.1
parameters a2=par2 * 4.1466e+000 * 3 / 2.1
parameters a3=par3 * 3.6308e+000 * 3 / 2.1
parameters a4=par4 * 2.5547e+000 * 3 / 2.1
parameters toxp=2.2000e-009 + ( - 5.0852e-012) * a1 + (2.8679e-012) * a2 + (9.6855e-012) 
+ * a3 + (3.5262e-012) * a4
parameters dxwp=0.0000e+000 + (5.9778e-010) * a1 + ( - 1.4566e-009) * a2 + ( - 1.0382e-009) 
+ * a3 + ( - 2.1865e-010) * a4
parameters dxlp=0.0000e+000 + ( - 3.6668e-010) * a1 + (1.0699e-010) * a2 + (2.2490e-010) 
+ * a3 + (9.4412e-011) * a4
parameters dvthp=0.0000e+000 + (2.6665e-003) * a1 + ( - 3.2625e-003) * a2 + (2.1130e-003) 
+ * a3 + (1.1626e-003) * a4
parameters dlvthp=0.0000e+000 + (2.9916e-011) * a1 + ( - 6.0617e-011) * a2 + (5.0020e-011) 
+ * a3 + ( - 1.5761e-011) * a4
parameters dwvthp=0.0000e+000 + (2.2495e-010) * a1 + ( - 3.4619e-010) * a2 + (2.5601e-010) 
+ * a3 + (1.2967e-011) * a4
parameters dpvthp=0.0000e+000 + (1.7160e-017) * a1 + ( - 1.9478e-017) * a2 + (1.1935e-017) 
+ * a3 + (9.3033e-018) * a4
parameters cjp=1.0600e-003 + ( - 6.7198e-006) * a1 + (8.3935e-006) * a2 + ( - 5.5129e-006) 
+ * a3 + ( - 2.7241e-006) * a4
parameters cjswp=6.4000e-011 + ( - 4.0573e-013) * a1 + (5.0678e-013) * a2 + ( - 
+ 3.3286e-013) * a3 + ( - 1.6448e-013) * a4
parameters cjswgp=2.5500e-010 + ( - 1.6166e-012) * a1 + (2.0192e-012) * a2 + ( - 
+ 1.3262e-012) * a3 + ( - 6.5533e-013) * a4
parameters cgop=3.018880e-11 + (2.6220e-013) * a1 + ( - 1.4777e-013) * a2 + ( - 
+ 4.9980e-013) * a3 + ( - 1.7990e-013) * a4
parameters cglp=5.247580e-11 + (3.1663e-013) * a1 + ( - 1.7858e-013) * a2 + ( - 
+ 6.0312e-013) * a3 + ( - 2.1957e-013) * a4
parameters cfp=1.3800e-010 + (7.4159e-013) * a1 + ( - 4.1823e-013) * a2 + ( - 1.4125e-012) 
+ * a3 + ( - 5.1423e-013) * a4 + 4.6e-11 * ccoflag
parameters du0p=0.0000e+000 + ( - 1.5235e-005) * a1 + (1.3925e-005) * a2 + ( - 6.9060e-006) 
+ * a3 + ( - 1.2298e-005) * a4
parameters dlu0p=0.0000e+000 + ( - 3.4244e-013) * a1 + (1.2002e-013) * a2 + ( - 
+ 5.2447e-013) * a3 + (5.0775e-013) * a4
parameters dwu0p=0.0000e+000 + (2.7169e-012) * a1 + ( - 3.3936e-012) * a2 + (2.2290e-012) 
+ * a3 + (1.1014e-012) * a4
parameters dpu0p=0.0000e+000 + ( - 1.2016e-019) * a1 + (1.4725e-019) * a2 + ( - 
+ 9.5471e-020) * a3 + ( - 5.2112e-020) * a4
parameters deta0p=0.0000e+000 + ( - 4.8879e-003) * a1 + (1.4050e-003) * a2 + ( - 
+ 9.9194e-004) * a3 + (9.1225e-003) * a4
parameters dleta0p=0.0000e+000 + (2.8150e-010) * a1 + ( - 6.3111e-011) * a2 + (1.0627e-013) 
+ * a3 + ( - 2.0951e-010) * a4
parameters dweta0p=0.0000e+000 + (2.0e-009) * a1 + ( - 6.4991e-010) * a2 + (5.2604e-010) 
+ * a3 + ( - 2.0e-009) * a4
parameters dpeta0p=0.0000e+000 + ( - 7.7739e-017) * a1 + (2.4163e-017) * a2 + ( 
+ - 2.1597e-017) * a3 + (1.7733e-016) * a4
parameters dvsatp=0.0000e+000 + ( - 1.2613e+002) * a1 + (3.2766e+002) * a2 + ( - 
+ 2.8989e+002) * a3 + (1.5293e+002) * a4
parameters dlvsatp=0.0000e+000 + ( - 3.0090e-006) * a1 + ( - 4.0283e-005) * a2 + 
+ (9.4962e-006) * a3 + (9.4313e-006) * a4
parameters ntoxp=1.0000e+000 + (3.7421e-002) * a1 + ( - 1.8992e-002) * a2 + ( - 
+ 6.4966e-002) * a3 + ( - 1.5028e-002) * a4
parameters dlk2p=0.0000e+000 + ( - 4.9669e-011) * a1 + ( - 3.2272e-011) * a2 + (4.9802e-011) 
+ * a3 + ( - 3.2810e-011) * a4
parameters dwk2p=0.0000e+000 + ( - 9.0564e-011) * a1 + (1.1312e-010) * a2 + ( - 
+ 7.4298e-011) * a3 + ( - 3.6713e-011) * a4
parameters dpk2p=0.0000e+000 + (2.9057e-018) * a1 + ( - 9.5150e-019) * a2 + (1.5752e-018) 
+ * a3 + (1.0306e-018) * a4
parameters dagsp=0.0000e+000 + (3.8879e-004) * a1 + (6.3192e-003) * a2 + ( - 7.1377e-003) 
+ * a3 + (8.3202e-003) * a4
parameters dwagsp=0.0000e+000 + ( - 4.1563e-009) * a1 + (4.5677e-009) * a2 + ( - 
+ 2.7263e-009) * a3 + ( - 2.4331e-009) * a4
parameters dla0p=0.0000e+000 + (6.0340e-009) * a1 + (4.9771e-009) * a2 + ( - 3.8372e-009) 
+ * a3 + ( - 3.4390e-009) * a4
parameters dlagsp=0.0000e+000 + (4.8522e-009) * a1 + ( - 3.8995e-010) * a2 + ( - 
+ 2.2331e-009) * a3 + (8.7691e-009) * a4
parameters dpagsp=0.0000e+000 + ( - 9.7044e-016) * a1 + (7.7990e-017) * a2 + (4.4663e-016) 
+ * a3 + ( - 1.7538e-015) * a4
parameters dcitp=0.0000e+000 + (1.2613e-005) * a1 + ( - 3.2766e-005) * a2 + (2.8989e-005) 
+ * a3 + ( - 1.5293e-005) * a4
parameters dlcitp=0.0000e+000 + (1.1859e-012) * a1 + (3.6085e-012) * a2 + (1.8034e-011) 
+ * a3 + (6.0285e-012) * a4
parameters dlvoffp=0.0000e+000 + (6.5576e-012) * a1 + ( - 3.9333e-011) * a2 + ( 
+ - 3.5957e-011) * a3 + ( - 3.2839e-011) * a4
parameters dlatp=0.0000e+000 + ( - 1.4557e-005) * a1 + (1.1699e-006) * a2 + (6.6994e-006) 
+ * a3 + ( - 2.6307e-005) * a4
parameters ff_flag=0.0000e+000 + (4.6113e-002) * a1 + ( - 1.3828e-002) * a2 + (1.1192e-002) 
+ * a3 + ( - 9.6223e-002) * a4
parameters ss_flag=0.0000e+000 + ( - 4.8522e-002) * a1 + (3.8995e-003) * a2 + (2.2331e-002) 
+ * a3 + ( - 8.7691e-002) * a4
parameters fs_flag=0.0000e+000 + (5.7047e-003) * a1 + (6.9231e-002) * a2 + ( - 2.2822e-002) 
+ * a3 + (2.5541e-002) * a4
parameters sf_flag=0.0000e+000 + ( - 4.3253e-003) * a1 + ( - 6.5044e-002) * a2 + 
+ (8.8318e-003) * a3 + (5.6978e-002) * a4
parameters toxn=2.0000e-009 + ( - 5.0852e-012) * a1 + (2.8679e-012) * a2 + (9.6855e-012) 
+ * a3 + (3.5262e-012) * a4
parameters dxwn=0.0000e+000 + (7.5826e-010) * a1 + (6.9182e-010) * a2 + ( - 1.5446e-009) 
+ * a3 + ( - 7.2166e-010) * a4
parameters dxln=0.0000e+000 + ( - 3.7854e-010) * a1 + (7.0910e-011) * a2 + (4.4557e-011) 
+ * a3 + (3.4127e-011) * a4
parameters dvthn=0.0000e+000 + ( - 2.9938e-003) * a1 + ( - 2.9906e-003) * a2 + ( 
+ - 1.1359e-003) * a3 + (3.7559e-004) * a4
parameters dlvthn=0.0000e+000 + ( - 7.0996e-011) * a1 + ( - 7.9326e-011) * a2 + 
+ ( - 3.3477e-011) * a3 + (2.3961e-011) * a4
parameters dwvthn=0.0000e+000 + ( - 9.2617e-011) * a1 + ( - 4.9244e-011) * a2 + 
+ ( - 1.4751e-012) * a3 + ( - 6.5871e-011) * a4
parameters dpvthn=0.0000e+000 + ( - 2.1330e-017) * a1 + ( - 2.1528e-017) * a2 + 
+ ( - 8.2645e-018) * a3 + (3.0708e-018) * a4
parameters cjn=1.2700e-003 + ( - 9.5656e-006) * a1 + ( - 9.3103e-006) * a2 + ( - 
+ 3.4387e-006) * a3 + (7.6128e-007) * a4
parameters cjswn=6.4000e-011 + ( - 4.8205e-013) * a1 + ( - 4.6918e-013) * a2 + ( 
+ - 1.7329e-013) * a3 + (3.8363e-014) * a4
parameters cjswgn=3.0500e-010 + ( - 2.2973e-012) * a1 + ( - 2.2359e-012) * a2 + 
+ ( - 8.2583e-013) * a3 + (1.8283e-013) * a4
parameters cgon=5.725430e-11 + (4.0516e-013) * a1 + ( - 2.2849e-013) * a2 + ( - 
+ 7.7167e-013) * a3 + ( - 2.8084e-013) * a4
parameters cgln=9.157840e-12 + (4.3203e-014) * a1 + ( - 2.4366e-014) * a2 + ( - 
+ 8.2293e-014) * a3 + ( - 2.9950e-014) * a4
parameters cfn=1.3900e-010 + (7.4159e-013) * a1 + ( - 4.1823e-013) * a2 + ( - 1.4125e-012) 
+ * a3 + ( - 5.1423e-013) * a4 + 4.1e-11 * ccoflag
parameters drdswn=0.0000e+000 + (2.4261e-001) * a1 + ( - 1.9498e-002) * a2 + ( - 
+ 1.1166e-001) * a3 + (4.3846e-001) * a4
parameters dlu0n=0.0000e+000 + (1.8760e-012) * a1 + ( - 2.8232e-012) * a2 + ( - 
+ 1.3308e-012) * a3 + (2.6845e-013) * a4
parameters deta0n=0.0000e+000 + (4.8522e-004) * a1 + ( - 3.8995e-005) * a2 + ( - 
+ 2.2331e-004) * a3 + (8.7691e-004) * a4
parameters dleta0n=0.0000e+000 + ( - 5.4856e-011) * a1 + ( - 6.3617e-011) * a2 + 
+ ( - 2.7675e-011) * a3 + (2.2676e-011) * a4
parameters dpeta0n=0.0000e+000 + (2.6542e-017) * a1 + (3.0179e-017) * a2 + (1.2922e-017) 
+ * a3 + ( - 9.8943e-018) * a4
parameters dlvsatn=0.0000e+000 + ( - 2.3079e-005) * a1 + (1.7002e-005) * a2 + ( 
+ - 1.4589e-005) * a3 + ( - 1.4982e-005) * a4
parameters dpvsatn=0.0000e+000 + ( - 6.2662e-012) * a1 + ( - 6.8658e-012) * a2 + 
+ ( - 2.8492e-012) * a3 + (1.8720e-012) * a4
parameters ntoxn=1.0000e+000 + (1.4531e-002) * a1 + ( - 7.7257e-003) * a2 + ( - 
+ 2.6275e-002) * a3 + ( - 7.6493e-003) * a4
parameters dk2n=0.0000e+000 + ( - 1.3018e-003) * a1 + ( - 1.3693e-003) * a2 + ( 
+ - 5.4751e-004) * a3 + (2.8671e-004) * a4
parameters dlk2n=0.0000e+000 + (2.4261e-012) * a1 + ( - 1.9498e-013) * a2 + ( - 
+ 1.1166e-012) * a3 + (4.3846e-012) * a4
parameters dwk2n=0.0000e+000 + ( - 1.9959e-010) * a1 + ( - 1.9937e-010) * a2 + ( 
+ - 7.5726e-011) * a3 + (2.5039e-011) * a4
parameters dpk2n=0.0000e+000 + ( - 1.1214e-017) * a1 + ( - 1.2704e-017) * a2 + ( 
+ - 5.4233e-018) * a3 + (4.0968e-018) * a4
parameters dagsn=0.0000e+000 + ( - 2.8273e-003) * a1 + ( - 5.1760e-003) * a2 + (2.3827e-003) 
+ * a3 + ( - 3.1271e-003) * a4
parameters dlcitn=0.0000e+000 + (9.8822e-013) * a1 + (3.0071e-012) * a2 + (1.5029e-011) 
+ * a3 + (5.0238e-012) * a4
parameters dlvoffn=0.0000e+000 + (3.2280e-011) * a1 + (3.1418e-011) * a2 + (1.1604e-011) 
+ * a3 + ( - 2.5690e-012) * a4
parameters dlkt1n=0.0000e+000 + (2.1520e-011) * a1 + (2.0946e-011) * a2 + (7.7361e-012) 
+ * a3 + ( - 1.7127e-012) * a4
parameters dkt2n=0.0000e+000 + (5.1054e-004) * a1 + (1.2074e-005) * a2 + (8.6335e-004) 
+ * a3 + ( - 7.1104e-004) * a4
parameters dlatn=0.0000e+000 + ( - 2.6900e-005) * a1 + ( - 2.6182e-005) * a2 + ( 
+ - 9.6701e-006) * a3 + (2.1408e-006) * a4
parameters dpatn=0.0000e+000 + ( - 6.4560e-012) * a1 + ( - 6.2837e-012) * a2 + ( 
+ - 2.3208e-012) * a3 + (5.1380e-013) * a4
parameters dlagsn=0.0000e+000 + ( - 8.7765e-009) * a1 + ( - 4.9634e-009) * a2 + 
+ ( - 3.7083e-010) * a3 + ( - 5.7102e-009) * a4
parameters dpagsn=0.0000e+000 + (1.0043e-015) * a1 + (1.8467e-015) * a2 + (1.0372e-015) 
+ * a3 + ( - 1.6363e-015) * a4
parameters ddlcp=4.745380e-09
parameters drdswp=0.0000e+000
parameters dnfactorp=0.0000e+000
parameters dlnfactorp=0.0000e+000
parameters dwnfactorp=0.0000e+000
parameters dpnfactorp=0.0000e+000
parameters dwvsatp=0.0000e+000
parameters dpvsatp=0.0000e+000
parameters dk2p=0.0000e+000
parameters dpclmp=0.0000e+000
parameters dwa0p=0.0000e+000
parameters dpa0p=0.0000e+000
parameters dwcitp=0.0000e+000
parameters dpcitp=0.0000e+000
parameters dvoffp=0.0000e+000
parameters dwvoffp=0.0000e+000
parameters dpvoffp=0.0000e+000
parameters da0p=0.0000e+000
parameters jtsswgp=7.2000e-010
parameters dlutep=0.0000e+000
parameters dlpclmp=0.0000e+000
parameters ddlcn=3.244300e-09
parameters dnfactorn=0.0000e+000
parameters dlnfactorn=0.0000e+000
parameters dwnfactorn=0.0000e+000
parameters dpnfactorn=0.0000e+000
parameters du0n=0.0000e+000
parameters dwu0n=0.0000e+000
parameters dpu0n=0.0000e+000
parameters dweta0n=0.0000e+000
parameters dvsatn=0.0000e+000
parameters dwvsatn=0.0000e+000
parameters dpclmn=0.0000e+000
parameters dppclmn=0.0000e+000
parameters dwcitn=0.0000e+000
parameters dpcitn=0.0000e+000
parameters da0n=0.0000e+000
parameters dla0n=0.0000e+000
parameters dwa0n=0.0000e+000
parameters dpa0n=0.0000e+000
parameters dvoffn=0.0000e+000
parameters dwvoffn=0.0000e+000
parameters dpvoffn=0.0000e+000
parameters dkt1n=0.0000e+000
parameters dwkt1n=0.0000e+000
parameters dpkt1n=0.0000e+000
parameters dlkt2n=0.0000e+000
parameters dwkt2n=0.0000e+000
parameters dpkt2n=0.0000e+000
parameters dub1n=0.0000e+000
parameters dlub1n=0.0000e+000
parameters dwub1n=0.0000e+000
parameters dpub1n=0.0000e+000
parameters dua1n=0.0000e+000
parameters dlua1n=0.0000e+000
parameters dwua1n=0.0000e+000
parameters dpua1n=0.0000e+000
parameters datn=0.0000e+000
parameters dwatn=0.0000e+000
parameters b1fn=-6.5E+40           
parameters b2fn=0
parameters b3fn=-2.49E+7           
parameters a1fn=9.25e+41   
parameters a2fn=0  
parameters a3fn=1.475e+9  
parameters c1fn=1.5E+41     
parameters c2fn=1E+14  
parameters c3fn=5E+7 
parameters b1fp=-5.5E+41   
parameters b2fp=0    
parameters b3fp=-7E+9   
parameters a1fp=1.19E+43   
parameters a2fp=3.995E+17  
parameters a3fp=4E+10 
parameters c1fp=1.2E+42   
parameters c2fp=1E+15    
parameters c3fp=1.5E+10   
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "crn65gplus_2d5_lk_v1d0.scs" section=mos
endsection mc
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_hvt
parameters a1_hvt= - par1 * 6.5767e+000 * 3 / 2.0
parameters a2_hvt= - par2 * 5.5366e+000 * 3 / 2.0
parameters a3_hvt= - par3 * 2.8107e+000 * 3 / 2.0
parameters a4_hvt= - par4 * 2.7341e+000 * 3 / 2.0
parameters a5_hvt= - par5 * 1.6483e+000 * 3 / 2.0
parameters toxn_hvt=2.0000e-009 + (5.7829e-012) * a1_hvt + ( - 4.8154e-013) * a2_hvt 
+ + (5.6662e-012) * a3_hvt + ( - 9.6243e-012) * a4_hvt + ( - 3.5638e-013) * a5_hvt
parameters dxln_hvt=0.0000e+000 + (3.4681e-010) * a1_hvt + ( - 1.8611e-011) * a2_hvt 
+ + (3.4762e-011) * a3_hvt + (1.1974e-010) * a4_hvt + ( - 3.5980e-011) * a5_hvt
parameters dxwn_hvt=0.0000e+000 + ( - 6.6941e-010) * a1_hvt + (8.7268e-010) * a2_hvt 
+ + ( - 8.2068e-011) * a3_hvt + ( - 1.1176e-010) * a4_hvt + (4.6410e-011) * a5_hvt
parameters cjn_hvt=1.3297e-003 + (7.7368e-006) * a1_hvt + ( - 8.1717e-006) * a2_hvt 
+ + ( - 3.2066e-008) * a3_hvt + (3.7236e-006) * a4_hvt + ( - 6.3356e-007) * a5_hvt
parameters cjswn_hvt=6.6900e-011 + (3.8925e-013) * a1_hvt + ( - 4.1114e-013) * a2_hvt 
+ + ( - 1.6138e-015) * a3_hvt + (1.8734e-013) * a4_hvt + ( - 3.1875e-014) * a5_hvt
parameters cjswgn_hvt=3.3536e-010 + (1.9512e-012) * a1_hvt + ( - 2.0610e-012) * 
+ a2_hvt + ( - 8.0902e-015) * a3_hvt + (9.3909e-013) * a4_hvt + ( - 1.5979e-013) 
+ * a5_hvt
parameters cgon_hvt=5.174670e-11 + ( - 4.1944e-013) * a1_hvt + (3.4927e-014) * a2_hvt 
+ + ( - 4.1098e-013) * a3_hvt + (6.9806e-013) * a4_hvt + (2.5849e-014) * a5_hvt
parameters cgln_hvt=1.337910e-11 + ( - 8.4730e-014) * a1_hvt + (7.0554e-015) * a2_hvt 
+ + ( - 8.3020e-014) * a3_hvt + (1.4101e-013) * a4_hvt + (5.2215e-015) * a5_hvt
parameters ntoxn_hvt=1.0000e+000 + ( - 1.9791e-002) * a1_hvt + (1.7245e-003) * a2_hvt 
+ + ( - 2.2949e-002) * a3_hvt + (3.4678e-002) * a4_hvt + (2.1670e-003) * a5_hvt
parameters cfn_hvt=1.3900e-010 + ( - 8.4297e-013) * a1_hvt + (7.0321e-014) * a2_hvt 
+ + ( - 8.3400e-013) * a3_hvt + (1.4000e-012) * a4_hvt + (5.5289e-014) * a5_hvt 
+ + 4.1e-11 * ccoflag_hvt
parameters dvthn_hvt=0.0000e+000 + (1.4651e-003) * a1_hvt + ( - 1.5282e-003) * a2_hvt 
+ + ( - 3.4970e-005) * a3_hvt + (6.8793e-004) * a4_hvt + ( - 1.0696e-004) * a5_hvt
parameters dlvthn_hvt=0.0000e+000 + (3.7537e-011) * a1_hvt + ( - 5.6586e-011) * 
+ a2_hvt + (2.5127e-011) * a3_hvt + (3.3126e-011) * a4_hvt + ( - 1.4461e-011) * 
+ a5_hvt
parameters dwvthn_hvt=0.0000e+000 + (2.5905e-010) * a1_hvt + ( - 2.9781e-010) * 
+ a2_hvt + (3.5044e-011) * a3_hvt + (1.4619e-010) * a4_hvt + ( - 3.7481e-011) * 
+ a5_hvt
parameters dpvthn_hvt=0.0000e+000 + (1.3964e-017) * a1_hvt + ( - 1.4749e-017) * 
+ a2_hvt + ( - 5.7903e-020) * a3_hvt + (6.7207e-018) * a4_hvt + ( - 1.1435e-018) 
+ * a5_hvt
parameters dk2n_hvt=0.0000e+000 + ( - 1.2690e-004) * a1_hvt + (1.1468e-004) * a2_hvt 
+ + (2.9421e-005) * a3_hvt + ( - 4.3864e-005) * a4_hvt + ( - 2.6219e-006) * a5_hvt
parameters dlk2n_hvt=0.0000e+000 + (4.9872e-011) * a1_hvt + ( - 5.2676e-011) * a2_hvt 
+ + ( - 2.0680e-013) * a3_hvt + (2.4002e-011) * a4_hvt + ( - 4.0840e-012) * a5_hvt
parameters dwk2n_hvt=0.0000e+000 + (4.9872e-011) * a1_hvt + ( - 5.2676e-011) * a2_hvt 
+ + ( - 2.0680e-013) * a3_hvt + (2.4002e-011) * a4_hvt + ( - 4.0840e-012) * a5_hvt
parameters dpk2n_hvt=0.0000e+000 + (1.0801e-018) * a1_hvt + ( - 2.5927e-018) * a2_hvt 
+ + (2.1626e-018) * a3_hvt + (1.8107e-018) * a4_hvt + ( - 1.0645e-018) * a5_hvt
parameters dlcitn_hvt=0.0000e+000 + (4.7111e-012) * a1_hvt + ( - 8.3590e-012) * 
+ a2_hvt + (8.4865e-012) * a3_hvt + ( - 1.5254e-012) * a4_hvt + ( - 2.6874e-012) 
+ * a5_hvt
parameters dpcitn_hvt=0.0000e+000 + (6.5160e-019) * a1_hvt + ( - 7.7185e-019) * 
+ a2_hvt + (1.7125e-019) * a3_hvt + (2.9122e-019) * a4_hvt + ( - 1.0995e-019) * 
+ a5_hvt
parameters dlvoffn_hvt=0.0000e+000 + ( - 2.3898e-011) * a1_hvt + (2.3413e-011) * 
+ a2_hvt + ( - 4.2480e-011) * a3_hvt + (7.9274e-011) * a4_hvt + (1.0846e-012) * 
+ a5_hvt
parameters dwvoffn_hvt=0.0000e+000 + (2.7430e-011) * a1_hvt + ( - 2.8972e-011) * 
+ a2_hvt + ( - 1.1374e-013) * a3_hvt + (1.3201e-011) * a4_hvt + ( - 2.2462e-012) 
+ * a5_hvt
parameters dpvoffn_hvt=0.0000e+000 + (2.3319e-018) * a1_hvt + ( - 3.0933e-018) * 
+ a2_hvt + ( - 5.8666e-018) * a3_hvt + (1.5057e-017) * a4_hvt + ( - 5.6099e-019) 
+ * a5_hvt
parameters dlpclmn_hvt=0.0000e+000 + (8.1585e-012) * a1_hvt + (2.2372e-010) * a2_hvt 
+ + (2.9079e-011) * a3_hvt + (1.5871e-013) * a4_hvt + (2.9454e-011) * a5_hvt
parameters dppclmn_hvt=0.0000e+000 + ( - 5.8904e-017) * a1_hvt + (6.3184e-017) * 
+ a2_hvt + ( - 1.2005e-018) * a3_hvt + ( - 2.9210e-017) * a4_hvt + (5.4743e-018) 
+ * a5_hvt
parameters dlvsatn_hvt=0.0000e+000 + (4.2947e-005) * a1_hvt + ( - 4.0522e-005) * 
+ a2_hvt + ( - 7.4017e-006) * a3_hvt + (1.6367e-005) * a4_hvt + ( - 2.6342e-007) 
+ * a5_hvt
parameters dpvsatn_hvt=0.0000e+000 + (9.9644e-012) * a1_hvt + ( - 3.8074e-012) * 
+ a2_hvt + ( - 1.0068e-011) * a3_hvt + ( - 1.1767e-012) * a4_hvt + (3.6998e-012) 
+ * a5_hvt
parameters dleta0n_hvt=0.0000e+000 + ( - 1.2264e-010) * a1_hvt + (8.2114e-011) * 
+ a2_hvt + (7.1300e-011) * a3_hvt + ( - 1.6858e-011) * a4_hvt + ( - 2.1841e-011) 
+ * a5_hvt
parameters dpeta0n_hvt=0.0000e+000 + ( - 4.6992e-018) * a1_hvt + (4.5763e-018) * 
+ a2_hvt + (5.9737e-019) * a3_hvt + ( - 1.9174e-018) * a4_hvt + (1.2453e-019) * 
+ a5_hvt
parameters dlu0n_hvt=0.0000e+000 + ( - 5.5297e-012) * a1_hvt + (8.7080e-012) * a2_hvt 
+ + ( - 3.9345e-012) * a3_hvt + ( - 5.0185e-012) * a4_hvt + (1.1192e-012) * a5_hvt
parameters dwu0n_hvt=0.0000e+000 + (1.2758e-013) * a1_hvt + (2.5241e-013) * a2_hvt 
+ + ( - 5.7842e-013) * a3_hvt + ( - 2.8283e-013) * a4_hvt + (2.4983e-013) * a5_hvt
parameters dpu0n_hvt=0.0000e+000 + (1.3824e-019) * a1_hvt + (5.4097e-020) * a2_hvt 
+ + ( - 2.2830e-019) * a3_hvt + ( - 6.9095e-020) * a4_hvt + ( - 1.5427e-019) * a5_hvt
parameters dagsn_hvt=0.0000e+000 + (1.4268e-002) * a1_hvt + ( - 1.7490e-002) * a2_hvt 
+ + (3.5526e-003) * a3_hvt + (9.0184e-003) * a4_hvt + ( - 2.7951e-003) * a5_hvt
parameters dwagsn_hvt=0.0000e+000 + (1.6068e-009) * a1_hvt + ( - 2.1811e-009) * 
+ a2_hvt + (7.1570e-010) * a3_hvt + (1.2036e-009) * a4_hvt + ( - 4.5693e-010) * 
+ a5_hvt
parameters dla0n_hvt=0.0000e+000 + ( - 2.9089e-010) * a1_hvt + ( - 8.3220e-009) 
+ * a2_hvt + ( - 1.4948e-009) * a3_hvt + ( - 2.0502e-010) * a4_hvt + ( - 2.1465e-009) 
+ * a5_hvt
parameters dpa0n_hvt=0.0000e+000 + (4.3686e-016) * a1_hvt + (1.5505e-015) * a2_hvt 
+ + ( - 4.7435e-016) * a3_hvt + ( - 2.0887e-016) * a4_hvt + (1.8609e-016) * a5_hvt
parameters dlatn_hvt=0.0000e+000 + (8.4811e-005) * a1_hvt + ( - 2.4676e-006) * a2_hvt 
+ + ( - 1.3038e-004) * a3_hvt + ( - 3.6634e-005) * a4_hvt + (5.1617e-005) * a5_hvt
parameters dluc1n_hvt=0.0000e+000 + ( - 3.8071e-019) * a1_hvt + ( - 4.6591e-020) 
+ * a2_hvt + (6.2699e-019) * a3_hvt + (1.8929e-019) * a4_hvt + ( - 9.7054e-020) 
+ * a5_hvt
parameters dlub1n_hvt=0.0000e+000 + ( - 3.4330e-029) * a1_hvt + ( - 5.2326e-028) 
+ * a2_hvt + (4.3211e-028) * a3_hvt + (2.4066e-028) * a4_hvt + (1.2032e-027) * a5_hvt
parameters dpatn_hvt=0.0000e+000 + (5.1829e-012) * a1_hvt + ( - 1.5080e-013) * a2_hvt 
+ + ( - 7.9675e-012) * a3_hvt + ( - 2.2388e-012) * a4_hvt + (3.1544e-012) * a5_hvt
parameters dlubn_hvt=0.0000e+000 + ( - 3.8946e-028) * a1_hvt + (7.1141e-028) * a2_hvt 
+ + ( - 4.4625e-028) * a3_hvt + ( - 4.5422e-028) * a4_hvt + (2.3361e-028) * a5_hvt
parameters dpubn_hvt=0.0000e+000 + ( - 2.0882e-035) * a1_hvt + (5.0125e-035) * a2_hvt 
+ + ( - 4.1810e-035) * a3_hvt + ( - 3.5007e-035) * a4_hvt + (2.0580e-035) * a5_hvt
parameters dlkt2n_hvt=0.0000e+000 + ( - 5.5227e-012) * a1_hvt + (2.3752e-011) * 
+ a2_hvt + ( - 8.5804e-012) * a3_hvt + ( - 7.7770e-012) * a4_hvt + ( - 5.8447e-011) 
+ * a5_hvt
parameters dlkt1n_hvt=0.0000e+000 + ( - 1.0112e-010) * a1_hvt + (1.3101e-010) * 
+ a2_hvt + ( - 3.5699e-011) * a3_hvt + ( - 7.0182e-011) * a4_hvt + (2.4548e-011) 
+ * a5_hvt
parameters ss_flag_hvt=0.0000e+000 + (4.7117e-002) * a1_hvt + ( - 1.3709e-003) * 
+ a2_hvt + ( - 7.2432e-002) * a3_hvt + ( - 2.0352e-002) * a4_hvt + (2.8676e-002) 
+ * a5_hvt
parameters ff_flag_hvt=0.0000e+000 + ( - 3.9586e-002) * a1_hvt + (3.2818e-003) * 
+ a2_hvt + ( - 8.1122e-002) * a3_hvt + ( - 5.0287e-002) * a4_hvt + (3.7671e-002) 
+ * a5_hvt
parameters sf_flag_hvt=0.0000e+000 + ( - 3.4330e-003) * a1_hvt + ( - 5.2326e-002) 
+ * a2_hvt + (4.3211e-002) * a3_hvt + (2.4066e-002) * a4_hvt + (1.2032e-001) * a5_hvt
parameters fs_flag_hvt=0.0000e+000 + (5.6202e-004) * a1_hvt + (5.1769e-002) * a2_hvt 
+ + (5.0218e-002) * a3_hvt + (2.0996e-002) * a4_hvt + (1.1744e-001) * a5_hvt
parameters toxp_hvt=2.2000e-009 + (5.7829e-012) * a1_hvt + ( - 4.8154e-013) * a2_hvt 
+ + (5.6662e-012) * a3_hvt + ( - 9.6243e-012) * a4_hvt + ( - 3.5638e-013) * a5_hvt
parameters ori_dxlp_hvt=0.0000e+000 + (3.4681e-010) * a1_hvt + ( - 1.8611e-011) 
+ * a2_hvt + (3.4762e-011) * a3_hvt + (1.1974e-010) * a4_hvt + ( - 3.5980e-011) 
+ * a5_hvt
parameters dxwp_hvt=0.0000e+000 + ( - 8.4173e-010) * a1_hvt + ( - 7.5506e-010) * 
+ a2_hvt + ( - 1.1545e-009) * a3_hvt + (2.0692e-009) * a4_hvt + (5.8401e-011) * 
+ a5_hvt
parameters cjp_hvt=1.0800e-003 + (6.7817e-006) * a1_hvt + (5.9490e-006) * a2_hvt 
+ + (9.5112e-007) * a3_hvt + (2.3652e-006) * a4_hvt + ( - 8.5930e-007) * a5_hvt
parameters cjswp_hvt=6.4000e-011 + (4.0188e-013) * a1_hvt + (3.5254e-013) * a2_hvt 
+ + (5.6363e-014) * a3_hvt + (1.4016e-013) * a4_hvt + ( - 5.0922e-014) * a5_hvt
parameters cjswgp_hvt=3.0500e-010 + (1.9152e-012) * a1_hvt + (1.6800e-012) * a2_hvt 
+ + (2.6860e-013) * a3_hvt + (6.6794e-013) * a4_hvt + ( - 2.4267e-013) * a5_hvt
parameters cgop_hvt=2.616320e-11 + ( - 2.7281e-013) * a1_hvt + (2.2717e-014) * a2_hvt 
+ + ( - 2.6731e-013) * a3_hvt + (4.5403e-013) * a4_hvt + (1.6812e-014) * a5_hvt
parameters cglp_hvt=3.692040e-11 + ( - 2.4977e-013) * a1_hvt + (2.0799e-014) * a2_hvt 
+ + ( - 2.4474e-013) * a3_hvt + (4.1570e-013) * a4_hvt + (1.5392e-014) * a5_hvt
parameters cfp_hvt=1.3800e-010 + ( - 8.4297e-013) * a1_hvt + (7.0321e-014) * a2_hvt 
+ + ( - 8.3400e-013) * a3_hvt + (1.4000e-012) * a4_hvt + (5.5289e-014) * a5_hvt 
+ + 4.6e-11 * ccoflag_hvt
parameters ntoxp_hvt=1.0000e+000 + ( - 4.0395e-002) * a1_hvt + (3.1594e-003) * a2_hvt 
+ + ( - 3.0091e-002) * a3_hvt + (6.2582e-002) * a4_hvt + ( - 3.7039e-005) * a5_hvt
parameters dvthp_hvt=0.0000e+000 + ( - 2.4306e-003) * a1_hvt + ( - 2.1407e-003) 
+ * a2_hvt + ( - 3.5669e-004) * a3_hvt + ( - 8.5503e-004) * a4_hvt + (3.1490e-004) 
+ * a5_hvt
parameters dlvthp_hvt=0.0000e+000 + ( - 3.8637e-011) * a1_hvt + ( - 4.1152e-011) 
+ * a2_hvt + ( - 1.8855e-011) * a3_hvt + ( - 1.9728e-011) * a4_hvt + (1.0786e-011) 
+ * a5_hvt
parameters dwvthp_hvt=0.0000e+000 + ( - 4.6801e-010) * a1_hvt + ( - 4.6606e-010) 
+ * a2_hvt + ( - 1.6839e-010) * a3_hvt + ( - 2.1104e-010) * a4_hvt + (1.0434e-010) 
+ * a5_hvt
parameters dpvthp_hvt=0.0000e+000 + ( - 1.5344e-017) * a1_hvt + ( - 1.3375e-017) 
+ * a2_hvt + ( - 1.9939e-018) * a3_hvt + ( - 5.2778e-018) * a4_hvt + (1.8749e-018) 
+ * a5_hvt
parameters dvsatp_hvt=0.0000e+000 + (4.7117e+001) * a1_hvt + ( - 1.3709e+000) * 
+ a2_hvt + ( - 7.2432e+001) * a3_hvt + ( - 2.0352e+001) * a4_hvt + (2.8676e+001) 
+ * a5_hvt
parameters ori_dlvsatp_hvt=0.0000e+000 + (9.6319e-005) * a1_hvt + (4.4352e-005) 
+ * a2_hvt + ( - 6.0789e-005) * a3_hvt + ( - 9.8579e-007) * a4_hvt + (2.0363e-005) 
+ * a5_hvt
parameters ori_dpvsatp_hvt=0.0000e+000 + (2.2086e-011) * a1_hvt + (4.6419e-012) 
+ * a2_hvt + ( - 2.4171e-011) * a3_hvt + ( - 4.9880e-012) * a4_hvt + (9.1545e-012) 
+ * a5_hvt
parameters dleta0p_hvt=0.0000e+000 + ( - 1.3296e-010) * a1_hvt + ( - 7.9058e-011) 
+ * a2_hvt + (5.0907e-011) * a3_hvt + ( - 1.4001e-011) * a4_hvt + ( - 1.3641e-011) 
+ * a5_hvt
parameters dpeta0p_hvt=0.0000e+000 + (2.7817e-018) * a1_hvt + (7.3207e-019) * a2_hvt 
+ + ( - 2.7715e-018) * a3_hvt + ( - 5.0124e-019) * a4_hvt + (1.0334e-018) * a5_hvt
parameters dlk2p_hvt=0.0000e+000 + (4.9338e-011) * a1_hvt + (4.3280e-011) * a2_hvt 
+ + (6.9195e-012) * a3_hvt + (1.7207e-011) * a4_hvt + ( - 6.2516e-012) * a5_hvt
parameters dwk2p_hvt=0.0000e+000 + (4.9338e-011) * a1_hvt + (4.3280e-011) * a2_hvt 
+ + (6.9195e-012) * a3_hvt + (1.7207e-011) * a4_hvt + ( - 6.2516e-012) * a5_hvt
parameters dlvoffp_hvt=0.0000e+000 + ( - 4.4785e-011) * a1_hvt + ( - 4.9056e-011) 
+ * a2_hvt + (1.9673e-012) * a3_hvt + ( - 6.9468e-011) * a4_hvt + (1.2278e-011) 
+ * a5_hvt
parameters dwvoffp_hvt=0.0000e+000 + (2.8044e-011) * a1_hvt + (3.2491e-012) * a2_hvt 
+ + ( - 3.5587e-011) * a3_hvt + ( - 8.6119e-012) * a4_hvt + (1.3770e-011) * a5_hvt
parameters dpvoffp_hvt=0.0000e+000 + ( - 4.3724e-018) * a1_hvt + ( - 4.4229e-018) 
+ * a2_hvt + ( - 1.7940e-018) * a3_hvt + ( - 1.8694e-018) * a4_hvt + (1.0353e-018) 
+ * a5_hvt
parameters ori_dlpclmp_hvt=0.0000e+000 + ( - 6.8659e-011) * a1_hvt + ( - 1.0465e-009) 
+ * a2_hvt + (8.6423e-010) * a3_hvt + (4.8132e-010) * a4_hvt + (2.4065e-009) * a5_hvt
parameters ori_dppclmp_hvt=0.0000e+000 + ( - 5.1777e-016) * a1_hvt + ( - 4.6731e-016) 
+ * a2_hvt + ( - 4.9245e-016) * a3_hvt + ( - 3.9185e-016) * a4_hvt + (1.3912e-016) 
+ * a5_hvt
parameters dlu0p_hvt=0.0000e+000 + ( - 1.6779e-012) * a1_hvt + ( - 4.3261e-012) 
+ * a2_hvt + ( - 1.0253e-012) * a3_hvt + ( - 7.6359e-013) * a4_hvt + ( - 9.6951e-015) 
+ * a5_hvt
parameters dwu0p_hvt=0.0000e+000 + ( - 4.4853e-013) * a1_hvt + ( - 3.9345e-013) 
+ * a2_hvt + ( - 6.2905e-014) * a3_hvt + ( - 1.5643e-013) * a4_hvt + (5.6832e-014) 
+ * a5_hvt
parameters dpu0p_hvt=0.0000e+000 + ( - 6.5115e-019) * a1_hvt + ( - 6.6165e-019) 
+ * a2_hvt + ( - 3.6619e-019) * a3_hvt + ( - 3.6109e-019) * a4_hvt + (5.3775e-019) 
+ * a5_hvt
parameters dlcitp_hvt=0.0000e+000 + (2.8543e-012) * a1_hvt + (3.5179e-012) * a2_hvt 
+ + ( - 4.1334e-012) * a3_hvt + (1.2930e-011) * a4_hvt + ( - 8.6230e-013) * a5_hvt
parameters dpcitp_hvt=0.0000e+000 + (7.6217e-019) * a1_hvt + (1.3929e-018) * a2_hvt 
+ + (3.1386e-019) * a3_hvt + (2.8458e-018) * a4_hvt + ( - 6.2727e-019) * a5_hvt
parameters dagsp_hvt=0.0000e+000 + (1.0647e-002) * a1_hvt + (2.0015e-002) * a2_hvt 
+ + (2.1253e-002) * a3_hvt + (1.2909e-002) * a4_hvt + ( - 1.0011e-002) * a5_hvt
parameters dlagsp_hvt=0.0000e+000 + (5.6540e-009) * a1_hvt + ( - 1.6451e-010) * 
+ a2_hvt + ( - 8.6918e-009) * a3_hvt + ( - 2.4423e-009) * a4_hvt + (3.4412e-009) 
+ * a5_hvt
parameters dwagsp_hvt=0.0000e+000 + (6.2866e-009) * a1_hvt + (4.5325e-009) * a2_hvt 
+ + ( - 9.3623e-010) * a3_hvt + (1.3464e-009) * a4_hvt + (2.9912e-013) * a5_hvt
parameters dla0p_hvt=0.0000e+000 + ( - 3.4071e-009) * a1_hvt + ( - 6.4049e-009) 
+ * a2_hvt + ( - 6.8010e-009) * a3_hvt + ( - 4.1310e-009) * a4_hvt + (3.2034e-009) 
+ * a5_hvt
parameters dwa0p_hvt=0.0000e+000 + (2.3069e-009) * a1_hvt + ( - 8.8013e-010) * a2_hvt 
+ + ( - 5.0512e-009) * a3_hvt + ( - 1.6968e-009) * a4_hvt + (2.0636e-009) * a5_hvt
parameters dpa0p_hvt=0.0000e+000 + ( - 8.5177e-016) * a1_hvt + ( - 3.6012e-015) 
+ * a2_hvt + ( - 3.7003e-015) * a3_hvt + ( - 3.0327e-015) * a4_hvt + (8.0085e-016) 
+ * a5_hvt
parameters dua1p_hvt=0.0000e+000 + (1.4191e-011) * a1_hvt + (4.7657e-012) * a2_hvt 
+ + ( - 1.6708e-011) * a3_hvt + ( - 4.0061e-012) * a4_hvt + (2.0346e-011) * a5_hvt
parameters duc1p_hvt=0.0000e+000 + ( - 5.0581e-014) * a1_hvt + ( - 4.6592e-012) 
+ * a2_hvt + ( - 4.5196e-012) * a3_hvt + ( - 1.8897e-012) * a4_hvt + ( - 1.0569e-011) 
+ * a5_hvt
parameters dlubp_hvt=0.0000e+000 + ( - 7.0007e-028) * a1_hvt + ( - 7.7638e-028) 
+ * a2_hvt + ( - 3.9853e-028) * a3_hvt + ( - 3.8393e-028) * a4_hvt + (2.2036e-028) 
+ * a5_hvt
parameters dpubp_hvt=0.0000e+000 + ( - 4.3593e-035) * a1_hvt + ( - 5.0029e-035) 
+ * a2_hvt + ( - 2.4352e-035) * a3_hvt + ( - 2.3488e-035) * a4_hvt + (2.3595e-036) 
+ * a5_hvt
parameters dlkt1p_hvt=0.0000e+000 + ( - 1.3229e-010) * a1_hvt + ( - 1.5875e-010) 
+ * a2_hvt + ( - 9.7593e-011) * a3_hvt + ( - 8.2922e-011) * a4_hvt + (5.1409e-011) 
+ * a5_hvt
parameters dlkt2p_hvt=0.0000e+000 + ( - 6.8212e-012) * a1_hvt + ( - 2.0516e-011) 
+ * a2_hvt + ( - 9.9468e-012) * a3_hvt + ( - 5.5491e-012) * a4_hvt + ( - 5.0989e-011) 
+ * a5_hvt
parameters dpkt2p_hvt=0.0000e+000 + ( - 1.6860e-019) * a1_hvt + ( - 1.5531e-017) 
+ * a2_hvt + ( - 1.5065e-017) * a3_hvt + ( - 6.2988e-018) * a4_hvt + ( - 3.5231e-017) 
+ * a5_hvt
parameters ddlcn_hvt=3.414150e-09
parameters dcitn_hvt=0.0000e+000
parameters dwcitn_hvt=0.0000e+000
parameters dnfactorn_hvt=0.0000e+000
parameters dlnfactorn_hvt=0.0000e+000
parameters dwnfactorn_hvt=0.0000e+000
parameters dpnfactorn_hvt=0.0000e+000
parameters dvoffn_hvt=0.0000e+000
parameters dpclmn_hvt=0.0000e+000
parameters dwpclmn_hvt=0.0000e+000
parameters dvsatn_hvt=0.0000e+000
parameters dwvsatn_hvt=0.0000e+000
parameters deta0n_hvt=0.0000e+000
parameters dweta0n_hvt=0.0000e+000
parameters du0n_hvt=0.0000e+000
parameters dlagsn_hvt=0.0000e+000
parameters dpagsn_hvt=0.0000e+000
parameters da0n_hvt=0.0000e+000
parameters dwa0n_hvt=0.0000e+000
parameters dpkt1n_hvt=0.0000e+000
parameters dpkt2n_hvt=0.0000e+000
parameters ddlcp_hvt=3.655840e-09
parameters drdswp_hvt=0.0000e+000
parameters dwvsatp_hvt=0.0000e+000
parameters deta0p_hvt=0.0000e+000
parameters dweta0p_hvt=0.0000e+000
parameters dk2p_hvt=0.0000e+000
parameters dpk2p_hvt=0.0000e+000
parameters dnfactorp_hvt=0.0000e+000
parameters dlnfactorp_hvt=0.0000e+000
parameters dwnfactorp_hvt=0.0000e+000
parameters dpnfactorp_hvt=0.0000e+000
parameters dvoffp_hvt=0.0000e+000
parameters dpclmp_hvt=0.0000e+000
parameters dwpclmp_hvt=0.0000e+000
parameters du0p_hvt=0.0000e+000
parameters dcitp_hvt=0.0000e+000
parameters dwcitp_hvt=0.0000e+000
parameters dpagsp_hvt=0.0000e+000
parameters da0p_hvt=0.0000e+000
parameters datp_hvt=0.0000e+000
parameters dub1p_hvt=0.0000e+000
parameters dlub1p_hvt=0.0000e+000
parameters dlua1p_hvt=0.0000e+000
parameters dluc1p_hvt=0.0000e+000
parameters dpkt1p_hvt=0.0000e+000
parameters dxlp_hvt=((ori_dxlp_hvt + 6.9e-9) + sqrt((ori_dxlp_hvt + 6.9e-9) * (ori_dxlp_hvt 
+ + 6.9e-9) + 1e-24) - 6.9e-9 - sqrt(6.9e-9 * 6.9e-9 + 1e-24)) * 0.5
parameters dlpclmp_hvt=((ori_dlpclmp_hvt + 2.5e-8) + sqrt((ori_dlpclmp_hvt + 2.5e-8) 
+ * (ori_dlpclmp_hvt + 2.5e-8) + 1e-22) - 2.5e-8 - sqrt(2.5e-8 * 2.5e-8 + 1e-22)) 
+ * 0.5
parameters dppclmp_hvt=((ori_dppclmp_hvt + 1.5e-15) + sqrt((ori_dppclmp_hvt + 1.5e-15) 
+ * (ori_dppclmp_hvt + 1.5e-15) + 1e-40) - 1.5e-15 - sqrt(1.5e-15 * 1.5e-15 + 1e-40)) 
+ * 0.5
parameters dpvsatp_hvt=((ori_dpvsatp_hvt) + sqrt((ori_dpvsatp_hvt) * (ori_dpvsatp_hvt) 
+ + 1e-30) - (1e-15)) * 0.5
parameters dlvsatp_hvt=((ori_dlvsatp_hvt + 7.7e-4) + sqrt((ori_dlvsatp_hvt + 7.7e-4) 
+ * (ori_dlvsatp_hvt + 7.7e-4) + 1e-20) - 7.7e-4 - sqrt(7.7e-4 * 7.7e-4 + 1e-20)) 
+ * 0.5
parameters b1fn_hvt=-1.1E+41   
parameters b2fn_hvt=-2.2E+16   
parameters b3fn_hvt=-7.5E+7 
parameters a1fn_hvt=3.875E+42 
parameters a2fn_hvt=0   
parameters a3fn_hvt=-8E+7  
parameters c1fn_hvt=2.5E+41  
parameters c2fn_hvt=5E+16    
parameters c3fn_hvt=1.7E+8   
parameters b1fp_hvt=-1.163E+42    
parameters b2fp_hvt=0    
parameters b3fp_hvt=-4.25E+9    
parameters a1fp_hvt=2.133E+43    
parameters a2fp_hvt=0    
parameters a3fp_hvt=3.163E+11   
parameters c1fp_hvt=2.35E+42    
parameters c2fp_hvt=3E+13   
parameters c3fp_hvt=1.75E+10   
parameters noian_hvt=a1fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b1fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c1fn_hvt
parameters noibn_hvt=a2fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b2fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c2fn_hvt
parameters noicn_hvt=a3fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b3fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c3fn_hvt
parameters noiap_hvt=a1fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b1fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c1fp_hvt
parameters noibp_hvt=a2fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b2fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c2fp_hvt
parameters noicp_hvt=a3fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b3fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c3fp_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_hvt
endsection mc_hvt
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_lvt
parameters a1_lvt=par1 * 5.8169e+000 * 3 / 1.97
parameters a2_lvt=par2 * 4.5346e+000 * 3 / 1.97
parameters a3_lvt=par3 * 2.5378e+000 * 3 / 1.97
parameters a4_lvt=par4 * 2.2570e+000 * 3 / 1.97
parameters a5_lvt=par5 * 1.0272e+000 * 3 / 1.97
parameters ff_flag_lvt=0.0000e+000 + (4.3774e-002) * a1_lvt + (1.7457e-002) * a2_lvt 
+ + (9.3530e-002) * a3_lvt + (1.5210e-002) * a4_lvt
parameters sf_flag_lvt=0.0000e+000 + ( - 1.3691e-002) * a1_lvt + (5.9372e-002) * 
+ a2_lvt + ( - 3.5720e-002) * a3_lvt + ( - 2.1376e-002) * a4_lvt
parameters fs_flag_lvt=0.0000e+000 + (1.5275e-002) * a1_lvt + ( - 5.8961e-002) * 
+ a2_lvt + ( - 3.7872e-002) * a3_lvt + ( - 7.8143e-003) * a4_lvt
parameters toxn_lvt=2.0000e-009 + ( - 6.1986e-012) * a1_lvt + ( - 2.8659e-012) * 
+ a2_lvt + (2.4346e-012) * a3_lvt + ( - 1.2091e-011) * a4_lvt
parameters dxwn_lvt=0.0000e+000 + (1.0664e-009) * a1_lvt + ( - 5.5926e-010) * a2_lvt 
+ + ( - 4.9232e-010) * a3_lvt + (1.7735e-009) * a4_lvt
parameters dxln_lvt=0.0000e+000 + ( - 3.7112e-010) * a1_lvt + ( - 1.4812e-010) * 
+ a2_lvt + ( - 5.1079e-011) * a3_lvt + (2.7852e-011) * a4_lvt
parameters dvthn_lvt=0.0000e+000 + ( - 3.1333e-003) * a1_lvt + (1.6990e-003) * a2_lvt 
+ + ( - 7.1610e-004) * a3_lvt + (1.1430e-003) * a4_lvt
parameters dlvthn_lvt=0.0000e+000 + ( - 5.7643e-011) * a1_lvt + (3.1763e-011) * 
+ a2_lvt + ( - 1.4154e-011) * a3_lvt + (2.0709e-011) * a4_lvt
parameters dwvthn_lvt=0.0000e+000 + ( - 2.3261e-010) * a1_lvt + (1.4908e-010) * 
+ a2_lvt + ( - 9.7575e-011) * a3_lvt + (7.0412e-011) * a4_lvt
parameters dpvthn_lvt=0.0000e+000 + ( - 2.1048e-017) * a1_lvt + (8.5009e-018) * 
+ a2_lvt + (8.2560e-019) * a3_lvt + (9.5107e-018) * a4_lvt
parameters cjn_lvt=1.2070e-003 + ( - 9.5542e-006) * a1_lvt + (5.0889e-006) * a2_lvt 
+ + ( - 1.9259e-006) * a3_lvt + (3.5711e-006) * a4_lvt
parameters cjswn_lvt=6.4000e-011 + ( - 5.0898e-013) * a1_lvt + (2.6890e-013) * a2_lvt 
+ + ( - 1.0260e-013) * a3_lvt + (1.9014e-013) * a4_lvt
parameters cjswgn_lvt=2.9700e-010 + ( - 2.3629e-012) * a1_lvt + (1.2475e-012) * 
+ a2_lvt + ( - 4.7633e-013) * a3_lvt + (8.8265e-013) * a4_lvt
parameters cgon_lvt=6.331500e-11 + (5.3265e-013) * a1_lvt + (2.4627e-013) * a2_lvt 
+ + ( - 2.0920e-013) * a3_lvt + (1.0390e-012) * a4_lvt
parameters cgln_lvt=9.587230e-13 + (5.3292e-016) * a1_lvt + (2.4639e-016) * a2_lvt 
+ + ( - 2.0930e-016) * a3_lvt + (1.0395e-015) * a4_lvt
parameters cfn_lvt=1.3900e-010 + (9.0397e-013) * a1_lvt + (4.1794e-013) * a2_lvt 
+ + ( - 3.5504e-013) * a3_lvt + (1.7632e-012) * a4_lvt + 4.1e-11 * ccoflag_lvt
parameters drdswn_lvt=0.0000e+000 + (4.7835e-002) * a1_lvt + (1.8379e-002) * a2_lvt 
+ + ( - 7.4833e-002) * a3_lvt + ( - 4.5336e-002) * a4_lvt
parameters dlu0n_lvt=0.0000e+000 + (2.2722e-011) * a1_lvt + ( - 1.2005e-011) * a2_lvt 
+ + (4.5805e-012) * a3_lvt + ( - 8.4882e-012) * a4_lvt
parameters dleta0n_lvt=0.0000e+000 + (8.8874e-011) * a1_lvt + ( - 4.8771e-011) * 
+ a2_lvt + ( - 1.1747e-011) * a3_lvt + ( - 3.8528e-011) * a4_lvt
parameters dpeta0n_lvt=0.0000e+000 + (2.6639e-017) * a1_lvt + ( - 1.0934e-017) * 
+ a2_lvt + ( - 2.3644e-018) * a3_lvt + ( - 1.2250e-017) * a4_lvt
parameters dlvsatn_lvt=0.0000e+000 + (7.6536e-006) * a1_lvt + (2.9406e-006) * a2_lvt 
+ + ( - 1.1973e-005) * a3_lvt + ( - 7.2538e-006) * a4_lvt
parameters dpvsatn_lvt=0.0000e+000 + ( - 1.9733e-012) * a1_lvt + (2.3520e-012) * 
+ a2_lvt + ( - 2.9321e-012) * a3_lvt + ( - 8.6863e-014) * a4_lvt
parameters ntoxn_lvt=1.0000e+000 + (4.5706e-002) * a1_lvt + (2.0870e-002) * a2_lvt 
+ + ( - 2.1874e-002) * a3_lvt + (7.9446e-002) * a4_lvt
parameters dk2n_lvt=0.0000e+000 + ( - 1.9362e-003) * a1_lvt + (1.1015e-003) * a2_lvt 
+ + ( - 5.4236e-004) * a3_lvt + (6.7384e-004) * a4_lvt
parameters dlk2n_lvt=0.0000e+000 + (2.6071e-011) * a1_lvt + ( - 1.0718e-011) * a2_lvt 
+ + ( - 6.5783e-013) * a3_lvt + ( - 1.1662e-011) * a4_lvt
parameters dwk2n_lvt=0.0000e+000 + ( - 1.8716e-010) * a1_lvt + (1.2507e-010) * a2_lvt 
+ + ( - 8.8414e-011) * a3_lvt + (5.3436e-011) * a4_lvt
parameters dpk2n_lvt=0.0000e+000 + ( - 1.1062e-017) * a1_lvt + (7.1539e-018) * a2_lvt 
+ + ( - 4.7643e-018) * a3_lvt + (3.3084e-018) * a4_lvt
parameters dagsn_lvt=0.0000e+000 + ( - 2.5055e-002) * a1_lvt + (1.6292e-002) * a2_lvt 
+ + ( - 1.0964e-002) * a3_lvt + (7.4367e-003) * a4_lvt
parameters dlcitn_lvt=0.0000e+000 + (3.2889e-012) * a1_lvt + ( - 3.9201e-012) * 
+ a2_lvt + (4.8868e-012) * a3_lvt + (1.4477e-013) * a4_lvt
parameters dpcitn_lvt=0.0000e+000 + ( - 5.8721e-019) * a1_lvt + (6.2451e-019) * 
+ a2_lvt + ( - 7.2660e-019) * a3_lvt + (2.1594e-020) * a4_lvt
parameters dlagsn_lvt=0.0000e+000 + ( - 5.3026e-009) * a1_lvt + (2.8262e-010) * 
+ a2_lvt + (7.5219e-009) * a3_lvt + (4.2906e-009) * a4_lvt
parameters dla0n_lvt=0.0000e+000 + (2.5420e-008) * a1_lvt + (4.5569e-009) * a2_lvt 
+ + (1.1791e-008) * a3_lvt + ( - 1.2724e-008) * a4_lvt
parameters dwa0n_lvt=0.0000e+000 + ( - 2.6131e-008) * a1_lvt + (1.3805e-008) * a2_lvt 
+ + ( - 5.2676e-009) * a3_lvt + (9.7614e-009) * a4_lvt
parameters dpa0n_lvt=0.0000e+000 + (2.7028e-015) * a1_lvt + ( - 1.0350e-015) * a2_lvt 
+ + ( - 2.1545e-016) * a3_lvt + ( - 1.2568e-015) * a4_lvt
parameters dlatn_lvt=0.0000e+000 + ( - 1.3155e-005) * a1_lvt + (1.5680e-005) * a2_lvt 
+ + ( - 1.9547e-005) * a3_lvt + ( - 5.7908e-007) * a4_lvt
parameters dpagsn_lvt=0.0000e+000 + ( - 3.9466e-015) * a1_lvt + (4.7041e-015) * 
+ a2_lvt + ( - 5.8641e-015) * a3_lvt + ( - 1.7373e-016) * a4_lvt
parameters dwagsn_lvt=0.0000e+000 + (7.4249e-009) * a1_lvt + ( - 6.9976e-009) * 
+ a2_lvt + (7.9911e-009) * a3_lvt + ( - 7.8820e-010) * a4_lvt
parameters dlubn_lvt=0.0000e+000 + (2.8403e-027) * a1_lvt + ( - 1.5006e-027) * a2_lvt 
+ + (5.7256e-028) * a3_lvt + ( - 1.0610e-027) * a4_lvt
parameters toxp_lvt=2.2000e-009 + ( - 6.1986e-012) * a1_lvt + ( - 2.8659e-012) * 
+ a2_lvt + (2.4346e-012) * a3_lvt + ( - 1.2091e-011) * a4_lvt
parameters dxwp_lvt=0.0000e+000 + (6.4156e-010) * a1_lvt + (8.01765e-010) * a2_lvt 
+ + ( - 5.4448e-010) * a3_lvt + (2.4301e-009) * a4_lvt
parameters dvthp_lvt=0.0000e+000 + (2.1241e-003) * a1_lvt + (4.2304e-003) * a2_lvt 
+ + (1.0191e-003) * a3_lvt + ( - 2.0259e-003) * a4_lvt
parameters dlvthp_lvt=0.0000e+000 + (1.2446e-011) * a1_lvt + ( - 5.3575e-012) * 
+ a2_lvt + ( - 3.2365e-011) * a3_lvt + ( - 1.1758e-011) * a4_lvt
parameters dwvthp_lvt=0.0000e+000 + (1.5007e-010) * a1_lvt + (3.4736e-010) * a2_lvt 
+ + (1.3364e-010) * a3_lvt + ( - 1.4332e-010) * a4_lvt
parameters dpvthp_lvt=0.0000e+000 + (1.2861e-017) * a1_lvt + (2.4724e-017) * a2_lvt 
+ + (5.0374e-018) * a3_lvt + ( - 1.2264e-017) * a4_lvt
parameters cjp_lvt=1.0200e-003 + ( - 4.7836e-006) * a1_lvt + ( - 9.2253e-006) * 
+ a2_lvt + ( - 1.9111e-006) * a3_lvt + (4.5614e-006) * a4_lvt
parameters cjswp_lvt=6.4000e-011 + ( - 3.0135e-013) * a1_lvt + ( - 5.7930e-013) 
+ * a2_lvt + ( - 1.1803e-013) * a3_lvt + (2.8735e-013) * a4_lvt
parameters cjswgp_lvt=1.9500e-010 + ( - 9.1837e-013) * a1_lvt + ( - 1.7651e-012) 
+ * a2_lvt + ( - 3.5121e-013) * a3_lvt + (8.7854e-013) * a4_lvt
parameters cgop_lvt=3.241690e-11 + (3.3526e-013) * a1_lvt + (1.5501e-013) * a2_lvt 
+ + ( - 1.3167e-013) * a3_lvt + (6.5393e-013) * a4_lvt
parameters cglp_lvt=7.368500e-11 + (5.3433e-013) * a1_lvt + (2.4705e-013) * a2_lvt 
+ + ( - 2.0987e-013) * a3_lvt + (1.0422e-012) * a4_lvt
parameters cfp_lvt=1.3800e-010 + (9.0397e-013) * a1_lvt + (4.1794e-013) * a2_lvt 
+ + ( - 3.5504e-013) * a3_lvt + (1.7632e-012) * a4_lvt + 4.6e-11 * ccoflag_lvt
parameters drdswp_lvt=0.0000e+000 + (2.3917e-001) * a1_lvt + (9.1895e-002) * a2_lvt 
+ + ( - 3.7417e-001) * a3_lvt + ( - 2.2668e-001) * a4_lvt
parameters dlu0p_lvt=0.0000e+000 + (3.8861e-013) * a1_lvt + (2.2186e-012) * a2_lvt 
+ + (2.0236e-012) * a3_lvt + ( - 3.7607e-013) * a4_lvt
parameters dpu0p_lvt=0.0000e+000 + (2.0180e-019) * a1_lvt + (3.8793e-019) * a2_lvt 
+ + (7.9039e-020) * a3_lvt + ( - 1.9242e-019) * a4_lvt
parameters dleta0p_lvt=0.0000e+000 + (6.3305e-011) * a1_lvt + (8.1228e-011) * a2_lvt 
+ + ( - 2.6668e-011) * a3_lvt + ( - 6.0212e-011) * a4_lvt
parameters dpeta0p_lvt=0.0000e+000 + (1.8689e-019) * a1_lvt + ( - 1.4802e-018) * 
+ a2_lvt + ( - 2.2660e-018) * a3_lvt + ( - 1.7131e-019) * a4_lvt
parameters dlvsatp_lvt=0.0000e+000 + ( - 1.4612e-005) * a1_lvt + ( - 2.1128e-005) 
+ * a2_lvt + ( - 5.1831e-006) * a3_lvt + (1.2285e-005) * a4_lvt
parameters dpvsatp_lvt=0.0000e+000 + ( - 3.0483e-013) * a1_lvt + ( - 4.4639e-012) 
+ * a2_lvt + ( - 3.0560e-012) * a3_lvt + (6.9429e-013) * a4_lvt
parameters ntoxp_lvt=1.0000e+000 + (7.2337e-002) * a1_lvt + (3.2959e-002) * a2_lvt 
+ + ( - 3.5697e-002) * a3_lvt + (1.2307e-001) * a4_lvt
parameters dlk2p_lvt=0.0000e+000 + ( - 3.1690e-011) * a1_lvt + ( - 5.3561e-011) 
+ * a2_lvt + ( - 3.0552e-012) * a3_lvt + (3.0190e-011) * a4_lvt
parameters dlagsp_lvt=0.0000e+000 + ( - 6.2333e-009) * a1_lvt + ( - 7.5682e-009) 
+ * a2_lvt + (3.1727e-009) * a3_lvt + (5.9272e-009) * a4_lvt
parameters dwagsp_lvt=0.0000e+000 + ( - 1.4816e-011) * a1_lvt + ( - 5.1789e-009) 
+ * a2_lvt + ( - 6.5556e-009) * a3_lvt + (3.3442e-011) * a4_lvt
parameters dpagsp_lvt=0.0000e+000 + ( - 1.2093e-015) * a1_lvt + ( - 4.6778e-016) 
+ * a2_lvt + (6.8750e-015) * a3_lvt + (2.1189e-015) * a4_lvt
parameters dla0p_lvt=0.0000e+000 + (4.1260e-009) * a1_lvt + ( - 5.6719e-009) * a2_lvt 
+ + (7.5898e-009) * a3_lvt + (6.5604e-010) * a4_lvt
parameters dpa0p_lvt=0.0000e+000 + (5.7484e-017) * a1_lvt + (2.0934e-015) * a2_lvt 
+ + ( - 6.1444e-016) * a3_lvt + ( - 6.7831e-016) * a4_lvt
parameters dlpclmp_lvt=0.0000e+000 + ( - 4.3051e-011) * a1_lvt + ( - 1.6541e-011) 
+ * a2_lvt + (6.7350e-011) * a3_lvt + (4.0803e-011) * a4_lvt
parameters dlcitp_lvt=0.0000e+000 + ( - 1.9430e-013) * a1_lvt + ( - 1.1093e-012) 
+ * a2_lvt + ( - 1.0118e-012) * a3_lvt + (1.8803e-013) * a4_lvt
parameters dlkt1p_lvt=0.0000e+000 + (1.9430e-011) * a1_lvt + (1.1093e-010) * a2_lvt 
+ + (1.0118e-010) * a3_lvt + ( - 1.8803e-011) * a4_lvt
parameters dlubp_lvt=0.0000e+000 + (2.9145e-028) * a1_lvt + (1.6639e-027) * a2_lvt 
+ + (1.5177e-027) * a3_lvt + ( - 2.8205e-028) * a4_lvt
parameters ori_dppclmp_lvt=0.0000e+000 + (2.3150e-018) * a1_lvt + (6.3021e-017) 
+ * a2_lvt + ( - 7.7294e-018) * a3_lvt + ( - 1.8639e-017) * a4_lvt
parameters dppclmp_lvt=((ori_dppclmp_lvt + 0) + sqrt((ori_dppclmp_lvt + 0) * (ori_dppclmp_lvt 
+ + 0) + 1e-34) - 0 - sqrt(0 * 0 + 1e-34)) * 0.5
parameters ori_ss_flag_lvt=0.0000e+000 + ( - 4.7835e-002) * a1_lvt + ( - 1.8379e-002) 
+ * a2_lvt + (7.4833e-002) * a3_lvt + (4.5336e-002) * a4_lvt
parameters ss_flag_lvt=((ori_ss_flag_lvt - 1.15) - sqrt((ori_ss_flag_lvt - 1.15) 
+ * (ori_ss_flag_lvt - 1.15) + 1e-6) + 1.15 + sqrt(1.15 * 1.15 + 1e-6)) * 0.5
parameters ori_dxlp_lvt=0.0000e+000 + ( - 3.8984e-010) * a1_lvt + ( - 1.6720e-010) 
+ * a2_lvt + (4.3758e-011) * a3_lvt + ( - 3.4277e-010) * a4_lvt
parameters dxlp_lvt=((ori_dxlp_lvt + 7.9e-9) + sqrt((ori_dxlp_lvt + 7.9e-9) * (ori_dxlp_lvt 
+ + 7.9e-9) + 1e-24) - 7.9e-9 - sqrt(7.9e-9 * 7.9e-9 + 1e-24)) * 0.5
parameters ddlcn_lvt=3.303970e-09
parameters dnfactorn_lvt=0.0000e+000
parameters dlnfactorn_lvt=0.0000e+000
parameters dwnfactorn_lvt=0.0000e+000
parameters dpnfactorn_lvt=0.0000e+000
parameters du0n_lvt=0.0000e+000
parameters dwu0n_lvt=0.0000e+000
parameters dpu0n_lvt=0.0000e+000
parameters deta0n_lvt=0.0000e+000
parameters dweta0n_lvt=0.0000e+000
parameters dvsatn_lvt=0.0000e+000
parameters dwvsatn_lvt=0.0000e+000
parameters dpclmn_lvt=0.0000e+000
parameters dppclmn_lvt=0.0000e+000
parameters dwcitn_lvt=0.0000e+000
parameters datn_lvt=0.0000e+000
parameters dwatn_lvt=0.0000e+000
parameters dpatn_lvt=0.0000e+000
parameters dlkt1n_lvt=0.0000e+000
parameters dwkt1n_lvt=0.0000e+000
parameters dpkt1n_lvt=0.0000e+000
parameters dluan_lvt=0.0000e+000
parameters dpuan_lvt=0.0000e+000
parameters dpubn_lvt=0.0000e+000
parameters ddlcp_lvt=6.387060e-09
parameters dnfactorp_lvt=0.0000e+000
parameters dlnfactorp_lvt=0.0000e+000
parameters dwnfactorp_lvt=0.0000e+000
parameters dpnfactorp_lvt=0.0000e+000
parameters du0p_lvt=0.0000e+000
parameters dwu0p_lvt=0.0000e+000
parameters dvoffp_lvt=0.0000e+000
parameters dlvoffp_lvt=0.0000e+000
parameters dwvoffp_lvt=0.0000e+000
parameters dpvoffp_lvt=0.0000e+000
parameters deta0p_lvt=0.0000e+000
parameters dweta0p_lvt=0.0000e+000
parameters dvsatp_lvt=0.0000e+000
parameters dwvsatp_lvt=0.0000e+000
parameters dk2p_lvt=0.0000e+000
parameters dwk2p_lvt=0.0000e+000
parameters dpk2p_lvt=0.0000e+000
parameters dagsp_lvt=0.0000e+000
parameters da0p_lvt=0.0000e+000
parameters dwa0p_lvt=0.0000e+000
parameters dpclmp_lvt=0.0000e+000
parameters dwpclmp_lvt=0.0000e+000
parameters duc1p_lvt=0.0000e+000
parameters ducp_lvt=0.0000e+000
parameters dketap_lvt=0.0000e+000
parameters dlketap_lvt=0.0000e+000
parameters dwketap_lvt=0.0000e+000
parameters dpketap_lvt=0.0000e+000
parameters dwcitp_lvt=0.0000e+000
parameters dpcitp_lvt=0.0000e+000
parameters dlatp_lvt=0.0000e+000
parameters dwatp_lvt=0.0000e+000
parameters dpatp_lvt=0.0000e+000
parameters dwkt1p_lvt=0.0000e+000
parameters dpkt1p_lvt=0.0000e+000
parameters dluap_lvt=0.0000e+000
parameters dpuap_lvt=0.0000e+000
parameters dpubp_lvt=0.0000e+000
parameters b1fn_lvt=-1.363E+41  
parameters b2fn_lvt=0   
parameters b3fn_lvt=-3.721E+7  
parameters a1fn_lvt=1.598E+42  
parameters a2fn_lvt=0   
parameters a3fn_lvt=2.5E+8   
parameters c1fn_lvt=3.050E+41   
parameters c2fn_lvt=5E+12   
parameters c3fn_lvt=7.5E+7  
parameters b1fp_lvt=-4.5E+41   
parameters b2fp_lvt=1.485E+15    
parameters b3fp_lvt=-9.5E+9
parameters a1fp_lvt=1.69E+43   
parameters a2fp_lvt=1.485E+15    
parameters a3fp_lvt=3.5E+10    
parameters c1fp_lvt=1.2E+42  
parameters c2fp_lvt=3E+13    
parameters c3fp_lvt=2E+10   
parameters noian_lvt=a1fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b1fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c1fn_lvt
parameters noibn_lvt=a2fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b2fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c2fn_lvt
parameters noicn_lvt=a3fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b3fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c3fn_lvt
parameters noiap_lvt=a1fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b1fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c1fp_lvt
parameters noibp_lvt=a2fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b2fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c2fp_lvt
parameters noicp_lvt=a3fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b3fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c3fp_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_lvt
endsection mc_lvt
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_18
parameters a1_18=par6 * 4.1285 * 3 / 1.85
parameters a2_18=par7 * 3.581 * 3 / 1.85
parameters a3_18=par8 * 2.9155 * 3 / 1.85
parameters a4_18=par9 * 0.7952 * 3 / 1.85
parameters toxn_18=5.6e-09 + ( - 2.5615e-011) * a1_18 + (6.1353e-011) * a2_18 + 
+ ( - 7.8327e-012) * a3_18 + (6.4438e-012) * a4_18
parameters dxln_18=0 + ( - 1.0858e-009) * a1_18 + (1.2881e-009) * a2_18 + ( - 1.8628e-010) 
+ * a3_18 + (3.1565e-011) * a4_18
parameters dxwn_18=0 + (1.073e-009) * a1_18 + ( - 2.6264e-009) * a2_18 + ( - 2.052e-009) 
+ * a3_18 + ( - 4.6046e-010) * a4_18
parameters cjn_18=0.001051 + ( - 1.235e-005) * a1_18 + ( - 3.0305e-006) * a2_18 
+ + (1.155e-005) * a3_18 + ( - 2.1341e-006) * a4_18
parameters cjswn_18=1.355e-10 + ( - 1.5904e-012) * a1_18 + ( - 3.9162e-013) * a2_18 
+ + (1.4891e-012) * a3_18 + ( - 2.592e-013) * a4_18
parameters cjswgn_18=1.621e-10 + ( - 1.8941e-012) * a1_18 + ( - 4.7195e-013) * a2_18 
+ + (1.7821e-012) * a3_18 + ( - 3.091e-013) * a4_18
parameters cgon_18=3.855e-11 + (2.306e-013) * a1_18 + ( - 5.5195e-013) * a2_18 + 
+ (7.0472e-014) * a3_18 + ( - 5.7939e-014) * a4_18
parameters cgln_18=2.513e-10 + (1.5032e-012) * a1_18 + ( - 3.598e-012) * a2_18 + 
+ (4.5938e-013) * a3_18 + ( - 3.777e-013) * a4_18
parameters dvthn_18=0 + ( - 0.0063639) * a1_18 + ( - 0.0015722) * a2_18 + (0.0059665) 
+ * a3_18 + ( - 0.0010375) * a4_18
parameters dlvthn_18=0 + (1.7513e-010) * a1_18 + ( - 6.9137e-010) * a2_18 + ( - 
+ 3.1398e-010) * a3_18 + ( - 1.2413e-010) * a4_18
parameters dwvthn_18=0 + ( - 8.3735e-011) * a1_18 + ( - 2.0686e-011) * a2_18 + (7.8506e-011) 
+ * a3_18 + ( - 1.3652e-011) * a4_18
parameters dpvthn_18=0 + ( - 4.9068e-016) * a1_18 + ( - 3.2312e-017) * a2_18 + (4.9274e-016) 
+ * a3_18 + (1.0499e-018) * a4_18
parameters dlu0n_18=0 + (5.0241e-011) * a1_18 + (1.2412e-011) * a2_18 + ( - 4.7104e-011) 
+ * a3_18 + (8.1911e-012) * a4_18
parameters dwu0n_18=0 + (1.9935e-011) * a1_18 + (2.664e-012) * a2_18 + ( - 1.5509e-011) 
+ * a3_18 + (1.8423e-011) * a4_18
parameters dpu0n_18=0 + ( - 1.037e-017) * a1_18 + ( - 7.0838e-018) * a2_18 + (1.6087e-017) 
+ * a3_18 + (2.8655e-017) * a4_18
parameters dcitn_18=0 + ( - 1.6747e-005) * a1_18 + ( - 4.1373e-006) * a2_18 + (1.5701e-005) 
+ * a3_18 + ( - 2.7304e-006) * a4_18
parameters dwcitn_18=0 + (1.6747e-011) * a1_18 + (4.1373e-012) * a2_18 + ( - 1.5701e-011) 
+ * a3_18 + (2.7304e-012) * a4_18
parameters deta0n_18=0 + ( - 0.0051851) * a1_18 + ( - 0.0035419) * a2_18 + (0.0080433) 
+ * a3_18 + (0.014327) * a4_18
parameters cfn_18=9.000000e-011 + (5.3791e-013) * a1_18 + ( - 1.2884e-012) * a2_18 
+ + (1.6449e-013) * a3_18 + ( - 1.3532e-013) * a4_18 + 2.4e-11 * ccoflag_18
parameters dxlp_18=0 + ( - 9.9299e-010) * a1_18 + (1.5909e-009) * a2_18 + ( - 2.162e-010) 
+ * a3_18 + (1.0486e-010) * a4_18
parameters dxwp_18=0 + (9.7619e-010) * a1_18 + ( - 2.2819e-009) * a2_18 + (2.6786e-009) 
+ * a3_18 + ( - 5.5037e-011) * a4_18
parameters toxp_18=5.9e-09 + ( - 2.5615e-011) * a1_18 + (6.1353e-011) * a2_18 + 
+ ( - 7.8327e-012) * a3_18 + (6.4438e-012) * a4_18
parameters cjp_18=0.00112 + ( - 1.2935e-005) * a1_18 + ( - 6.2524e-006) * a2_18 
+ + ( - 1.2293e-005) * a3_18 + ( - 4.5409e-006) * a4_18
parameters cjswp_18=9e-11 + ( - 1.0436e-012) * a1_18 + ( - 5.0072e-013) * a2_18 
+ + ( - 9.8822e-013) * a3_18 + ( - 3.6538e-013) * a4_18
parameters cjswgp_18=1.7e-10 + ( - 1.9713e-012) * a1_18 + ( - 9.458e-013) * a2_18 
+ + ( - 1.8666e-012) * a3_18 + ( - 6.9016e-013) * a4_18
parameters cgop_18=5.23324e-11 + (3.1281e-013) * a1_18 + ( - 7.4919e-013) * a2_18 
+ + (9.5644e-014) * a3_18 + ( - 7.8129e-014) * a4_18
parameters cglp_18=2.68907e-10 + (1.6071e-012) * a1_18 + ( - 3.8496e-012) * a2_18 
+ + (4.9145e-013) * a3_18 + ( - 4.0371e-013) * a4_18
parameters dvthp_18=0 + (0.0030887) * a1_18 + (0.0042809) * a2_18 + (0.0012288) 
+ * a3_18 + (0.0030287) * a4_18
parameters dlvthp_18=0 + (2.7388e-010) * a1_18 + (7.0657e-010) * a2_18 + ( - 3.6515e-011) 
+ * a3_18 + (3.0717e-010) * a4_18
parameters dwvthp_18=0 + (7.3006e-010) * a1_18 + ( - 7.2584e-011) * a2_18 + (1.3037e-009) 
+ * a3_18 + ( - 1.3163e-009) * a4_18
parameters dpvthp_18=0 + (2.9312e-016) * a1_18 + (9.8592e-017) * a2_18 + (2.3799e-016) 
+ * a3_18 + (3.0669e-016) * a4_18
parameters dlu0p_18=0 + (1.0189e-012) * a1_18 + (1.0894e-012) * a2_18 + (1.5301e-012) 
+ * a3_18 + ( - 2.5585e-012) * a4_18
parameters dwu0p_18=0 + ( - 1.6566e-011) * a1_18 + ( - 7.9479e-012) * a2_18 + ( 
+ - 1.5686e-011) * a3_18 + ( - 5.7997e-012) * a4_18
parameters dlcitp_18=0 + ( - 2.0377e-012) * a1_18 + ( - 2.1789e-012) * a2_18 + ( 
+ - 3.0602e-012) * a3_18 + (5.1171e-012) * a4_18
parameters dpvsatp_18=0 + (1.414e-010) * a1_18 + ( - 4.5798e-011) * a2_18 + (1.8571e-010) 
+ * a3_18 + (3.1549e-011) * a4_18
parameters dleta0p_18=0 + (3.9508e-009) * a1_18 + (1.2949e-009) * a2_18 + (3.1757e-009) 
+ * a3_18 + (4.2985e-009) * a4_18
parameters dpa0p_18=0 + ( - 1.8735e-014) * a1_18 + ( - 5.3852e-015) * a2_18 + ( 
+ - 1.4349e-014) * a3_18 + ( - 2.4051e-014) * a4_18
parameters cfp_18=9.000000e-011 + (5.3791e-013) * a1_18 + ( - 1.2884e-012) * a2_18 
+ + (1.6449e-013) * a3_18 + ( - 1.3532e-013) * a4_18 + 2.4e-11 * ccoflag_18
parameters dlkt1p_18=0 + (5.0943e-010) * a1_18 + (5.4472e-010) * a2_18 + (7.6504e-010) 
+ * a3_18 + ( - 1.2793e-009) * a4_18
parameters dlcn_18=4.654e-08
parameters du0n_18=0
parameters dlcitn_18=0
parameters dpcitn_18=0
parameters dleta0n_18=0
parameters dweta0n_18=0
parameters dpeta0n_18=0
parameters dk2n_18=0
parameters dlk2n_18=0
parameters dwk2n_18=0
parameters dpk2n_18=0
parameters dk2_18=0
parameters dlcp_18=5.49049e-08
parameters du0p_18=0
parameters dpu0p_18=0
parameters dnfactorp_18=0
parameters dlnfactorp_18=0
parameters dwnfactorp_18=0
parameters dpnfactorp_18=0
parameters dcitp_18=0
parameters dwcitp_18=0
parameters dpcitp_18=0
parameters dvsatp_18=0
parameters dlvsatp_18=0
parameters dwvsatp_18=0
parameters dpeta0p_18=0
parameters dla0p_18=0
parameters dwa0p_18=0
parameters b1fn_18=-7.25E+40
parameters b2fn_18=4.75E+22 
parameters b3fn_18=-1.925E+8   
parameters a1fn_18=8.975E+41 
parameters a2fn_18=4.75E+22  
parameters a3fn_18=4.825e+8  
parameters c1fn_18=2.05E+41  
parameters c2fn_18=4E+10    
parameters c3fn_18=5.35e+8 
parameters b1fp_18=-3.55E+41   
parameters b2fp_18=0    
parameters b3fp_18=-2.225E+9    
parameters a1fp_18=1.573E+42    
parameters a2fp_18=0  
parameters a3fp_18=4.825E+9 
parameters c1fp_18=8.05E+41     
parameters c2fp_18=4E+10  
parameters c3fp_18=5.35E+9  
parameters noian_18=a1fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b1fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c1fn_18
parameters noibn_18=a2fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b2fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c2fn_18
parameters noicn_18=a3fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b3fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c3fn_18
parameters noiap_18=a1fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b1fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c1fp_18
parameters noibp_18=a2fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b2fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c2fp_18
parameters noicp_18=a3fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b3fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c3fp_18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_18
endsection mc_18
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25
parameters a1_25=par6 * 4.3219e+000 * 3 / 2.1
parameters a2_25=par7 * 3.4010e+000 * 3 / 2.1
parameters a3_25=par8 * 2.8997e+000 * 3 / 2.1
parameters toxn_25=5.6000e-009 + ( - 5.4716e-012) * a1_25 + ( - 7.0317e-011) * a2_25 
+ + ( - 1.6227e-011) * a3_25
parameters dxln_25=0.0000e+000 + ( - 7.9271e-011) * a1_25 + ( - 2.2385e-009) * a2_25 
+ + ( - 5.1409e-010) * a3_25
parameters dxwn_25=0.0000e+000 + (1.9090e-010) * a1_25 + (2.4225e-009) * a2_25 + 
+ (2.9937e-009) * a3_25
parameters cjn_25=1.0510e-003 + (1.3228e-005) * a1_25 + ( - 6.2919e-007) * a2_25 
+ + ( - 1.1737e-005) * a3_25
parameters cjswn_25=1.3550e-010 + (1.7043e-012) * a1_25 + ( - 7.9152e-014) * a2_25 
+ + ( - 1.5127e-012) * a3_25
parameters cjswgn_25=1.6210e-010 + (2.0333e-012) * a1_25 + ( - 8.6312e-014) * a2_25 
+ + ( - 1.8079e-012) * a3_25
parameters cgon_25=3.8550e-011 + (4.9089e-014) * a1_25 + (6.3269e-013) * a2_25 + 
+ (1.4600e-013) * a3_25
parameters cgln_25=2.5130e-010 + (3.2007e-013) * a1_25 + (4.1243e-012) * a2_25 + 
+ (9.5175e-013) * a3_25
parameters dvthn_25=0.0000e+000 + (6.8227e-003) * a1_25 + ( - 3.0935e-004) * a2_25 
+ + ( - 6.0588e-003) * a3_25
parameters dlvthn_25=0.0000e+000 + ( - 4.4886e-010) * a1_25 + (2.0352e-011) * a2_25 
+ + (3.9860e-010) * a3_25
parameters dwvthn_25=0.0000e+000 + (8.9772e-011) * a1_25 + ( - 4.0705e-012) * a2_25 
+ + ( - 7.9721e-011) * a3_25
parameters dpvthn_25=0.0000e+000 + (5.6621e-016) * a1_25 + ( - 1.2855e-017) * a2_25 
+ + ( - 5.0727e-016) * a3_25
parameters dlu0n_25=0.0000e+000 + ( - 5.3863e-011) * a1_25 + (2.4423e-012) * a2_25 
+ + (4.7832e-011) * a3_25
parameters dwu0n_25=0.0000e+000 + ( - 2.0037e-011) * a1_25 + (4.1130e-012) * a2_25 
+ + (1.6678e-011) * a3_25
parameters dpu0n_25=0.0000e+000 + (1.3789e-017) * a1_25 + (5.7837e-018) * a2_25 
+ + ( - 1.4476e-017) * a3_25
parameters dcitn_25=0.0000e+000 + (1.7954e-005) * a1_25 + ( - 8.1409e-007) * a2_25 
+ + ( - 1.5944e-005) * a3_25
parameters dlcitn_25=0.0000e+000 + ( - 8.2492e-012) * a1_25 + ( - 8.4309e-012) * 
+ a2_25 + ( - 2.1455e-012) * a3_25
parameters dwcitn_25=0.0000e+000 + ( - 1.7954e-011) * a1_25 + (8.1409e-013) * a2_25 
+ + (1.5944e-011) * a3_25
parameters dpcitn_25=0.0000e+000 + (1.0312e-018) * a1_25 + (1.0539e-018) * a2_25 
+ + (2.6818e-019) * a3_25
parameters cfn_25=9.0000e-011 + (1.1490e-013) * a1_25 + (1.4766e-012) * a2_25 + 
+ (3.4077e-013) * a3_25 + 2.4e-11 * ccoflag_25
parameters dxlp_25=0.0000e+000 + ( - 7.9271e-011) * a1_25 + ( - 2.2385e-009) * a2_25 
+ + ( - 5.1409e-010) * a3_25
parameters dxwp_25=0.0000e+000 + (2.4682e-010) * a1_25 + (3.2029e-009) * a2_25 + 
+ ( - 1.6955e-009) * a3_25
parameters toxp_25=5.9000e-009 + ( - 5.4716e-012) * a1_25 + ( - 7.0317e-011) * a2_25 
+ + ( - 1.6227e-011) * a3_25
parameters cjp_25=1.1200e-003 + (1.3750e-005) * a1_25 + ( - 4.6655e-006) * a2_25 
+ + (1.2019e-005) * a3_25
parameters cjswp_25=9.0000e-011 + (1.1076e-012) * a1_25 + ( - 3.7905e-013) * a2_25 
+ + (9.6497e-013) * a3_25
parameters cjswgp_25=1.7000e-010 + (2.0922e-012) * a1_25 + ( - 7.1599e-013) * a2_25 
+ + (1.8227e-012) * a3_25
parameters cgop_25=5.2332e-011 + (1.3774e-013) * a1_25 + (1.8487e-012) * a2_25 + 
+ ( - 5.7507e-012) * a3_25
parameters cglp_25=2.6891e-010 + (4.1880e-013) * a1_25 + (5.4647e-012) * a2_25 + 
+ ( - 5.3077e-012) * a3_25
parameters dvthp_25=0.0000e+000 + ( - 1.9664e-003) * a1_25 + (9.3156e-004) * a2_25 
+ + ( - 1.4583e-003) * a3_25
parameters dlvthp_25=0.0000e+000 + ( - 3.2016e-010) * a1_25 + (2.6802e-011) * a2_25 
+ + ( - 3.6047e-010) * a3_25
parameters dwvthp_25=0.0000e+000 + ( - 1.1807e-009) * a1_25 + (1.4543e-010) * a2_25 
+ + ( - 1.2835e-009) * a3_25
parameters dpvthp_25=0.0000e+000 + ( - 2.9288e-016) * a1_25 + (1.3644e-016) * a2_25 
+ + ( - 2.1948e-016) * a3_25
parameters dlu0p_25=0.0000e+000 + ( - 1.3417e-012) * a1_25 + ( - 5.8112e-014) * 
+ a2_25 + ( - 1.6785e-012) * a3_25
parameters dwu0p_25=0.0000e+000 + (1.7582e-011) * a1_25 + ( - 6.0167e-012) * a2_25 
+ + (1.5317e-011) * a3_25
parameters dlcitp_25=0.0000e+000 + ( - 5.1558e-012) * a1_25 + ( - 5.2693e-012) * 
+ a2_25 + ( - 1.3409e-012) * a3_25
parameters dpvsatp_25=0.0000e+000 + ( - 1.9340e-010) * a1_25 + (6.6184e-011) * a2_25 
+ + ( - 1.6849e-010) * a3_25
parameters dleta0p_25=0.0000e+000 + ( - 3.9328e-009) * a1_25 + (1.8631e-009) * a2_25 
+ + ( - 2.9166e-009) * a3_25
parameters dpa0p_25=0.0000e+000 + (1.8322e-014) * a1_25 + ( - 9.3737e-015) * a2_25 
+ + (1.2904e-014) * a3_25
parameters cfp_25=9.0000e-011 + (1.1490e-013) * a1_25 + (1.4766e-012) * a2_25 + 
+ (3.4077e-013) * a3_25 + 2.4e-11 * ccoflag_25
parameters dlcn_25=4.6540e-008
parameters du0n_25=0.0000e+000
parameters dk2n_25=0.0000e+000
parameters dlk2n_25=0.0000e+000
parameters dwk2n_25=0.0000e+000
parameters dpk2n_25=0.0000e+000
parameters dk2_25=0.0000e+000
parameters dlcp_25=5.4905e-008
parameters du0p_25=0.0000e+000
parameters dpu0p_25=0.0000e+000
parameters dnfactorp_25=0.0000e+000
parameters dlnfactorp_25=0.0000e+000
parameters dwnfactorp_25=0.0000e+000
parameters dpnfactorp_25=0.0000e+000
parameters dcitp_25=0.0000e+000
parameters dwcitp_25=0.0000e+000
parameters dpcitp_25=0.0000e+000
parameters dvsatp_25=0.0000e+000
parameters dlvsatp_25=0.0000e+000
parameters dwvsatp_25=0.0000e+000
parameters dpeta0p_25=0.0000e+000
parameters dla0p_25=0.0000e+000
parameters dwa0p_25=0.0000e+000
parameters b1fn_25=-7.25E+40
parameters b2fn_25=4.75E+22 
parameters b3fn_25=-1.925E+8   
parameters a1fn_25=8.975E+41 
parameters a2fn_25=4.75E+22  
parameters a3fn_25=4.825e+8  
parameters c1fn_25=2.05E+41  
parameters c2fn_25=4E+10    
parameters c3fn_25=5.35e+8 
parameters b1fp_25=-3.55E+41   
parameters b2fp_25=0    
parameters b3fp_25=-2.225E+9    
parameters a1fp_25=1.573E+42    
parameters a2fp_25=0  
parameters a3fp_25=4.825E+9 
parameters c1fp_25=8.05E+41     
parameters c2fp_25=4E+10  
parameters c3fp_25=5.35E+9  
parameters noian_25=a1fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b1fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c1fn_25
parameters noibn_25=a2fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b2fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c2fn_25
parameters noicn_25=a3fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b3fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c3fn_25
parameters noiap_25=a1fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b1fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c1fp_25
parameters noibp_25=a2fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b2fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c2fp_25
parameters noicp_25=a3fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b3fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c3fp_25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25
endsection mc_25
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25ud18
parameters a1_25ud18=par6 * 4.1285 * 3 / 1.85
parameters a2_25ud18=par7 * 3.581 * 3 / 1.85
parameters a3_25ud18=par8 * 2.9155 * 3 / 1.85
parameters a4_25ud18=par9 * 0.7952 * 3 / 1.85
parameters toxn_25ud18=5.6e-09 + ( - 2.5615e-011) * a1_25ud18 + (6.1353e-011) * 
+ a2_25ud18 + ( - 7.8327e-012) * a3_25ud18 + (6.4438e-012) * a4_25ud18
parameters dxln_25ud18=0 + ( - 1.0858e-009) * a1_25ud18 + (1.2881e-009) * a2_25ud18 
+ + ( - 1.8628e-010) * a3_25ud18 + (3.1565e-011) * a4_25ud18
parameters dxwn_25ud18=0 + (1.073e-009) * a1_25ud18 + ( - 2.6264e-009) * a2_25ud18 
+ + ( - 2.052e-009) * a3_25ud18 + ( - 4.6046e-010) * a4_25ud18
parameters cjn_25ud18=0.001051 + ( - 1.235e-005) * a1_25ud18 + ( - 3.0305e-006) 
+ * a2_25ud18 + (1.155e-005) * a3_25ud18 + ( - 2.1341e-006) * a4_25ud18
parameters cjswn_25ud18=1.355e-10 + ( - 1.5904e-012) * a1_25ud18 + ( - 3.9162e-013) 
+ * a2_25ud18 + (1.4891e-012) * a3_25ud18 + ( - 2.592e-013) * a4_25ud18
parameters cjswgn_25ud18=1.621e-10 + ( - 1.8941e-012) * a1_25ud18 + ( - 4.7195e-013) 
+ * a2_25ud18 + (1.7821e-012) * a3_25ud18 + ( - 3.091e-013) * a4_25ud18
parameters cgon_25ud18=3.855e-11 + (2.306e-013) * a1_25ud18 + ( - 5.5195e-013) * 
+ a2_25ud18 + (7.0472e-014) * a3_25ud18 + ( - 5.7939e-014) * a4_25ud18
parameters cgln_25ud18=2.513e-10 + (1.5032e-012) * a1_25ud18 + ( - 3.598e-012) * 
+ a2_25ud18 + (4.5938e-013) * a3_25ud18 + ( - 3.777e-013) * a4_25ud18
parameters dvthn_25ud18=0 + ( - 0.0063639) * a1_25ud18 + ( - 0.0015722) * a2_25ud18 
+ + (0.0059665) * a3_25ud18 + ( - 0.0010375) * a4_25ud18
parameters dlvthn_25ud18=0 + (1.7513e-010) * a1_25ud18 + ( - 6.9137e-010) * a2_25ud18 
+ + ( - 3.1398e-010) * a3_25ud18 + ( - 1.2413e-010) * a4_25ud18
parameters dwvthn_25ud18=0 + ( - 8.3735e-011) * a1_25ud18 + ( - 2.0686e-011) * a2_25ud18 
+ + (7.8506e-011) * a3_25ud18 + ( - 1.3652e-011) * a4_25ud18
parameters dpvthn_25ud18=0 + ( - 4.9068e-016) * a1_25ud18 + ( - 3.2312e-017) * a2_25ud18 
+ + (4.9274e-016) * a3_25ud18 + (1.0499e-018) * a4_25ud18
parameters dlu0n_25ud18=0 + (5.0241e-011) * a1_25ud18 + (1.2412e-011) * a2_25ud18 
+ + ( - 4.7104e-011) * a3_25ud18 + (8.1911e-012) * a4_25ud18
parameters dwu0n_25ud18=0 + (1.9935e-011) * a1_25ud18 + (2.664e-012) * a2_25ud18 
+ + ( - 1.5509e-011) * a3_25ud18 + (1.8423e-011) * a4_25ud18
parameters dpu0n_25ud18=0 + ( - 1.037e-017) * a1_25ud18 + ( - 7.0838e-018) * a2_25ud18 
+ + (1.6087e-017) * a3_25ud18 + (2.8655e-017) * a4_25ud18
parameters dcitn_25ud18=0 + ( - 1.6747e-005) * a1_25ud18 + ( - 4.1373e-006) * a2_25ud18 
+ + (1.5701e-005) * a3_25ud18 + ( - 2.7304e-006) * a4_25ud18
parameters dwcitn_25ud18=0 + (1.6747e-011) * a1_25ud18 + (4.1373e-012) * a2_25ud18 
+ + ( - 1.5701e-011) * a3_25ud18 + (2.7304e-012) * a4_25ud18
parameters deta0n_25ud18=0 + ( - 0.0051851) * a1_25ud18 + ( - 0.0035419) * a2_25ud18 
+ + (0.0080433) * a3_25ud18 + (0.014327) * a4_25ud18
parameters cfn_25ud18=9.000000e-011 + (5.3791e-013) * a1_25ud18 + ( - 1.2884e-012) 
+ * a2_25ud18 + (1.6449e-013) * a3_25ud18 + ( - 1.3532e-013) * a4_25ud18 + 2.4e-11 
+ * ccoflag_25ud18
parameters dxlp_25ud18=0 + ( - 9.9299e-010) * a1_25ud18 + (1.5909e-009) * a2_25ud18 
+ + ( - 2.162e-010) * a3_25ud18 + (1.0486e-010) * a4_25ud18
parameters dxwp_25ud18=0 + (9.7619e-010) * a1_25ud18 + ( - 2.2819e-009) * a2_25ud18 
+ + (2.6786e-009) * a3_25ud18 + ( - 5.5037e-011) * a4_25ud18
parameters toxp_25ud18=5.9e-09 + ( - 2.5615e-011) * a1_25ud18 + (6.1353e-011) * 
+ a2_25ud18 + ( - 7.8327e-012) * a3_25ud18 + (6.4438e-012) * a4_25ud18
parameters cjp_25ud18=0.00112 + ( - 1.2935e-005) * a1_25ud18 + ( - 6.2524e-006) 
+ * a2_25ud18 + ( - 1.2293e-005) * a3_25ud18 + ( - 4.5409e-006) * a4_25ud18
parameters cjswp_25ud18=9e-11 + ( - 1.0436e-012) * a1_25ud18 + ( - 5.0072e-013) 
+ * a2_25ud18 + ( - 9.8822e-013) * a3_25ud18 + ( - 3.6538e-013) * a4_25ud18
parameters cjswgp_25ud18=1.7e-10 + ( - 1.9713e-012) * a1_25ud18 + ( - 9.458e-013) 
+ * a2_25ud18 + ( - 1.8666e-012) * a3_25ud18 + ( - 6.9016e-013) * a4_25ud18
parameters cgop_25ud18=5.23324e-11 + (3.1281e-013) * a1_25ud18 + ( - 7.4919e-013) 
+ * a2_25ud18 + (9.5644e-014) * a3_25ud18 + ( - 7.8129e-014) * a4_25ud18
parameters cglp_25ud18=2.68907e-10 + (1.6071e-012) * a1_25ud18 + ( - 3.8496e-012) 
+ * a2_25ud18 + (4.9145e-013) * a3_25ud18 + ( - 4.0371e-013) * a4_25ud18
parameters dvthp_25ud18=0 + (0.0030887) * a1_25ud18 + (0.0042809) * a2_25ud18 + 
+ (0.0012288) * a3_25ud18 + (0.0030287) * a4_25ud18
parameters dlvthp_25ud18=0 + (2.7388e-010) * a1_25ud18 + (7.0657e-010) * a2_25ud18 
+ + ( - 3.6515e-011) * a3_25ud18 + (3.0717e-010) * a4_25ud18
parameters dwvthp_25ud18=0 + (7.3006e-010) * a1_25ud18 + ( - 7.2584e-011) * a2_25ud18 
+ + (1.3037e-009) * a3_25ud18 + ( - 1.3163e-009) * a4_25ud18
parameters dpvthp_25ud18=0 + (2.9312e-016) * a1_25ud18 + (9.8592e-017) * a2_25ud18 
+ + (2.3799e-016) * a3_25ud18 + (3.0669e-016) * a4_25ud18
parameters dlu0p_25ud18=0 + (1.0189e-012) * a1_25ud18 + (1.0894e-012) * a2_25ud18 
+ + (1.5301e-012) * a3_25ud18 + ( - 2.5585e-012) * a4_25ud18
parameters dwu0p_25ud18=0 + ( - 1.6566e-011) * a1_25ud18 + ( - 7.9479e-012) * a2_25ud18 
+ + ( - 1.5686e-011) * a3_25ud18 + ( - 5.7997e-012) * a4_25ud18
parameters dlcitp_25ud18=0 + ( - 2.0377e-012) * a1_25ud18 + ( - 2.1789e-012) * a2_25ud18 
+ + ( - 3.0602e-012) * a3_25ud18 + (5.1171e-012) * a4_25ud18
parameters dpvsatp_25ud18=0 + (1.414e-010) * a1_25ud18 + ( - 4.5798e-011) * a2_25ud18 
+ + (1.8571e-010) * a3_25ud18 + (3.1549e-011) * a4_25ud18
parameters dleta0p_25ud18=0 + (3.9508e-009) * a1_25ud18 + (1.2949e-009) * a2_25ud18 
+ + (3.1757e-009) * a3_25ud18 + (4.2985e-009) * a4_25ud18
parameters dpa0p_25ud18=0 + ( - 1.8735e-014) * a1_25ud18 + ( - 5.3852e-015) * a2_25ud18 
+ + ( - 1.4349e-014) * a3_25ud18 + ( - 2.4051e-014) * a4_25ud18
parameters cfp_25ud18=9.000000e-011 + (5.3791e-013) * a1_25ud18 + ( - 1.2884e-012) 
+ * a2_25ud18 + (1.6449e-013) * a3_25ud18 + ( - 1.3532e-013) * a4_25ud18 + 2.4e-11 
+ * ccoflag_25ud18
parameters dlkt1p_25ud18=0 + (5.0943e-010) * a1_25ud18 + (5.4472e-010) * a2_25ud18 
+ + (7.6504e-010) * a3_25ud18 + ( - 1.2793e-009) * a4_25ud18
parameters dlcn_25ud18=4.654e-08
parameters du0n_25ud18=0
parameters dlcitn_25ud18=0
parameters dpcitn_25ud18=0
parameters dleta0n_25ud18=0
parameters dweta0n_25ud18=0
parameters dpeta0n_25ud18=0
parameters dk2n_25ud18=0
parameters dlk2n_25ud18=0
parameters dwk2n_25ud18=0
parameters dpk2n_25ud18=0
parameters dk2_25ud18=0
parameters dlcp_25ud18=5.49049e-08
parameters du0p_25ud18=0
parameters dpu0p_25ud18=0
parameters dnfactorp_25ud18=0
parameters dlnfactorp_25ud18=0
parameters dwnfactorp_25ud18=0
parameters dpnfactorp_25ud18=0
parameters dcitp_25ud18=0
parameters dwcitp_25ud18=0
parameters dpcitp_25ud18=0
parameters dvsatp_25ud18=0
parameters dlvsatp_25ud18=0
parameters dwvsatp_25ud18=0
parameters dpeta0p_25ud18=0
parameters dla0p_25ud18=0
parameters dwa0p_25ud18=0
parameters b1fn_25ud18=-7.25E+40
parameters b2fn_25ud18=4.75E+22 
parameters b3fn_25ud18=-1.925E+8   
parameters a1fn_25ud18=8.975E+41 
parameters a2fn_25ud18=4.75E+22  
parameters a3fn_25ud18=4.825e+8  
parameters c1fn_25ud18=2.05E+41  
parameters c2fn_25ud18=4E+10    
parameters c3fn_25ud18=5.35e+8 
parameters b1fp_25ud18=-3.55E+41   
parameters b2fp_25ud18=0    
parameters b3fp_25ud18=-2.225E+9    
parameters a1fp_25ud18=1.573E+42    
parameters a2fp_25ud18=0  
parameters a3fp_25ud18=4.825E+9 
parameters c1fp_25ud18=8.05E+41     
parameters c2fp_25ud18=4E+10  
parameters c3fp_25ud18=5.35E+9  
parameters noian_25ud18=a1fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b1fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c1fn_25ud18
parameters noibn_25ud18=a2fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b2fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c2fn_25ud18
parameters noicn_25ud18=a3fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b3fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c3fn_25ud18
parameters noiap_25ud18=a1fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b1fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c1fp_25ud18
parameters noibp_25ud18=a2fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b2fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c2fp_25ud18
parameters noicp_25ud18=a3fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b3fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c3fp_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25ud18
endsection mc_25ud18
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25od33
parameters a1_25od33=par6 * 4.4286e+000 * 3 / 2.1
parameters a2_25od33=par7 * 3.5643e+000 * 3 / 2.1
parameters a3_25od33=par8 * 2.7400e+000 * 3 / 2.1
parameters a4_25od33=par9 * 1.0842e+000 * 3 / 2.1
parameters toxn_25od33=5.6000e-009 + ( - 6.5018e-012) * a1_25od33 + ( - 6.7923e-011) 
+ * a2_25od33 + ( - 3.6884e-012) * a3_25od33 + (1.9727e-011) * a4_25od33
parameters dxln_25od33=0.0000e+000 + ( - 2.9725e-010) * a1_25od33 + ( - 2.1376e-009) 
+ * a2_25od33 + ( - 1.0726e-010) * a3_25od33 + (6.2908e-010) * a4_25od33
parameters dxwn_25od33=0.0000e+000 + (1.6711e-010) * a1_25od33 + (2.8058e-009) * 
+ a2_25od33 + ( - 2.3725e-009) * a3_25od33 + ( - 1.0008e-009) * a4_25od33
parameters cjn_25od33=1.0510e-003 + ( - 1.2419e-005) * a1_25od33 + (5.6657e-007) 
+ * a2_25od33 + (1.3650e-005) * a3_25od33 + (1.8119e-006) * a4_25od33
parameters cjswn_25od33=1.3550e-010 + ( - 1.5995e-012) * a1_25od33 + (7.4816e-014) 
+ * a2_25od33 + (1.7597e-012) * a3_25od33 + (2.4460e-013) * a4_25od33
parameters cjswgn_25od33=1.6210e-010 + ( - 1.9069e-012) * a1_25od33 + (9.5990e-014) 
+ * a2_25od33 + (2.1049e-012) * a3_25od33 + (2.9020e-013) * a4_25od33
parameters cgon_25od33=3.8550e-011 + (5.8637e-014) * a1_25od33 + (6.1111e-013) * 
+ a2_25od33 + (3.3172e-014) * a3_25od33 + ( - 1.7750e-013) * a4_25od33
parameters cgln_25od33=2.5130e-010 + (3.8216e-013) * a1_25od33 + (3.9837e-012) * 
+ a2_25od33 + (2.1625e-013) * a3_25od33 + ( - 1.1571e-012) * a4_25od33
parameters dvthn_25od33=0.0000e+000 + ( - 6.4021e-003) * a1_25od33 + (3.0574e-004) 
+ * a2_25od33 + (7.0496e-003) * a3_25od33 + (9.7771e-004) * a4_25od33
parameters dlvthn_25od33=0.0000e+000 + (4.2119e-010) * a1_25od33 + ( - 2.0114e-011) 
+ * a2_25od33 + ( - 4.6379e-010) * a3_25od33 + ( - 6.4323e-011) * a4_25od33
parameters dwvthn_25od33=0.0000e+000 + ( - 8.4238e-011) * a1_25od33 + (4.0229e-012) 
+ * a2_25od33 + (9.2758e-011) * a3_25od33 + (1.2865e-011) * a4_25od33
parameters dpvthn_25od33=0.0000e+000 + ( - 5.2868e-016) * a1_25od33 + (3.6925e-017) 
+ * a2_25od33 + (5.9277e-016) * a3_25od33 + (1.2341e-016) * a4_25od33
parameters dlu0n_25od33=0.0000e+000 + (5.0543e-011) * a1_25od33 + ( - 2.4137e-012) 
+ * a2_25od33 + ( - 5.5655e-011) * a3_25od33 + ( - 7.7188e-012) * a4_25od33
parameters dwu0n_25od33=0.0000e+000 + (1.9457e-011) * a1_25od33 + (1.9899e-012) 
+ * a2_25od33 + ( - 1.8771e-011) * a3_25od33 + (7.6973e-012) * a4_25od33
parameters dpu0n_25od33=0.0000e+000 + ( - 1.1628e-017) * a1_25od33 + (6.3936e-018) 
+ * a2_25od33 + (1.8112e-017) * a3_25od33 + (2.3113e-017) * a4_25od33
parameters dcitn_25od33=0.0000e+000 + ( - 1.6848e-005) * a1_25od33 + (8.0458e-007) 
+ * a2_25od33 + (1.8552e-005) * a3_25od33 + (2.5729e-006) * a4_25od33
parameters dwcitn_25od33=0.0000e+000 + (1.6848e-011) * a1_25od33 + ( - 8.0458e-013) 
+ * a2_25od33 + ( - 1.8552e-011) * a3_25od33 + ( - 2.5729e-012) * a4_25od33
parameters cfn_25od33=9.0000e-011 + (1.3654e-013) * a1_25od33 + (1.4264e-012) * 
+ a2_25od33 + (7.7457e-014) * a3_25od33 + ( - 4.1427e-013) * a4_25od33 + 2.4e-11 
+ * ccoflag_25od33
parameters dxlp_25od33=0.0000e+000 + ( - 2.9725e-010) * a1_25od33 + ( - 2.1376e-009) 
+ * a2_25od33 + ( - 1.0726e-010) * a3_25od33 + (6.2908e-010) * a4_25od33
parameters dxwp_25od33=0.0000e+000 + (3.5303e-010) * a1_25od33 + (2.6280e-009) * 
+ a2_25od33 + (2.6676e-009) * a3_25od33 + ( - 5.7739e-010) * a4_25od33
parameters toxp_25od33=5.9000e-009 + ( - 6.5018e-012) * a1_25od33 + ( - 6.7923e-011) 
+ * a2_25od33 + ( - 3.6884e-012) * a3_25od33 + (1.9727e-011) * a4_25od33
parameters cjp_25od33=1.1200e-003 + ( - 1.4139e-005) * a1_25od33 + (1.6002e-006) 
+ * a2_25od33 + ( - 1.1800e-005) * a3_25od33 + ( - 2.1075e-007) * a4_25od33
parameters cjswp_25od33=9.0000e-011 + ( - 1.1395e-012) * a1_25od33 + (1.2538e-013) 
+ * a2_25od33 + ( - 9.4807e-013) * a3_25od33 + ( - 1.5737e-014) * a4_25od33
parameters cjswgp_25od33=1.7000e-010 + ( - 2.1524e-012) * a1_25od33 + (2.3683e-013) 
+ * a2_25od33 + ( - 1.7908e-012) * a3_25od33 + ( - 2.9726e-014) * a4_25od33
parameters cgop_25od33=5.2332e-011 + (7.9418e-014) * a1_25od33 + (8.2943e-013) * 
+ a2_25od33 + (4.5033e-014) * a3_25od33 + ( - 2.4049e-013) * a4_25od33
parameters cglp_25od33=2.6891e-010 + (4.0790e-013) * a1_25od33 + (4.2618e-012) * 
+ a2_25od33 + (2.3143e-013) * a3_25od33 + ( - 1.2373e-012) * a4_25od33
parameters dvthp_25od33=0.0000e+000 + (2.0697e-003) * a1_25od33 + (8.0438e-005) 
+ * a2_25od33 + (1.4829e-003) * a3_25od33 + (1.0520e-003) * a4_25od33
parameters dlvthp_25od33=0.0000e+000 + (3.1440e-010) * a1_25od33 + ( - 1.3321e-010) 
+ * a2_25od33 + (3.3810e-010) * a3_25od33 + ( - 3.2315e-010) * a4_25od33
parameters dwvthp_25od33=0.0000e+000 + (1.1679e-009) * a1_25od33 + ( - 4.3667e-010) 
+ * a2_25od33 + (1.2108e-009) * a3_25od33 + ( - 1.0073e-009) * a4_25od33
parameters dpvthp_25od33=0.0000e+000 + (3.0784e-016) * a1_25od33 + (9.2712e-018) 
+ * a2_25od33 + (2.2266e-016) * a3_25od33 + (1.4753e-016) * a4_25od33
parameters dlu0p_25od33=0.0000e+000 + (1.2867e-012) * a1_25od33 + ( - 7.5792e-013) 
+ * a2_25od33 + (1.5488e-012) * a3_25od33 + ( - 2.0291e-012) * a4_25od33
parameters dwu0p_25od33=0.0000e+000 + ( - 1.8087e-011) * a1_25od33 + (1.9901e-012) 
+ * a2_25od33 + ( - 1.5049e-011) * a3_25od33 + ( - 2.4980e-013) * a4_25od33
parameters dpu0p_25od33=0.0000e+000 + (5.8959e-017) * a1_25od33 + ( - 9.4028e-019) 
+ * a2_25od33 + (4.4751e-017) * a3_25od33 + (1.9236e-017) * a4_25od33
parameters dwcitp_25od33=0.0000e+000 + (5.2197e-012) * a1_25od33 + (5.5890e-012) 
+ * a2_25od33 + ( - 4.3945e-013) * a3_25od33 + (2.0540e-011) * a4_25od33
parameters dpcitp_25od33=0.0000e+000 + (2.4158e-018) * a1_25od33 + ( - 3.7955e-018) 
+ * a2_25od33 + ( - 4.7066e-019) * a3_25od33 + (8.5487e-019) * a4_25od33
parameters dlvsatp_25od33=0.0000e+000 + ( - 1.2867e-004) * a1_25od33 + (7.5792e-005) 
+ * a2_25od33 + ( - 1.5488e-004) * a3_25od33 + (2.0291e-004) * a4_25od33
parameters dpvsatp_25od33=0.0000e+000 + ( - 3.0262e-010) * a1_25od33 + ( - 3.6822e-012) 
+ * a2_25od33 + ( - 2.2310e-010) * a3_25od33 + ( - 1.2699e-010) * a4_25od33
parameters dleta0p_25od33=0.0000e+000 + (4.1394e-009) * a1_25od33 + (1.6088e-010) 
+ * a2_25od33 + (2.9658e-009) * a3_25od33 + (2.1040e-009) * a4_25od33
parameters dpa0p_25od33=0.0000e+000 + ( - 1.0439e-015) * a1_25od33 + ( - 1.1178e-015) 
+ * a2_25od33 + (8.7890e-017) * a3_25od33 + ( - 4.1081e-015) * a4_25od33
parameters dpk2_25od33=0.0000e+000 + ( - 5.4261e-016) * a1_25od33 + (5.9704e-017) 
+ * a2_25od33 + ( - 4.5146e-016) * a3_25od33 + ( - 7.4939e-018) * a4_25od33
parameters cfp_25od33=9.0000e-011 + (1.3654e-013) * a1_25od33 + (1.4264e-012) * 
+ a2_25od33 + (7.7457e-014) * a3_25od33 + ( - 4.1427e-013) * a4_25od33 + 2.4e-11 
+ * ccoflag_25od33
parameters dlcn_25od33=4.6540e-008
parameters du0n_25od33=0.0000e+000
parameters dlcitn_25od33=0.0000e+000
parameters dpcitn_25od33=0.0000e+000
parameters dk2n_25od33=0.0000e+000
parameters dlk2n_25od33=0.0000e+000
parameters dwk2n_25od33=0.0000e+000
parameters dpk2n_25od33=0.0000e+000
parameters dk2_25od33=0.0000e+000
parameters dlcp_25od33=5.4905e-008
parameters du0p_25od33=0.0000e+000
parameters dnfactorp_25od33=0.0000e+000
parameters dlnfactorp_25od33=0.0000e+000
parameters dwnfactorp_25od33=0.0000e+000
parameters dpnfactorp_25od33=0.0000e+000
parameters dcitp_25od33=0.0000e+000
parameters dlcitp_25od33=0.0000e+000
parameters dvsatp_25od33=0.0000e+000
parameters dwvsatp_25od33=0.0000e+000
parameters dpeta0p_25od33=0.0000e+000
parameters dla0p_25od33=0.0000e+000
parameters dwa0p_25od33=0.0000e+000
parameters dlk2_25od33=0.0000e+000
parameters dwk2_25od33=0.0000e+000
parameters b1fn_25od33=-7.25E+40
parameters b2fn_25od33=4.75E+22 
parameters b3fn_25od33=-1.925E+8   
parameters a1fn_25od33=8.975E+41 
parameters a2fn_25od33=4.75E+22  
parameters a3fn_25od33=4.825e+8  
parameters c1fn_25od33=2.05E+41  
parameters c2fn_25od33=4E+10    
parameters c3fn_25od33=5.35e+8 
parameters b1fp_25od33=-3.55E+41   
parameters b2fp_25od33=0    
parameters b3fp_25od33=-2.225E+9    
parameters a1fp_25od33=1.573E+42    
parameters a2fp_25od33=0  
parameters a3fp_25od33=4.825E+9 
parameters c1fp_25od33=8.05E+41     
parameters c2fp_25od33=4E+10  
parameters c3fp_25od33=5.35E+9  
parameters noian_25od33=a1fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b1fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c1fn_25od33
parameters noibn_25od33=a2fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b2fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c2fn_25od33
parameters noicn_25od33=a3fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b3fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c3fn_25od33
parameters noiap_25od33=a1fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b1fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c1fp_25od33
parameters noibp_25od33=a2fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b2fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c2fp_25od33
parameters noicp_25od33=a3fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b3fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c3fp_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25od33
endsection mc_25od33
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_33
parameters a1_33=par6 * 4.4286e+000 * 3 / 2.1
parameters a2_33=par7 * 3.5643e+000 * 3 / 2.1
parameters a3_33=par8 * 2.7400e+000 * 3 / 2.1
parameters a4_33=par9 * 1.0842e+000 * 3 / 2.1
parameters toxn_33=5.6000e-009 + ( - 6.5018e-012) * a1_33 + ( - 6.7923e-011) * a2_33 
+ + ( - 3.6884e-012) * a3_33 + (1.9727e-011) * a4_33
parameters dxln_33=0.0000e+000 + ( - 2.9725e-010) * a1_33 + ( - 2.1376e-009) * a2_33 
+ + ( - 1.0726e-010) * a3_33 + (6.2908e-010) * a4_33
parameters dxwn_33=0.0000e+000 + (1.6711e-010) * a1_33 + (2.8058e-009) * a2_33 + 
+ ( - 2.3725e-009) * a3_33 + ( - 1.0008e-009) * a4_33
parameters cjn_33=1.0510e-003 + ( - 1.2419e-005) * a1_33 + (5.6657e-007) * a2_33 
+ + (1.3650e-005) * a3_33 + (1.8119e-006) * a4_33
parameters cjswn_33=1.3550e-010 + ( - 1.5995e-012) * a1_33 + (7.4816e-014) * a2_33 
+ + (1.7597e-012) * a3_33 + (2.4460e-013) * a4_33
parameters cjswgn_33=1.6210e-010 + ( - 1.9069e-012) * a1_33 + (9.5990e-014) * a2_33 
+ + (2.1049e-012) * a3_33 + (2.9020e-013) * a4_33
parameters cgon_33=3.8550e-011 + (5.8637e-014) * a1_33 + (6.1111e-013) * a2_33 + 
+ (3.3172e-014) * a3_33 + ( - 1.7750e-013) * a4_33
parameters cgln_33=2.5130e-010 + (3.8216e-013) * a1_33 + (3.9837e-012) * a2_33 + 
+ (2.1625e-013) * a3_33 + ( - 1.1571e-012) * a4_33
parameters dvthn_33=0.0000e+000 + ( - 6.4021e-003) * a1_33 + (3.0574e-004) * a2_33 
+ + (7.0496e-003) * a3_33 + (9.7771e-004) * a4_33
parameters dlvthn_33=0.0000e+000 + (4.2119e-010) * a1_33 + ( - 2.0114e-011) * a2_33 
+ + ( - 4.6379e-010) * a3_33 + ( - 6.4323e-011) * a4_33
parameters dwvthn_33=0.0000e+000 + ( - 8.4238e-011) * a1_33 + (4.0229e-012) * a2_33 
+ + (9.2758e-011) * a3_33 + (1.2865e-011) * a4_33
parameters dpvthn_33=0.0000e+000 + ( - 5.2868e-016) * a1_33 + (3.6925e-017) * a2_33 
+ + (5.9277e-016) * a3_33 + (1.2341e-016) * a4_33
parameters dlu0n_33=0.0000e+000 + (5.0543e-011) * a1_33 + ( - 2.4137e-012) * a2_33 
+ + ( - 5.5655e-011) * a3_33 + ( - 7.7188e-012) * a4_33
parameters dwu0n_33=0.0000e+000 + (1.9457e-011) * a1_33 + (1.9899e-012) * a2_33 
+ + ( - 1.8771e-011) * a3_33 + (7.6973e-012) * a4_33
parameters dpu0n_33=0.0000e+000 + ( - 1.1628e-017) * a1_33 + (6.3936e-018) * a2_33 
+ + (1.8112e-017) * a3_33 + (2.3113e-017) * a4_33
parameters dcitn_33=0.0000e+000 + ( - 1.6848e-005) * a1_33 + (8.0458e-007) * a2_33 
+ + (1.8552e-005) * a3_33 + (2.5729e-006) * a4_33
parameters dwcitn_33=0.0000e+000 + (1.6848e-011) * a1_33 + ( - 8.0458e-013) * a2_33 
+ + ( - 1.8552e-011) * a3_33 + ( - 2.5729e-012) * a4_33
parameters cfn_33=9.0000e-011 + (1.3654e-013) * a1_33 + (1.4264e-012) * a2_33 + 
+ (7.7457e-014) * a3_33 + ( - 4.1427e-013) * a4_33 + 2.4e-11 * ccoflag_33
parameters dxlp_33=0.0000e+000 + ( - 2.9725e-010) * a1_33 + ( - 2.1376e-009) * a2_33 
+ + ( - 1.0726e-010) * a3_33 + (6.2908e-010) * a4_33
parameters dxwp_33=0.0000e+000 + (3.5303e-010) * a1_33 + (2.6280e-009) * a2_33 + 
+ (2.6676e-009) * a3_33 + ( - 5.7739e-010) * a4_33
parameters toxp_33=5.9000e-009 + ( - 6.5018e-012) * a1_33 + ( - 6.7923e-011) * a2_33 
+ + ( - 3.6884e-012) * a3_33 + (1.9727e-011) * a4_33
parameters cjp_33=1.1200e-003 + ( - 1.4139e-005) * a1_33 + (1.6002e-006) * a2_33 
+ + ( - 1.1800e-005) * a3_33 + ( - 2.1075e-007) * a4_33
parameters cjswp_33=9.0000e-011 + ( - 1.1395e-012) * a1_33 + (1.2538e-013) * a2_33 
+ + ( - 9.4807e-013) * a3_33 + ( - 1.5737e-014) * a4_33
parameters cjswgp_33=1.7000e-010 + ( - 2.1524e-012) * a1_33 + (2.3683e-013) * a2_33 
+ + ( - 1.7908e-012) * a3_33 + ( - 2.9726e-014) * a4_33
parameters cgop_33=5.2332e-011 + (7.9418e-014) * a1_33 + (8.2943e-013) * a2_33 + 
+ (4.5033e-014) * a3_33 + ( - 2.4049e-013) * a4_33
parameters cglp_33=2.6891e-010 + (4.0790e-013) * a1_33 + (4.2618e-012) * a2_33 + 
+ (2.3143e-013) * a3_33 + ( - 1.2373e-012) * a4_33
parameters dvthp_33=0.0000e+000 + (2.0697e-003) * a1_33 + (8.0438e-005) * a2_33 
+ + (1.4829e-003) * a3_33 + (1.0520e-003) * a4_33
parameters dlvthp_33=0.0000e+000 + (3.1440e-010) * a1_33 + ( - 1.3321e-010) * a2_33 
+ + (3.3810e-010) * a3_33 + ( - 3.2315e-010) * a4_33
parameters dwvthp_33=0.0000e+000 + (1.1679e-009) * a1_33 + ( - 4.3667e-010) * a2_33 
+ + (1.2108e-009) * a3_33 + ( - 1.0073e-009) * a4_33
parameters dpvthp_33=0.0000e+000 + (3.0784e-016) * a1_33 + (9.2712e-018) * a2_33 
+ + (2.2266e-016) * a3_33 + (1.4753e-016) * a4_33
parameters dlu0p_33=0.0000e+000 + (1.2867e-012) * a1_33 + ( - 7.5792e-013) * a2_33 
+ + (1.5488e-012) * a3_33 + ( - 2.0291e-012) * a4_33
parameters dwu0p_33=0.0000e+000 + ( - 1.8087e-011) * a1_33 + (1.9901e-012) * a2_33 
+ + ( - 1.5049e-011) * a3_33 + ( - 2.4980e-013) * a4_33
parameters dpu0p_33=0.0000e+000 + (5.8959e-017) * a1_33 + ( - 9.4028e-019) * a2_33 
+ + (4.4751e-017) * a3_33 + (1.9236e-017) * a4_33
parameters dwcitp_33=0.0000e+000 + (5.2197e-012) * a1_33 + (5.5890e-012) * a2_33 
+ + ( - 4.3945e-013) * a3_33 + (2.0540e-011) * a4_33
parameters dpcitp_33=0.0000e+000 + (2.4158e-018) * a1_33 + ( - 3.7955e-018) * a2_33 
+ + ( - 4.7066e-019) * a3_33 + (8.5487e-019) * a4_33
parameters dlvsatp_33=0.0000e+000 + ( - 1.2867e-004) * a1_33 + (7.5792e-005) * a2_33 
+ + ( - 1.5488e-004) * a3_33 + (2.0291e-004) * a4_33
parameters dpvsatp_33=0.0000e+000 + ( - 3.0262e-010) * a1_33 + ( - 3.6822e-012) 
+ * a2_33 + ( - 2.2310e-010) * a3_33 + ( - 1.2699e-010) * a4_33
parameters dleta0p_33=0.0000e+000 + (4.1394e-009) * a1_33 + (1.6088e-010) * a2_33 
+ + (2.9658e-009) * a3_33 + (2.1040e-009) * a4_33
parameters dpa0p_33=0.0000e+000 + ( - 1.0439e-015) * a1_33 + ( - 1.1178e-015) * 
+ a2_33 + (8.7890e-017) * a3_33 + ( - 4.1081e-015) * a4_33
parameters dpk2_33=0.0000e+000 + ( - 5.4261e-016) * a1_33 + (5.9704e-017) * a2_33 
+ + ( - 4.5146e-016) * a3_33 + ( - 7.4939e-018) * a4_33
parameters cfp_33=9.0000e-011 + (1.3654e-013) * a1_33 + (1.4264e-012) * a2_33 + 
+ (7.7457e-014) * a3_33 + ( - 4.1427e-013) * a4_33 + 2.4e-11 * ccoflag_33
parameters dlcn_33=4.6540e-008
parameters du0n_33=0.0000e+000
parameters dlcitn_33=0.0000e+000
parameters dpcitn_33=0.0000e+000
parameters dk2n_33=0.0000e+000
parameters dlk2n_33=0.0000e+000
parameters dwk2n_33=0.0000e+000
parameters dpk2n_33=0.0000e+000
parameters dk2_33=0.0000e+000
parameters dlcp_33=5.4905e-008
parameters du0p_33=0.0000e+000
parameters dnfactorp_33=0.0000e+000
parameters dlnfactorp_33=0.0000e+000
parameters dwnfactorp_33=0.0000e+000
parameters dpnfactorp_33=0.0000e+000
parameters dcitp_33=0.0000e+000
parameters dlcitp_33=0.0000e+000
parameters dvsatp_33=0.0000e+000
parameters dwvsatp_33=0.0000e+000
parameters dpeta0p_33=0.0000e+000
parameters dla0p_33=0.0000e+000
parameters dwa0p_33=0.0000e+000
parameters dlk2_33=0.0000e+000
parameters dwk2_33=0.0000e+000
parameters b1fn_33=-7.25E+40
parameters b2fn_33=4.75E+22 
parameters b3fn_33=-1.925E+8   
parameters a1fn_33=8.975E+41 
parameters a2fn_33=4.75E+22  
parameters a3fn_33=4.825e+8  
parameters c1fn_33=2.05E+41  
parameters c2fn_33=4E+10    
parameters c3fn_33=5.35e+8 
parameters b1fp_33=-3.55E+41   
parameters b2fp_33=0    
parameters b3fp_33=-2.225E+9    
parameters a1fp_33=1.573E+42    
parameters a2fp_33=0  
parameters a3fp_33=4.825E+9 
parameters c1fp_33=8.05E+41     
parameters c2fp_33=4E+10  
parameters c3fp_33=5.35E+9  
parameters noian_33=a1fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b1fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c1fn_33
parameters noibn_33=a2fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b2fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c2fn_33
parameters noicn_33=a3fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b3fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c3fn_33
parameters noiap_33=a1fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b1fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c1fp_33
parameters noibp_33=a2fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b2fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c2fp_33
parameters noicp_33=a3fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b3fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c3fp_33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_33
endsection mc_33
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_na
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na
parameters a1_na= - par1 * 3.4393e+000 * 3 / 2.1
parameters a2_na= - par2 * 2.7429e+000 * 3 / 2.1
parameters a3_na= - par3 * 1.8177e+000 * 3 / 2.1
parameters a4_na= - par4 * 5.3021e-001 * 3 / 2.1
parameters toxn_na=2.0000e-009 + (6.5902e-012) * a1_na + ( - 1.4640e-011) * a2_na 
+ + (7.8850e-012) * a3_na + (1.4897e-011) * a4_na
parameters dxln_na=0.0000e+000 + (4.7182e-010) * a1_na + ( - 1.6529e-009) * a2_na 
+ + (1.0595e-009) * a3_na + (7.5706e-010) * a4_na
parameters dxwn_na=0.0000e+000 + ( - 1.4378e-009) * a1_na + (2.1415e-009) * a2_na 
+ + ( - 2.7770e-009) * a3_na + (4.6753e-009) * a4_na
parameters dvthn_na=0.0000e+000 + (6.8109e-003) * a1_na + (1.9145e-003) * a2_na 
+ + ( - 1.7046e-004) * a3_na + ( - 1.5289e-003) * a4_na
parameters dlvthn_na=0.0000e+000 + (8.1204e-010) * a1_na + (2.0788e-010) * a2_na 
+ + ( - 4.6629e-011) * a3_na + ( - 1.8661e-010) * a4_na
parameters dwvthn_na=0.0000e+000 + (4.4175e-010) * a1_na + (2.1820e-010) * a2_na 
+ + (1.1033e-010) * a3_na + ( - 7.9219e-011) * a4_na
parameters cjn_na=1.6200e-004 + (2.5463e-006) * a1_na + (7.4876e-007) * a2_na + 
+ ( - 2.1113e-008) * a3_na + ( - 5.6459e-007) * a4_na
parameters cjswn_na=1.2700e-010 + (1.9962e-012) * a1_na + (5.8699e-013) * a2_na 
+ + ( - 1.6551e-014) * a3_na + ( - 4.4261e-013) * a4_na
parameters cjswgn_na=2.9500e-010 + (4.6368e-012) * a1_na + (1.3635e-012) * a2_na 
+ + ( - 3.8446e-014) * a3_na + ( - 1.0281e-012) * a4_na
parameters cgon_na=1.423060e-10 + (1.8120e-012) * a1_na + (1.7154e-011) * a2_na 
+ + ( - 1.5168e-011) * a3_na + (1.4934e-011) * a4_na
parameters cgln_na=4.913760e-12 + ( - 5.2524e-014) * a1_na + ( - 1.8667e-013) * 
+ a2_na + (1.8545e-013) * a3_na + ( - 2.7395e-013) * a4_na
parameters cfn_na=1.3900e-010 + ( - 9.6108e-013) * a1_na + (2.1350e-012) * a2_na 
+ + ( - 1.1499e-012) * a3_na + ( - 2.1724e-012) * a4_na + 4.1e-11 * ccoflag_na
parameters du0n_na=0.0000e+000 + ( - 2.2454e-004) * a1_na + ( - 6.6028e-005) * a2_na 
+ + (1.8618e-006) * a3_na + (4.9788e-005) * a4_na
parameters dlu0n_na=0.0000e+000 + (1.2406e-010) * a1_na + ( - 3.2105e-011) * a2_na 
+ + (2.0678e-011) * a3_na + (1.6763e-010) * a4_na
parameters dwu0n_na=0.0000e+000 + ( - 1.7892e-011) * a1_na + (3.7121e-011) * a2_na 
+ + (5.4863e-011) * a3_na + (1.2958e-011) * a4_na
parameters dpu0n_na=0.0000e+000 + (3.8737e-018) * a1_na + ( - 9.8097e-018) * a2_na 
+ + ( - 1.4167e-017) * a3_na + ( - 3.1814e-018) * a4_na
parameters drdswn_na=0.0000e+000 + ( - 4.4503e-004) * a1_na + ( - 2.6502e-001) * 
+ a2_na + ( - 3.4196e-001) * a3_na + ( - 5.6092e-002) * a4_na
parameters dk2n_na=0.0000e+000 + (1.1227e-003) * a1_na + (3.3014e-004) * a2_na + 
+ ( - 9.3090e-006) * a3_na + ( - 2.4894e-004) * a4_na
parameters dcitn_na=0.0000e+000 + (4.4819e-005) * a1_na + ( - 3.9799e-005) * a2_na 
+ + ( - 6.8765e-005) * a3_na + ( - 2.1176e-005) * a4_na
parameters dlcitn_na=0.0000e+000 + (4.4953e-012) * a1_na + (3.9708e-012) * a2_na 
+ + (3.3824e-012) * a3_na + ( - 4.3484e-013) * a4_na
parameters ntoxn_na=1.0000e+000 + ( - 1.0588e-002) * a1_na + (2.5513e-002) * a2_na 
+ + ( - 1.6748e-002) * a3_na + ( - 2.8016e-002) * a4_na
parameters dlagsn_na=0.0000e+000 + (5.9759e-009) * a1_na + ( - 5.3065e-009) * a2_na 
+ + ( - 9.1687e-009) * a3_na + ( - 2.8234e-009) * a4_na
parameters dwagsn_na=0.0000e+000 + (1.4984e-009) * a1_na + (1.3236e-009) * a2_na 
+ + (1.1275e-009) * a3_na + ( - 1.4495e-010) * a4_na
parameters dpvthn_na=0.0000e+000
parameters ddlcn_na=5.107660e-09
parameters dnfactorn_na=0.0000e+000
parameters dlnfactorn_na=0.0000e+000
parameters dwnfactorn_na=0.0000e+000
parameters dpnfactorn_na=0.0000e+000
parameters deta0n_na=0.0000e+000
parameters dleta0n_na=0.0000e+000
parameters dweta0n_na=0.0000e+000
parameters dpeta0n_na=0.0000e+000
parameters dcdscdn_na=0.0000e+000
parameters dlk2n_na=0.0000e+000
parameters dwk2n_na=0.0000e+000
parameters dpk2n_na=0.0000e+000
parameters dwcitn_na=0.0000e+000
parameters dpcitn_na=0.0000e+000
parameters dagsn_na=0.0000e+000
parameters dpagsn_na=0.0000e+000
parameters dla0_na=0.0000e+000
parameters dvsat_na=0.0000e+000
parameters dlvsat_na=0.0000e+000
parameters dwvsat_na=0.0000e+000
parameters dpvsat_na=0.0000e+000
parameters b1fn_na=-5.625e+41   
parameters b2fn_na=-6.75e+13
parameters b3fn_na=-1.125e+7 
parameters a1fn_na=4.413e+42   
parameters a2fn_na=0   
parameters a3fn_na=-1.175e+7 
parameters c1fn_na=1.175e+42  
parameters c2fn_na=1.5e+14  
parameters c3fn_na=2.35e+7     
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na
endsection mc_na
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25
parameters a1_na25=par6 * 3.4040e+000 * 3 / 2.25
parameters a2_na25=par7 * 1.8426e+000 * 3 / 2.25
parameters a3_na25=par8 * 9.4865e-001 * 3 / 2.25
parameters toxn_na25=5.6000e-009 + ( - 5.2498e-011) * a1_na25 + ( - 8.9561e-011) 
+ * a2_na25 + ( - 3.0162e-011) * a3_na25
parameters dxln_na25=0.0000e+000 + ( - 1.5821e-009) * a1_na25 + ( - 1.7926e-009) 
+ * a2_na25 + (4.3657e-010) * a3_na25
parameters dxwn_na25=0.0000e+000 + (2.9362e-009) * a1_na25 + (1.8136e-009) * a2_na25 
+ + (2.6856e-009) * a3_na25
parameters cjn_na25=1.4516e-004 + ( - 2.1110e-006) * a1_na25 + (1.1306e-006) * a2_na25 
+ + (9.4939e-007) * a3_na25
parameters cjswn_na25=1.6900e-010 + ( - 2.4534e-012) * a1_na25 + (1.3181e-012) * 
+ a2_na25 + (1.0997e-012) * a3_na25
parameters cjswgn_na25=1.1776e-010 + ( - 1.7126e-012) * a1_na25 + (9.1726e-013) 
+ * a2_na25 + (7.7005e-013) * a3_na25
parameters cgon_na25=5.4786e-011 + (6.7110e-013) * a1_na25 + (1.1449e-012) * a2_na25 
+ + (3.8557e-013) * a3_na25
parameters cgln_na25=7.5784e-010 + (9.2832e-012) * a1_na25 + (1.5837e-011) * a2_na25 
+ + (5.3334e-012) * a3_na25
parameters dvthn_na25=0.0000e+000 + ( - 1.0259e-002) * a1_na25 + (6.0929e-003) * 
+ a2_na25 + (2.8893e-003) * a3_na25
parameters dlvthn_na25=0.0000e+000 + ( - 6.9910e-009) * a1_na25 + (3.5603e-009) 
+ * a2_na25 + (3.6750e-009) * a3_na25
parameters dwvthn_na25=0.0000e+000 + (5.9167e-011) * a1_na25 + ( - 2.4789e-010) 
+ * a2_na25 + (5.9701e-010) * a3_na25
parameters dpvthn_na25=0.0000e+000 + (1.3504e-016) * a1_na25 + ( - 7.2325e-017) 
+ * a2_na25 + ( - 6.0733e-017) * a3_na25
parameters du0n_na25=0.0000e+000 + (3.7347e-004) * a1_na25 + ( - 1.7243e-004) * 
+ a2_na25 + ( - 2.4758e-004) * a3_na25
parameters dpu0n_na25=0.0000e+000 + (2.0775e-017) * a1_na25 + ( - 1.1127e-017) * 
+ a2_na25 + ( - 9.3436e-018) * a3_na25
parameters dcitn_na25=0.0000e+000 + (4.2031e-004) * a1_na25 + ( - 5.0112e-004) * 
+ a2_na25 + (6.0707e-004) * a3_na25
parameters cfn_na25=9.0000e-011 + (1.1025e-012) * a1_na25 + (1.8808e-012) * a2_na25 
+ + (6.3340e-013) * a3_na25 + 2.4e-11 * ccoflag_na25
parameters ddlcn_na25=1.3015e-007
parameters dlu0n_na25=0.0000e+000
parameters dwu0n_na25=0.0000e+000
parameters dlcitn_na25=0.0000e+000
parameters dwcitn_na25=0.0000e+000
parameters dpcitn_na25=0.0000e+000
parameters dnfactorn_na25=0.0000e+000
parameters dlnfactorn_na25=0.0000e+000
parameters dwnfactorn_na25=0.0000e+000
parameters dpnfactorn_na25=0.0000e+000
parameters dvsatn_na25=0.0000e+000
parameters dlvsatn_na25=0.0000e+000
parameters dwvsatn_na25=0.0000e+000
parameters dpvsatn_na25=0.0000e+000
parameters deta0n_na25=0.0000e+000
parameters dleta0n_na25=0.0000e+000
parameters dweta0n_na25=0.0000e+000
parameters dpeta0n_na25=0.0000e+000
parameters b1fn_na25=-6e+40
parameters b2fn_na25=-1.5e+24
parameters b3fn_na25=-1.35e+8   
parameters a1fn_na25=3e+41   
parameters a2fn_na25=0   
parameters a3fn_na25=1.35e+9   
parameters c1fn_na25=2e+41     
parameters c2fn_na25=7.5e+24     
parameters c3fn_na25=3e+8     
parameters noian_na25=a1fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b1fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c1fn_na25
parameters noibn_na25=a2fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b2fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c2fn_na25
parameters noicn_na25=a3fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b3fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c3fn_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25
endsection mc_na25
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25od33
parameters a1_na25od33=par6 * 3.3194 * 3 / 2.25
parameters a2_na25od33=par7 * 1.9178 * 3 / 2.25
parameters a3_na25od33=par8 * 1.1179 * 3 / 2.25
parameters toxn_na25od33=5.6e-09 + ( - 5.4305e-011) * a1_na25od33 + ( - 8.6217e-011) 
+ * a2_na25od33 + ( - 8.1721e-012) * a3_na25od33
parameters dxln_na25od33=0 + ( - 1.6228e-009) * a1_na25od33 + ( - 1.7013e-009) * 
+ a2_na25od33 + ( - 2.1642e-010) * a3_na25od33
parameters dxwn_na25od33=max( - 1.2e-8,0 + (2.1722e-009) * a1_na25od33 + (3.4487e-009) 
+ * a2_na25od33 + (3.2688e-010) * a3_na25od33)
parameters cjn_na25od33=0.000145159 + ( - 2.3421e-006) * a1_na25od33 + (1.5246e-006) 
+ * a2_na25od33 + (3.7979e-007) * a3_na25od33
parameters cjswn_na25od33=1.69e-10 + ( - 2.7198e-012) * a1_na25od33 + (1.7713e-012) 
+ * a2_na25od33 + (4.4109e-013) * a3_na25od33
parameters cjswgn_na25od33=1.17763e-10 + ( - 1.9002e-012) * a1_na25od33 + (1.2369e-012) 
+ * a2_na25od33 + (3.0788e-013) * a3_na25od33
parameters cgon_na25od33=5.47859e-11 + (6.942e-013) * a1_na25od33 + (1.1021e-012) 
+ * a2_na25od33 + (1.0447e-013) * a3_na25od33
parameters cgln_na25od33=7.57836e-10 + (9.6027e-012) * a1_na25od33 + (1.5246e-011) 
+ * a2_na25od33 + (1.4451e-012) * a3_na25od33
parameters dvthn_na25od33=0 + ( - 0.011121) * a1_na25od33 + (0.0073915) * a2_na25od33 
+ + (0.00026225) * a3_na25od33
parameters dlvthn_na25od33=0 + ( - 7.8372e-009) * a1_na25od33 + (5.055e-009) * a2_na25od33 
+ + (1.7451e-009) * a3_na25od33
parameters dwvthn_na25od33=0 + ( - 2.8933e-011) * a1_na25od33 + ( - 3.6049e-011) 
+ * a2_na25od33 + (5.6188e-010) * a3_na25od33
parameters dpvthn_na25od33=0 + (1.4983e-016) * a1_na25od33 + ( - 9.7532e-017) * 
+ a2_na25od33 + ( - 2.4295e-017) * a3_na25od33
parameters du0n_na25od33=0 + (0.00042644) * a1_na25od33 + ( - 0.0002706) * a2_na25od33 
+ + ( - 0.00014028) * a3_na25od33
parameters dpu0n_na25od33=0 + (2.305e-017) * a1_na25od33 + ( - 1.5005e-017) * a2_na25od33 
+ + ( - 3.7377e-018) * a3_na25od33
parameters dcitn_na25od33=0 + (0.0003456) * a1_na25od33 + ( - 0.00029504) * a2_na25od33 
+ + (0.00065526) * a3_na25od33
parameters cfn_na25od33=9.000000e-011 + (1.1404e-012) * a1_na25od33 + (1.8106e-012) 
+ * a2_na25od33 + (1.7161e-013) * a3_na25od33 + 2.4e-11 * ccoflag_na25od33
parameters ddlcn_na25od33=1.30153e-07
parameters dlu0n_na25od33=0
parameters dwu0n_na25od33=0
parameters dlcitn_na25od33=0
parameters dwcitn_na25od33=0
parameters dpcitn_na25od33=0
parameters dnfactorn_na25od33=0
parameters dlnfactorn_na25od33=0
parameters dwnfactorn_na25od33=0
parameters dpnfactorn_na25od33=0
parameters dvsatn_na25od33=0
parameters dlvsatn_na25od33=0
parameters dwvsatn_na25od33=0
parameters dpvsatn_na25od33=0
parameters deta0n_na25od33=0
parameters dleta0n_na25od33=0
parameters dweta0n_na25od33=0
parameters dpeta0n_na25od33=0
parameters b1fn_na25od33=-6e+40
parameters b2fn_na25od33=-1.5e+24
parameters b3fn_na25od33=-1.35e+8   
parameters a1fn_na25od33=3e+41   
parameters a2fn_na25od33=0   
parameters a3fn_na25od33=1.35e+9   
parameters c1fn_na25od33=2e+41     
parameters c2fn_na25od33=7.5e+24     
parameters c3fn_na25od33=3e+8     
parameters noian_na25od33=a1fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b1fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c1fn_na25od33
parameters noibn_na25od33=a2fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b2fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c2fn_na25od33
parameters noicn_na25od33=a3fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b3fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c3fn_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25od33
endsection mc_na25od33
 
// **************************     LIBRARY OF STATISTICAL CASE     ***************************

section mc_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na33
parameters a1_na33=par6 * 3.3194 * 3 / 2.25
parameters a2_na33=par7 * 1.9178 * 3 / 2.25
parameters a3_na33=par8 * 1.1179 * 3 / 2.25
parameters toxn_na33=5.6e-09 + ( - 5.4305e-011) * a1_na33 + ( - 8.6217e-011) * a2_na33 
+ + ( - 8.1721e-012) * a3_na33
parameters dxln_na33=0 + ( - 1.6228e-009) * a1_na33 + ( - 1.7013e-009) * a2_na33 
+ + ( - 2.1642e-010) * a3_na33
parameters dxwn_na33=max( - 1.2e-8,0 + (2.1722e-009) * a1_na33 + (3.4487e-009) * 
+ a2_na33 + (3.2688e-010) * a3_na33)
parameters cjn_na33=0.000145159 + ( - 2.3421e-006) * a1_na33 + (1.5246e-006) * a2_na33 
+ + (3.7979e-007) * a3_na33
parameters cjswn_na33=1.69e-10 + ( - 2.7198e-012) * a1_na33 + (1.7713e-012) * a2_na33 
+ + (4.4109e-013) * a3_na33
parameters cjswgn_na33=1.17763e-10 + ( - 1.9002e-012) * a1_na33 + (1.2369e-012) 
+ * a2_na33 + (3.0788e-013) * a3_na33
parameters cgon_na33=5.47859e-11 + (6.942e-013) * a1_na33 + (1.1021e-012) * a2_na33 
+ + (1.0447e-013) * a3_na33
parameters cgln_na33=7.57836e-10 + (9.6027e-012) * a1_na33 + (1.5246e-011) * a2_na33 
+ + (1.4451e-012) * a3_na33
parameters dvthn_na33=0 + ( - 0.011121) * a1_na33 + (0.0073915) * a2_na33 + (0.00026225) 
+ * a3_na33
parameters dlvthn_na33=0 + ( - 7.8372e-009) * a1_na33 + (5.055e-009) * a2_na33 + 
+ (1.7451e-009) * a3_na33
parameters dwvthn_na33=0 + ( - 2.8933e-011) * a1_na33 + ( - 3.6049e-011) * a2_na33 
+ + (5.6188e-010) * a3_na33
parameters dpvthn_na33=0 + (1.4983e-016) * a1_na33 + ( - 9.7532e-017) * a2_na33 
+ + ( - 2.4295e-017) * a3_na33
parameters du0n_na33=0 + (0.00042644) * a1_na33 + ( - 0.0002706) * a2_na33 + ( - 
+ 0.00014028) * a3_na33
parameters dpu0n_na33=0 + (2.305e-017) * a1_na33 + ( - 1.5005e-017) * a2_na33 + 
+ ( - 3.7377e-018) * a3_na33
parameters dcitn_na33=0 + (0.0003456) * a1_na33 + ( - 0.00029504) * a2_na33 + (0.00065526) 
+ * a3_na33
parameters cfn_na33=9.000000e-011 + (1.1404e-012) * a1_na33 + (1.8106e-012) * a2_na33 
+ + (1.7161e-013) * a3_na33 + 2.4e-11 * ccoflag_na33
parameters ddlcn_na33=1.30153e-07
parameters dlu0n_na33=0
parameters dwu0n_na33=0
parameters dlcitn_na33=0
parameters dwcitn_na33=0
parameters dpcitn_na33=0
parameters dnfactorn_na33=0
parameters dlnfactorn_na33=0
parameters dwnfactorn_na33=0
parameters dpnfactorn_na33=0
parameters dvsatn_na33=0
parameters dlvsatn_na33=0
parameters dwvsatn_na33=0
parameters dpvsatn_na33=0
parameters deta0n_na33=0
parameters dleta0n_na33=0
parameters dweta0n_na33=0
parameters dpeta0n_na33=0
parameters b1fn_na33=-6e+40
parameters b2fn_na33=-1.5e+24
parameters b3fn_na33=-1.35e+8   
parameters a1fn_na33=3e+41   
parameters a2fn_na33=0   
parameters a3fn_na33=1.35e+9   
parameters c1fn_na33=2e+41     
parameters c2fn_na33=7.5e+24     
parameters c3fn_na33=3e+8     
parameters noian_na33=a1fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b1fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c1fn_na33
parameters noibn_na33=a2fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b2fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c2fn_na33
parameters noicn_na33=a3fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b3fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c3fn_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na33
endsection mc_na33
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters toxp=2.2e-09
parameters dxwp=0
parameters dxlp=0
parameters dvthp=0
parameters dlvthp=0
parameters dwvthp=0
parameters dpvthp=0
parameters cjp=1.0600e-03
parameters cjswp=6.4000e-11
parameters cjswgp=2.5500e-10
parameters cgop=3.018880e-11
parameters cglp=5.247580e-11
parameters ddlcp=4.745380e-09
parameters cfp=1.3800e-10 + 4.6e-11 * ccoflag
parameters drdswp=0
parameters dnfactorp=0
parameters dlnfactorp=0
parameters dwnfactorp=0
parameters dpnfactorp=0
parameters du0p=0
parameters dlu0p=0
parameters dwu0p=0
parameters dpu0p=0
parameters deta0p=0
parameters dleta0p=0
parameters dweta0p=0
parameters dpeta0p=0
parameters dvsatp=0
parameters dlvsatp=0
parameters dwvsatp=0
parameters dpvsatp=0
parameters ntoxp=1
parameters dk2p=0
parameters dlk2p=0
parameters dwk2p=0
parameters dpk2p=0
parameters dagsp=0
parameters dwagsp=0
parameters dpclmp=0
parameters dlpclmp=0
parameters dla0p=0
parameters dlagsp=0
parameters dpagsp=0
parameters dwa0p=0
parameters dpa0p=0
parameters dcitp=0
parameters dlcitp=0
parameters dwcitp=0
parameters dpcitp=0
parameters dvoffp=0
parameters dlvoffp=0
parameters dwvoffp=0
parameters dpvoffp=0
parameters da0p=0
parameters jtsswgp=7.2e-10
parameters dlutep=0
parameters dlatp=0
parameters ff_flag=0
parameters ss_flag=0
parameters fs_flag=0
parameters sf_flag=0
parameters toxn=2e-09
parameters dxwn=0
parameters dxln=0
parameters dvthn=0
parameters dlvthn=0
parameters dwvthn=0
parameters dpvthn=0
parameters cjn=1.2700e-03
parameters cjswn=6.4000e-11
parameters cjswgn=3.0500e-10
parameters cgon=5.725430e-11
parameters cgln=9.157840e-12
parameters ddlcn=3.244300e-09
parameters cfn=1.3900e-10 + 4.1e-11 * ccoflag
parameters drdswn=0
parameters dnfactorn=0
parameters dlnfactorn=0
parameters dwnfactorn=0
parameters dpnfactorn=0
parameters du0n=0
parameters dlu0n=0
parameters dwu0n=0
parameters dpu0n=0
parameters deta0n=0
parameters dleta0n=0
parameters dweta0n=0
parameters dpeta0n=0
parameters dvsatn=0
parameters dlvsatn=0
parameters dwvsatn=0
parameters dpvsatn=0
parameters ntoxn=1
parameters dk2n=0
parameters dlk2n=0
parameters dwk2n=0
parameters dpk2n=0
parameters dagsn=0
parameters dpclmn=0
parameters dppclmn=0
parameters dlcitn=0
parameters dwcitn=0
parameters dpcitn=0
parameters da0n=0
parameters dla0n=0
parameters dwa0n=0
parameters dpa0n=0
parameters dvoffn=0
parameters dlvoffn=0
parameters dwvoffn=0
parameters dpvoffn=0
parameters dkt1n=0
parameters dlkt1n=0
parameters dwkt1n=0
parameters dpkt1n=0
parameters dkt2n=0
parameters dlkt2n=0
parameters dwkt2n=0
parameters dpkt2n=0
parameters dub1n=0
parameters dlub1n=0
parameters dwub1n=0
parameters dpub1n=0
parameters dua1n=0
parameters dlua1n=0
parameters dwua1n=0
parameters dpua1n=0
parameters datn=0
parameters dlatn=0
parameters dpatn=0
parameters dwatn=0
parameters dlagsn=0
parameters dpagsn=0
parameters b1fn=-6.5E+40           
parameters b2fn=0
parameters b3fn=-2.49E+7           
parameters a1fn=9.25e+41   
parameters a2fn=0  
parameters a3fn=1.475e+9  
parameters c1fn=1.5E+41     
parameters c2fn=1E+14  
parameters c3fn=5E+7 
parameters b1fp=-5.5E+41   
parameters b2fp=0    
parameters b3fp=-7E+9   
parameters a1fp=1.19E+43   
parameters a2fp=3.995E+17  
parameters a3fp=4E+10 
parameters c1fp=1.2E+42   
parameters c2fp=1E+15    
parameters c3fp=1.5E+10   
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "crn65gplus_2d5_lk_v1d0.scs" section=mos
endsection tt
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters toxp=2.26e-09
parameters dxwp=-8e-09
parameters dxlp=4e-09
parameters dvthp=-0.03
parameters dlvthp=-1.4e-10
parameters dwvthp=-1.95e-09
parameters dpvthp=-2.055e-16
parameters cjp=1.1342e-03
parameters cjswp=6.8480e-11
parameters cjswgp=2.7285e-10
parameters cgop=2.80756e-11
parameters cglp=4.88025e-11
parameters ddlcp=4.74538e-09
parameters cfp=1.283e-10 + 4.6e-11 * ccoflag
parameters drdswp=0
parameters dnfactorp=0
parameters dlnfactorp=0
parameters dwnfactorp=0
parameters dpnfactorp=0
parameters du0p=0.00021
parameters dlu0p=0
parameters dwu0p=-3e-11
parameters dpu0p=1.35e-18
parameters deta0p=0.0057
parameters dleta0p= - 0.4e-09 * 0 - 1.8e-09
parameters dweta0p=0
parameters dpeta0p=-8e-17
parameters dvsatp=0
parameters dlvsatp=0
parameters dwvsatp=0
parameters dpvsatp=0
parameters ntoxp=0.52
parameters dk2p=0
parameters dlk2p=0.8e-09
parameters dwk2p=1e-09
parameters dpk2p=-3e-17
parameters dagsp=-0.06
parameters dwagsp=5.1e-08
parameters dpclmp=0
parameters dlpclmp=1e-7
parameters dla0p= - 6e-08
parameters dlagsp= - 1e-07
parameters dpagsp=2e-14
parameters dwa0p=0
parameters dpa0p=0
parameters dcitp=0
parameters dlcitp=0
parameters dwcitp=0
parameters dpcitp=0
parameters dvoffp=0
parameters dlvoffp=0
parameters dwvoffp=0
parameters dpvoffp=0
parameters da0p=0
parameters jtsswgp=7.2e-10
parameters dlutep=0
parameters dlatp=0.3e-03
parameters ff_flag=0
parameters ss_flag=1
parameters fs_flag=0
parameters sf_flag=0
parameters toxn=2.06e-09
parameters dxwn=-8e-09
parameters dxln=4e-09
parameters dvthn=0.0270
parameters dlvthn=5.5e-10
parameters dwvthn=1.3e-09
parameters dpvthn=1.9e-16
parameters cjn=1.3589e-03
parameters cjswn=6.8480e-11
parameters cjswgn=3.2635e-10
parameters cgon=5.32465e-11
parameters cgln=8.51679e-12
parameters ddlcn=3.24430e-09
parameters cfn=1.293e-10 + 4.1e-11 * ccoflag
parameters drdswn=-5
parameters dnfactorn=0
parameters dlnfactorn=0
parameters dwnfactorn=0
parameters dpnfactorn=0
parameters du0n=0
parameters dlu0n=-2.0e-11
parameters dwu0n=0
parameters dpu0n=0
parameters deta0n=-0.01
parameters dleta0n=1.7e-09 * 0 + 0.4e-09
parameters dweta0n=0
parameters dpeta0n=-2e-16
parameters dvsatn=0
parameters dlvsatn=0.00029
parameters dwvsatn=0
parameters dpvsatn=5e-11
parameters ntoxn=0.82
parameters dk2n=0.011
parameters dlk2n=-5e-11
parameters dwk2n=1.8e-09
parameters dpk2n=8.5e-17
parameters dagsn=0.05
parameters dpclmn=0
parameters dppclmn=0
parameters dlcitn=5e-11 * 0
parameters dwcitn=0
parameters dpcitn=0
parameters da0n=0
parameters dla0n=0
parameters dwa0n=0
parameters dpa0n=0
parameters dvoffn=0
parameters dlvoffn= - 0.3e-09
parameters dwvoffn=0
parameters dpvoffn=0.3e-09 * 0
parameters dkt1n=0
parameters dlkt1n=-2e-10
parameters dwkt1n=0
parameters dpkt1n=0
parameters dkt2n=0
parameters dlkt2n=0
parameters dwkt2n=0
parameters dpkt2n=0
parameters dub1n=0
parameters dlub1n=0
parameters dwub1n=0
parameters dpub1n=0
parameters dua1n=0
parameters dlua1n=0
parameters dwua1n=0
parameters dpua1n=0
parameters datn=0
parameters dlatn=0.00025
parameters dpatn=6e-11
parameters dwatn=0
parameters dlagsn=1.2e-07
parameters dpagsn=0
parameters b1fn=-6.5E+40           
parameters b2fn=0
parameters b3fn=-2.49E+7           
parameters a1fn=9.25e+41   
parameters a2fn=0  
parameters a3fn=1.475e+9  
parameters c1fn=1.5E+41     
parameters c2fn=1E+14  
parameters c3fn=5E+7 
parameters b1fp=-5.5E+41   
parameters b2fp=0    
parameters b3fp=-7E+9   
parameters a1fp=1.19E+43   
parameters a2fp=3.995E+17  
parameters a3fp=4E+10 
parameters c1fp=1.2E+42   
parameters c2fp=1E+15    
parameters c3fp=1.5E+10    
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "crn65gplus_2d5_lk_v1d0.scs" section=mos
endsection ss
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters toxp=2.14e-09
parameters dxwp=8e-09
parameters dxlp=-4e-09
parameters dvthp=0.0288
parameters dlvthp=5.5e-10
parameters dwvthp=3.1e-09
parameters dpvthp=1.71e-16
parameters cjp=9.8580e-04
parameters cjswp=5.9520e-11
parameters cjswgp=2.3715e-10
parameters cgop=3.23020e-11
parameters cglp=5.61491e-11
parameters ddlcp=4.74538e-09
parameters cfp=1.477e-10 + 4.6e-11 * ccoflag
parameters drdswp=0
parameters dnfactorp=0
parameters dlnfactorp=0
parameters dwnfactorp=0
parameters dpnfactorp=0
parameters du0p=-0.00012
parameters dlu0p=-7e-12
parameters dwu0p=3e-11
parameters dpu0p=-1.3e-18
parameters deta0p=-0.1
parameters dleta0p=3.3e-09 * 0 + 3.8e-09
parameters dweta0p=4.7e-08
parameters dpeta0p=-1.77e-15
parameters dvsatp=-3000
parameters dlvsatp=0
parameters dwvsatp=0
parameters dpvsatp=0
parameters ntoxp=1.39
parameters dk2p=0
parameters dlk2p=-0.2e-09
parameters dwk2p=-1e-09
parameters dpk2p=3e-17
parameters dagsp=-0.06
parameters dwagsp=-4e-08
parameters dpclmp=0
parameters dlpclmp=0
parameters dla0p=6e-08
parameters dlagsp=0
parameters dpagsp=0
parameters dwa0p=0
parameters dpa0p=0
parameters dcitp=0.0003
parameters dlcitp=1.5e-11
parameters dwcitp=0
parameters dpcitp=0
parameters dvoffp=0
parameters dlvoffp=0.25e-09
parameters dwvoffp=0
parameters dpvoffp=0
parameters da0p=0
parameters jtsswgp=7.2e-10
parameters dlutep=0
parameters dlatp=0
parameters ff_flag=1
parameters ss_flag=0
parameters fs_flag=0
parameters sf_flag=0
parameters toxn=1.94e-09
parameters dxwn=8e-09
parameters dxln=-4e-09
parameters dvthn=-0.0285
parameters dlvthn=-7.5e-10
parameters dwvthn=-0.5e-09
parameters dpvthn=-2.05e-16
parameters cjn=1.1811e-03
parameters cjswn=5.9520e-11
parameters cjswgn=2.8365e-10
parameters cgon=6.12621e-11
parameters cgln=9.79889e-12
parameters ddlcn=3.24430e-09
parameters cfn=1.487e-10 + 4.1e-11 * ccoflag
parameters drdswn=0
parameters dnfactorn=0
parameters dlnfactorn=0
parameters dwnfactorn=0
parameters dpnfactorn=0
parameters du0n=0
parameters dlu0n= - 3e-12 * 0 + 1e-11
parameters dwu0n=0
parameters dpu0n=0
parameters deta0n=0
parameters dleta0n= - 1.1e-09 * 0 - 0.6e-09
parameters dweta0n=0
parameters dpeta0n=2.85e-16
parameters dvsatn=0
parameters dlvsatn=-0.0002
parameters dwvsatn=0
parameters dpvsatn=-6.5e-11
parameters ntoxn=1.16
parameters dk2n=-0.013
parameters dlk2n=0
parameters dwk2n=-1.9e-09
parameters dpk2n=-1.2e-16
parameters dagsn=0
parameters dpclmn=0
parameters dppclmn=0
parameters dlcitn= - 5e-11 * 0
parameters dwcitn=0
parameters dpcitn=0
parameters da0n=0
parameters dla0n=0
parameters dwa0n=0
parameters dpa0n=0
parameters dvoffn=0
parameters dlvoffn=0.3e-9
parameters dwvoffn=0
parameters dpvoffn=0
parameters dkt1n=0
parameters dlkt1n=2e-10
parameters dwkt1n=0
parameters dpkt1n=0
parameters dkt2n=0.01
parameters dlkt2n=0
parameters dwkt2n=0
parameters dpkt2n=0
parameters dub1n=0
parameters dlub1n=0
parameters dwub1n=0
parameters dpub1n=0
parameters dua1n=0
parameters dlua1n=0
parameters dwua1n=0
parameters dpua1n=0
parameters datn=0
parameters dlatn=-0.00025
parameters dpatn=-6e-11
parameters dwatn=0
parameters dlagsn= - 0.5e-07
parameters dpagsn=1.7e-14
parameters b1fn=-6.5E+40           
parameters b2fn=0
parameters b3fn=-2.49E+7           
parameters a1fn=9.25e+41   
parameters a2fn=0  
parameters a3fn=1.475e+9  
parameters c1fn=1.5E+41     
parameters c2fn=1E+14  
parameters c3fn=5E+7 
parameters b1fp=-5.5E+41   
parameters b2fp=0    
parameters b3fp=-7E+9   
parameters a1fp=1.19E+43   
parameters a2fp=3.995E+17  
parameters a3fp=4E+10 
parameters c1fp=1.2E+42   
parameters c2fp=1E+15    
parameters c3fp=1.5E+10    
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "crn65gplus_2d5_lk_v1d0.scs" section=mos
endsection ff
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters a1n=0.8
parameters a1p=-0.8
parameters a2n=0
parameters a2p=0
parameters a3n=-1
parameters a3p=1
parameters a4np=0
parameters toxp=2.2e-09 + 6.0000e-11 * a4np
parameters dxwp=8e-09 * a3p
parameters dxlp=4e-09 * a2p
parameters dvthp= - 0.0288 * a1p
parameters dlvthp= - 5.5e-10 * a1p
parameters dwvthp= - 3.1e-09 * a1p
parameters dpvthp= - 1.71e-16 * a1p
parameters cjp=1.0600e-03 * (1 + 0.070 * a1p)
parameters cjswp=6.4000e-11 * (1 + 0.070 * a1p)
parameters cjswgp=2.5500e-10 * (1 + 0.070 * a1p)
parameters cgop=3.01888e-11 * (1 - 0.070 * a4np)
parameters cglp=5.24758e-11 * (1 - 0.070 * a4np)
parameters ddlcp=4.74538e-09
parameters cfp=1.38e-10 * (1 - 0.070 * a4np) + 4.6e-11 * ccoflag
parameters drdswp=0
parameters dnfactorp=0
parameters dlnfactorp=0
parameters dwnfactorp=0
parameters dpnfactorp=0
parameters du0p=0.00012 * a1p
parameters dlu0p=1e-12 * a1p
parameters dwu0p= - 3e-11 * a1p
parameters dpu0p=1.3e-18 * a1p
parameters deta0p=0.1 * a1p
parameters dleta0p= - 3.8e-09 * a1p
parameters dweta0p= - 4.7e-08 * a1p
parameters dpeta0p=1.77e-15 * a1p * 1.1
parameters dvsatp=3000 * a1p
parameters dlvsatp=0.0003
parameters dwvsatp=0
parameters dpvsatp=0
parameters ntoxp=1 +  - 3.9000e-01 * a4np
parameters dk2p=0
parameters dlk2p= - 1.0e-09 * a1p * 0.4
parameters dwk2p=1e-09 * a1p
parameters dpk2p= - 1.5e-17 * a1p
parameters dagsp=0.06 * a1p
parameters dwagsp=4e-08 * a1p
parameters dpclmp=0
parameters dla0p=6e-08 * a1p
parameters dlagsp=0
parameters dpagsp=0
parameters dwa0p=0
parameters dpa0p=0
parameters dlpclmp=0
parameters dcitp= - 0.0003 * a1p
parameters dlcitp= - 1.5e-11 * a1p
parameters dwcitp=0
parameters dpcitp=0
parameters dvoffp=0
parameters dlvoffp=0
parameters dwvoffp=0
parameters dpvoffp=0
parameters da0p=0
parameters jtsswgp=7.2e-10
parameters dlutep=0
parameters dlatp=0
parameters ff_flag=0
parameters ss_flag=0
parameters fs_flag=0
parameters sf_flag=1
parameters toxn=2e-09 + 6.0000e-11 * a4np
parameters dxwn=8e-09 * a3n
parameters dxln=4e-09 * a2n
parameters dvthn=0.0285 * a1n
parameters dlvthn=4.5e-10 * a1n
parameters dwvthn=5e-10 * a1n
parameters dpvthn=2.05e-16 * a1n
parameters cjn=1.2700e-03 * (1 + 0.070 * a1n)
parameters cjswn=6.4000e-11 * (1 + 0.070 * a1n)
parameters cjswgn=3.0500e-10 * (1 + 0.070 * a1n)
parameters cgon=5.72543e-11 * (1 - 0.070 * a4np)
parameters cgln=9.15784e-12 * (1 - 0.070 * a4np)
parameters ddlcn=3.24430e-09
parameters cfn=1.3900e-10 * (1 - 0.070 * a4np) + 4.1e-11 * ccoflag
parameters drdswn=0
parameters dnfactorn=0
parameters dlnfactorn=0
parameters dwnfactorn=0
parameters dpnfactorn=0
parameters du0n=0
parameters dlu0n=3e-12 * a1n
parameters dwu0n=0
parameters dpu0n=0
parameters deta0n=0
parameters dleta0n=0.4e-09 * a1n
parameters dweta0n=0
parameters dpeta0n= - 2.85e-16 * a1n
parameters dvsatn=0
parameters dlvsatn= - 0.00015 * a1n
parameters dwvsatn=0
parameters dpvsatn=6.5e-11 * a1n
parameters ntoxn=1 +  - 1.6000e-01 * a4np
parameters dk2n=0.013 * a1n
parameters dlk2n=0
parameters dwk2n=1.9e-09 * a1n
parameters dpk2n=1.2e-16 * a1n
parameters dagsn=0.05 * a1n
parameters dpclmn=0
parameters dppclmn=0
parameters dlcitn=0
parameters dwcitn=0
parameters dpcitn=0
parameters da0n=0
parameters dla0n=0
parameters dwa0n=0
parameters dpa0n=0
parameters dvoffn=0
parameters dlvoffn= - 0.3e-09 * a1n
parameters dwvoffn=0
parameters dpvoffn=0
parameters dkt1n=0
parameters dlkt1n= - 2e-10 * a1n
parameters dwkt1n=0
parameters dpkt1n=0
parameters dkt2n=0
parameters dlkt2n=0
parameters dwkt2n=0
parameters dpkt2n=0
parameters dub1n=0
parameters dlub1n=0
parameters dwub1n=0
parameters dpub1n=0
parameters dua1n=0
parameters dlua1n=0
parameters dwua1n=0
parameters dpua1n=0
parameters datn=0
parameters dlatn=0.00025 * a1n
parameters dpatn=6e-11 * a1n
parameters dwatn=0
parameters dlagsn=0.5e-07 * a1n
parameters dpagsn= - 1.7e-14 * a1n
parameters b1fn=-6.5E+40           
parameters b2fn=0
parameters b3fn=-2.49E+7           
parameters a1fn=9.25e+41   
parameters a2fn=0  
parameters a3fn=1.475e+9  
parameters c1fn=1.5E+41     
parameters c2fn=1E+14  
parameters c3fn=5E+7 
parameters b1fp=-5.5E+41   
parameters b2fp=0    
parameters b3fp=-7E+9   
parameters a1fp=1.19E+43   
parameters a2fp=3.995E+17  
parameters a3fp=4E+10 
parameters c1fp=1.2E+42   
parameters c2fp=1E+15    
parameters c3fp=1.5E+10   
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "crn65gplus_2d5_lk_v1d0.scs" section=mos
endsection sf
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu
parameters parn1=0
parameters parn2=0
parameters parp1=0
parameters parp2=0
parameters a1n=-0.8
parameters a1p=0.8
parameters a2n=0
parameters a2p=0
parameters a3n=1
parameters a3p=-1
parameters a4np=0
parameters toxp=2.2e-09 + 6.0000e-11 * a4np
parameters dxwp=8e-09 * a3p
parameters dxlp=4e-09 * a2p
parameters dvthp= - 0.0288 * a1p
parameters dlvthp= - 5.5e-10 * a1p
parameters dwvthp= - 3.1e-09 * a1p
parameters dpvthp= - 1.71e-16 * a1p
parameters cjp=1.0600e-03 * (1 + 0.070 * a1p)
parameters cjswp=6.4000e-11 * (1 + 0.070 * a1p)
parameters cjswgp=2.5500e-10 * (1 + 0.070 * a1p)
parameters cgop=3.01888e-11 * (1 - 0.070 * a4np)
parameters cglp=5.24758e-11 * (1 - 0.070 * a4np)
parameters ddlcp=4.74538e-09
parameters cfp=1.3800e-10 * (1 - 0.070 * a4np) + 4.6e-11 * ccoflag
parameters drdswp=0
parameters dnfactorp=0
parameters dlnfactorp=0
parameters dwnfactorp=0
parameters dpnfactorp=0
parameters du0p=0.00012 * a1p
parameters dlu0p=1e-12 * a1p
parameters dwu0p= - 3e-11 * a1p
parameters dpu0p=1.3e-18 * a1p
parameters deta0p=0.1 * a1p
parameters dleta0p= - 3.8e-09 * a1p
parameters dweta0p= - 2.0e-08 * a1p
parameters dpeta0p=1.77e-15 * a1p * 0.5
parameters dvsatp=3000 * a1p
parameters dlvsatp=-0.0003
parameters dwvsatp=0
parameters dpvsatp=0
parameters ntoxp=1 +  - 3.9000e-01 * a4np
parameters dk2p=0
parameters dlk2p= - 1.0e-09 * a1p * 0.4
parameters dwk2p=1e-09 * a1p
parameters dpk2p= - 0e-17 * a1p
parameters dagsp=0.06 * a1p
parameters dwagsp=4e-08 * a1p
parameters dpclmp=0
parameters dla0p=6e-08 * a1p
parameters dlagsp=0
parameters dpagsp=0
parameters dwa0p=0
parameters dpa0p=0
parameters dlpclmp=0
parameters dcitp= - 0.0003 * a1p
parameters dlcitp= - 1.5e-11 * a1p
parameters dwcitp=0
parameters dpcitp=0
parameters dvoffp=0
parameters dlvoffp=0
parameters dwvoffp=0
parameters dpvoffp=0
parameters da0p=0
parameters jtsswgp=7.2e-10
parameters dlutep=0
parameters dlatp=0
parameters ff_flag=0
parameters ss_flag=0
parameters fs_flag=1
parameters sf_flag=0
parameters toxn=2e-09 + 6.0000e-11 * a4np
parameters dxwn=8e-09 * a3n
parameters dxln=4e-09 * a2n
parameters dvthn=0.0285 * a1n
parameters dlvthn=4.5e-10 * a1n
parameters dwvthn=5e-10 * a1n
parameters dpvthn=2.05e-16 * a1n
parameters cjn=1.2700e-03 * (1 + 0.070 * a1n)
parameters cjswn=6.4000e-11 * (1 + 0.070 * a1n)
parameters cjswgn=3.0500e-10 * (1 + 0.070 * a1n)
parameters cgon=5.72543e-11 * (1 - 0.070 * a4np)
parameters cgln=9.15784e-12 * (1 - 0.070 * a4np)
parameters ddlcn=3.24430e-09
parameters cfn=1.3900e-10 * (1 - 0.070 * a4np) + 4.1e-11 * ccoflag
parameters drdswn=0
parameters dnfactorn=0
parameters dlnfactorn=0
parameters dwnfactorn=0
parameters dpnfactorn=0
parameters du0n=0
parameters dlu0n=3e-12 * a1n
parameters dwu0n=0
parameters dpu0n=0
parameters deta0n=0
parameters dleta0n=0.4e-09 * a1n
parameters dweta0n=0
parameters dpeta0n= - 2.85e-16 * a1n
parameters dvsatn=0
parameters dlvsatn= - 0.00015 * a1n
parameters dwvsatn=0
parameters dpvsatn=6.5e-11 * a1n
parameters ntoxn=1 +  - 1.6000e-01 * a4np
parameters dk2n=0.013 * a1n
parameters dlk2n=0
parameters dwk2n=1.9e-09 * a1n
parameters dpk2n=1.2e-16 * a1n
parameters dagsn=0.05 * a1n
parameters dpclmn=0
parameters dppclmn=0
parameters dlcitn=0
parameters dwcitn=0
parameters dpcitn=0
parameters da0n=0
parameters dla0n=0
parameters dwa0n=0
parameters dpa0n=0
parameters dvoffn=0
parameters dlvoffn= - 0.3e-09 * a1n
parameters dwvoffn=0
parameters dpvoffn=0
parameters dkt1n=0
parameters dlkt1n= - 2e-10 * a1n
parameters dwkt1n=0
parameters dpkt1n=0
parameters dkt2n=0
parameters dlkt2n=0
parameters dwkt2n=0
parameters dpkt2n=0
parameters dub1n=0
parameters dlub1n=0
parameters dwub1n=0
parameters dpub1n=0
parameters dua1n=0
parameters dlua1n=0
parameters dwua1n=0
parameters dpua1n=0
parameters datn=0
parameters dlatn=0.00025 * a1n
parameters dpatn=6e-11 * a1n
parameters dwatn=0
parameters dlagsn=0.5e-07 * a1n
parameters dpagsn= - 1.7e-14 * a1n
parameters b1fn=-6.5E+40           
parameters b2fn=0
parameters b3fn=-2.49E+7           
parameters a1fn=9.25e+41   
parameters a2fn=0  
parameters a3fn=1.475e+9  
parameters c1fn=1.5E+41     
parameters c2fn=1E+14  
parameters c3fn=5E+7 
parameters b1fp=-5.5E+41   
parameters b2fp=0    
parameters b3fp=-7E+9   
parameters a1fp=1.19E+43   
parameters a2fp=3.995E+17  
parameters a3fp=4E+10 
parameters c1fp=1.2E+42   
parameters c2fp=1E+15    
parameters c3fp=1.5E+10    
parameters noian=a1fn * (abs(noiseflagn) + noiseflagn) + b1fn * (abs(noiseflagn) 
+ - noiseflagn) + c1fn
parameters noibn=a2fn * (abs(noiseflagn) + noiseflagn) + b2fn * (abs(noiseflagn) 
+ - noiseflagn) + c2fn
parameters noicn=a3fn * (abs(noiseflagn) + noiseflagn) + b3fn * (abs(noiseflagn) 
+ - noiseflagn) + c3fn
parameters noiap=a1fp * (abs(noiseflagp) + noiseflagp) + b1fp * (abs(noiseflagp) 
+ - noiseflagp) + c1fp
parameters noibp=a2fp * (abs(noiseflagp) + noiseflagp) + b2fp * (abs(noiseflagp) 
+ - noiseflagp) + c2fp
parameters noicp=a3fp * (abs(noiseflagp) + noiseflagp) + b3fp * (abs(noiseflagp) 
+ - noiseflagp) + c3fp
include "crn65gplus_2d5_lk_v1d0.scs" section=mos
endsection fs
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_hvt
parameters parn1_hvt=0
parameters parn2_hvt=0
parameters parp1_hvt=0
parameters parp2_hvt=0
parameters toxn_hvt=2e-09
parameters dxln_hvt=0
parameters dxwn_hvt=0
parameters cjn_hvt=1.32969e-03
parameters cjswn_hvt=6.68996e-11
parameters cjswgn_hvt=3.35356e-10
parameters cgon_hvt=5.174670e-11
parameters cgln_hvt=1.337910e-11
parameters ddlcn_hvt=3.414150e-09
parameters ntoxn_hvt=1
parameters cfn_hvt=1.39e-10 + 4.1e-11 * ccoflag_hvt
parameters dvthn_hvt=0
parameters dlvthn_hvt=0
parameters dwvthn_hvt=0
parameters dpvthn_hvt=0
parameters dk2n_hvt=0
parameters dlk2n_hvt=0
parameters dwk2n_hvt=0
parameters dpk2n_hvt=0
parameters dcitn_hvt=0
parameters dlcitn_hvt=0
parameters dwcitn_hvt=0
parameters dpcitn_hvt=0
parameters dnfactorn_hvt=0
parameters dlnfactorn_hvt=0
parameters dwnfactorn_hvt=0
parameters dpnfactorn_hvt=0
parameters dvoffn_hvt=0
parameters dlvoffn_hvt=0
parameters dwvoffn_hvt=0
parameters dpvoffn_hvt=0
parameters dpclmn_hvt=0
parameters dlpclmn_hvt=0
parameters dwpclmn_hvt=0
parameters dppclmn_hvt=0
parameters dvsatn_hvt=0
parameters dlvsatn_hvt=0
parameters dwvsatn_hvt=0
parameters dpvsatn_hvt=0
parameters deta0n_hvt=0
parameters dleta0n_hvt=0
parameters dweta0n_hvt=0
parameters dpeta0n_hvt=0
parameters du0n_hvt=0
parameters dlu0n_hvt=0
parameters dwu0n_hvt=0
parameters dpu0n_hvt=0
parameters dagsn_hvt=0
parameters dlagsn_hvt=0
parameters dwagsn_hvt=0
parameters dpagsn_hvt=0
parameters da0n_hvt=0
parameters dla0n_hvt=0
parameters dwa0n_hvt=0
parameters dpa0n_hvt=0
parameters dlatn_hvt=0
parameters dluc1n_hvt=0
parameters dlub1n_hvt=0
parameters dpatn_hvt=0
parameters dpkt1n_hvt=0
parameters dlubn_hvt=0
parameters dpubn_hvt=0
parameters dlkt1n_hvt=0
parameters dlkt2n_hvt=0
parameters dpkt2n_hvt=0
parameters ss_flag_hvt=0
parameters ff_flag_hvt=0
parameters sf_flag_hvt=0
parameters fs_flag_hvt=0
parameters toxp_hvt=2.2e-09
parameters dxlp_hvt=0
parameters dxwp_hvt=0
parameters cjp_hvt=1.0800e-03
parameters cjswp_hvt=6.4000e-11
parameters cjswgp_hvt=3.0500e-10
parameters cgop_hvt=2.616320e-11
parameters cglp_hvt=3.692040e-11
parameters ddlcp_hvt=3.655840e-09
parameters cfp_hvt=1.38e-10 + 4.6e-11 * ccoflag_hvt
parameters ntoxp_hvt=1
parameters drdswp_hvt=0
parameters dvthp_hvt=0
parameters dlvthp_hvt=0
parameters dwvthp_hvt=0
parameters dpvthp_hvt=0
parameters dvsatp_hvt=0
parameters dlvsatp_hvt=0
parameters dwvsatp_hvt=0
parameters dpvsatp_hvt=0
parameters deta0p_hvt=0
parameters dleta0p_hvt=0
parameters dweta0p_hvt=0
parameters dpeta0p_hvt=0
parameters dk2p_hvt=0
parameters dlk2p_hvt=0
parameters dwk2p_hvt=0
parameters dpk2p_hvt=0
parameters dnfactorp_hvt=0
parameters dlnfactorp_hvt=0
parameters dwnfactorp_hvt=0
parameters dpnfactorp_hvt=0
parameters dvoffp_hvt=0
parameters dlvoffp_hvt=0
parameters dwvoffp_hvt=0
parameters dpvoffp_hvt=0
parameters dpclmp_hvt=0
parameters dlpclmp_hvt=0
parameters dwpclmp_hvt=0
parameters dppclmp_hvt=0
parameters du0p_hvt=0
parameters dlu0p_hvt=0
parameters dwu0p_hvt=0
parameters dpu0p_hvt=0
parameters dcitp_hvt=0
parameters dlcitp_hvt=0
parameters dwcitp_hvt=0
parameters dpcitp_hvt=0
parameters dagsp_hvt=0
parameters dlagsp_hvt=0
parameters dwagsp_hvt=0
parameters dpagsp_hvt=0
parameters da0p_hvt=0
parameters dla0p_hvt=0
parameters dwa0p_hvt=0
parameters dpa0p_hvt=0
parameters datp_hvt=0
parameters dub1p_hvt=0
parameters dlub1p_hvt=0
parameters dua1p_hvt=0
parameters dlua1p_hvt=0
parameters duc1p_hvt=0
parameters dluc1p_hvt=0
parameters dlubp_hvt=0
parameters dpubp_hvt=0
parameters dlkt1p_hvt=0
parameters dpkt1p_hvt=0
parameters dlkt2p_hvt=0
parameters dpkt2p_hvt=0
parameters b1fn_hvt=-1.1E+41   
parameters b2fn_hvt=-2.2E+16   
parameters b3fn_hvt=-7.5E+7 
parameters a1fn_hvt=3.875E+42 
parameters a2fn_hvt=0   
parameters a3fn_hvt=-8E+7  
parameters c1fn_hvt=2.5E+41  
parameters c2fn_hvt=5E+16    
parameters c3fn_hvt=1.7E+8   
parameters b1fp_hvt=-1.163E+42    
parameters b2fp_hvt=0    
parameters b3fp_hvt=-4.25E+9    
parameters a1fp_hvt=2.133E+43    
parameters a2fp_hvt=0    
parameters a3fp_hvt=3.163E+11   
parameters c1fp_hvt=2.35E+42    
parameters c2fp_hvt=3E+13   
parameters c3fp_hvt=1.75E+10    
parameters noian_hvt=a1fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b1fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c1fn_hvt
parameters noibn_hvt=a2fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b2fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c2fn_hvt
parameters noicn_hvt=a3fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b3fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c3fn_hvt
parameters noiap_hvt=a1fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b1fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c1fp_hvt
parameters noibp_hvt=a2fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b2fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c2fp_hvt
parameters noicp_hvt=a3fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b3fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c3fp_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_hvt
endsection tt_hvt
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_hvt
parameters parn1_hvt=0
parameters parn2_hvt=0
parameters parp1_hvt=0
parameters parp2_hvt=0
parameters toxn_hvt=2.06e-09
parameters dxln_hvt=4e-09
parameters dxwn_hvt=-8e-09
parameters cjn_hvt=1.42277e-03
parameters cjswn_hvt=7.15826e-11
parameters cjswgn_hvt=3.58831e-10
parameters cgon_hvt=4.81244e-11
parameters cgln_hvt=1.24426e-11
parameters ddlcn_hvt=3.41415e-09
parameters ntoxn_hvt=0.81
parameters cfn_hvt=1.293e-10 + 4.1e-11 * ccoflag_hvt
parameters dvthn_hvt=0.0178
parameters dlvthn_hvt=0.3e-9
parameters dwvthn_hvt=2.9e-09
parameters dpvthn_hvt=1.68e-16
parameters dk2n_hvt=-0.0017
parameters dlk2n_hvt=6e-10
parameters dwk2n_hvt=6e-10
parameters dpk2n_hvt=0
parameters dcitn_hvt=0
parameters dlcitn_hvt=0.20e-10
parameters dwcitn_hvt=0
parameters dpcitn_hvt=0.7e-17
parameters dnfactorn_hvt=0
parameters dlnfactorn_hvt=0
parameters dwnfactorn_hvt=0
parameters dpnfactorn_hvt=0
parameters dvoffn_hvt=0
parameters dlvoffn_hvt=-2.20e-10
parameters dwvoffn_hvt=3.3e-10
parameters dpvoffn_hvt=0.35e-16
parameters dpclmn_hvt=0
parameters dlpclmn_hvt=0
parameters dwpclmn_hvt=0
parameters dppclmn_hvt=-7.0e-16
parameters dvsatn_hvt=0
parameters dlvsatn_hvt=0.00056
parameters dwvsatn_hvt=0
parameters dpvsatn_hvt=18.0e-11
parameters deta0n_hvt=0
parameters dleta0n_hvt=-19e-10
parameters dweta0n_hvt=0
parameters dpeta0n_hvt=-0.60e-16
parameters du0n_hvt=0
parameters dlu0n_hvt=-45.2e-12
parameters dwu0n_hvt=0.5e-11
parameters dpu0n_hvt=2.5e-18
parameters dagsn_hvt=0.15
parameters dlagsn_hvt=0
parameters dwagsn_hvt=1.5e-8
parameters dpagsn_hvt=0
parameters da0n_hvt=0
parameters dla0n_hvt=0
parameters dwa0n_hvt=0
parameters dpa0n_hvt=0.8e-14
parameters dlatn_hvt=1.8e-3
parameters dluc1n_hvt=-0.08e-16
parameters dlub1n_hvt=0
parameters dpatn_hvt=1.1e-10
parameters dpkt1n_hvt=0
parameters dlubn_hvt=-2.0e-27
parameters dpubn_hvt=0
parameters dlkt1n_hvt=-0.10e-8
parameters dlkt2n_hvt=-1.5e-10
parameters dpkt2n_hvt=0
parameters ss_flag_hvt=1
parameters ff_flag_hvt=0
parameters sf_flag_hvt=0
parameters fs_flag_hvt=0
parameters toxp_hvt=2.26e-09
parameters dxlp_hvt=4e-09
parameters dxwp_hvt=-8e-09
parameters cjp_hvt=1.1556e-03
parameters cjswp_hvt=6.8480e-11
parameters cjswgp_hvt=3.2635e-10
parameters cgop_hvt=2.43318e-11
parameters cglp_hvt=3.43360e-11
parameters ddlcp_hvt=3.65584e-09
parameters cfp_hvt=1.283e-10 + 4.6e-11 * ccoflag_hvt
parameters ntoxp_hvt=0.54
parameters drdswp_hvt=0
parameters dvthp_hvt=-0.0270
parameters dlvthp_hvt=-3.5e-10
parameters dwvthp_hvt=-4.6e-9
parameters dpvthp_hvt=-1.72e-16
parameters dvsatp_hvt=1000
parameters dlvsatp_hvt=0.00152
parameters dwvsatp_hvt=0
parameters dpvsatp_hvt=41.0e-11
parameters deta0p_hvt=0
parameters dleta0p_hvt=-19e-10
parameters dweta0p_hvt=0
parameters dpeta0p_hvt=5e-17
parameters dk2p_hvt=0
parameters dlk2p_hvt=5.5e-10
parameters dwk2p_hvt=5.5e-10
parameters dpk2p_hvt=0
parameters dnfactorp_hvt=0
parameters dlnfactorp_hvt=0
parameters dwnfactorp_hvt=0
parameters dpnfactorp_hvt=0
parameters dvoffp_hvt=0
parameters dlvoffp_hvt=-4.5e-10
parameters dwvoffp_hvt=5.5e-10
parameters dpvoffp_hvt=-4.2e-17
parameters dpclmp_hvt=0
parameters dlpclmp_hvt=0
parameters dwpclmp_hvt=0
parameters dppclmp_hvt=-3.5e-15
parameters du0p_hvt=0.00000
parameters dlu0p_hvt=-15.0e-12
parameters dwu0p_hvt=-0.5e-11
parameters dpu0p_hvt=-4.9e-18
parameters dcitp_hvt=0
parameters dlcitp_hvt=3.5e-11
parameters dwcitp_hvt=0
parameters dpcitp_hvt=0.3e-17
parameters dagsp_hvt=0
parameters dlagsp_hvt=1.2e-7
parameters dwagsp_hvt=8.1e-8
parameters dpagsp_hvt=0
parameters da0p_hvt=0
parameters dla0p_hvt=0
parameters dwa0p_hvt=5.8e-8
parameters dpa0p_hvt=0
parameters datp_hvt=0
parameters dub1p_hvt=0
parameters dlub1p_hvt=0
parameters dua1p_hvt=0.3e-9
parameters dlua1p_hvt=0
parameters duc1p_hvt=0
parameters dluc1p_hvt=0
parameters dlubp_hvt=-6.0e-27
parameters dpubp_hvt=-0.4e-33
parameters dlkt1p_hvt=-0.1e-8
parameters dpkt1p_hvt=0
parameters dlkt2p_hvt=-1.4e-10
parameters dpkt2p_hvt=0
parameters b1fn_hvt=-1.1E+41   
parameters b2fn_hvt=-2.2E+16   
parameters b3fn_hvt=-7.5E+7 
parameters a1fn_hvt=3.875E+42 
parameters a2fn_hvt=0   
parameters a3fn_hvt=-8E+7  
parameters c1fn_hvt=2.5E+41  
parameters c2fn_hvt=5E+16    
parameters c3fn_hvt=1.7E+8   
parameters b1fp_hvt=-1.163E+42    
parameters b2fp_hvt=0    
parameters b3fp_hvt=-4.25E+9    
parameters a1fp_hvt=2.133E+43    
parameters a2fp_hvt=0    
parameters a3fp_hvt=3.163E+11   
parameters c1fp_hvt=2.35E+42    
parameters c2fp_hvt=3E+13   
parameters c3fp_hvt=1.75E+10   
parameters noian_hvt=a1fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b1fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c1fn_hvt
parameters noibn_hvt=a2fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b2fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c2fn_hvt
parameters noicn_hvt=a3fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b3fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c3fn_hvt
parameters noiap_hvt=a1fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b1fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c1fp_hvt
parameters noibp_hvt=a2fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b2fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c2fp_hvt
parameters noicp_hvt=a3fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b3fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c3fp_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_hvt
endsection ss_hvt
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_hvt
parameters parn1_hvt=0
parameters parn2_hvt=0
parameters parp1_hvt=0
parameters parp2_hvt=0
parameters toxn_hvt=1.94e-09
parameters dxln_hvt=-4e-09
parameters dxwn_hvt=8e-09
parameters cjn_hvt=1.23661e-03
parameters cjswn_hvt=6.22166e-11
parameters cjswgn_hvt=3.11881e-10
parameters cgon_hvt=5.53690e-11
parameters cgln_hvt=1.43156e-11
parameters ddlcn_hvt=3.41415e-09
parameters ntoxn_hvt=1.22
parameters cfn_hvt=1.487e-10 + 4.1e-11 * ccoflag_hvt
parameters dvthn_hvt=-0.0174
parameters dlvthn_hvt=-0.65e-9
parameters dwvthn_hvt=-3.4e-09
parameters dpvthn_hvt=-1.68e-16
parameters dk2n_hvt=0.0013
parameters dlk2n_hvt=-6e-10
parameters dwk2n_hvt=-6e-10
parameters dpk2n_hvt=-3e-17
parameters dcitn_hvt=0
parameters dlcitn_hvt=-0.95e-10
parameters dwcitn_hvt=0
parameters dpcitn_hvt=-0.88e-17
parameters dnfactorn_hvt=0
parameters dlnfactorn_hvt=0
parameters dwnfactorn_hvt=0
parameters dpnfactorn_hvt=0
parameters dvoffn_hvt=0
parameters dlvoffn_hvt=2.49e-10
parameters dwvoffn_hvt=-3.3e-10
parameters dpvoffn_hvt=-0.38e-16
parameters dpclmn_hvt=0
parameters dlpclmn_hvt=0
parameters dwpclmn_hvt=0
parameters dppclmn_hvt=7.2e-16
parameters dvsatn_hvt=0
parameters dlvsatn_hvt=-0.00046
parameters dwvsatn_hvt=0
parameters dpvsatn_hvt=-4.12e-11
parameters deta0n_hvt=0
parameters dleta0n_hvt=9.2e-10
parameters dweta0n_hvt=0
parameters dpeta0n_hvt=0.52e-16
parameters du0n_hvt=0
parameters dlu0n_hvt=95.2e-12
parameters dwu0n_hvt=0.3e-11
parameters dpu0n_hvt=-0.4e-18
parameters dagsn_hvt=-0.20
parameters dlagsn_hvt=0
parameters dwagsn_hvt=-2.5e-8
parameters dpagsn_hvt=0
parameters da0n_hvt=0
parameters dla0n_hvt=0
parameters dwa0n_hvt=0
parameters dpa0n_hvt=0
parameters dlatn_hvt=0
parameters dluc1n_hvt=0
parameters dlub1n_hvt=0
parameters dpatn_hvt=0
parameters dpkt1n_hvt=0
parameters dlubn_hvt=8.2e-27
parameters dpubn_hvt=0.58e-33
parameters dlkt1n_hvt=0.15e-8
parameters dlkt2n_hvt=0
parameters dpkt2n_hvt=0
parameters ss_flag_hvt=0
parameters ff_flag_hvt=1
parameters sf_flag_hvt=0
parameters fs_flag_hvt=0
parameters toxp_hvt=2.14e-09
parameters dxlp_hvt=-4e-09
parameters dxwp_hvt=8e-09
parameters cjp_hvt=1.0044e-03
parameters cjswp_hvt=5.9520e-11
parameters cjswgp_hvt=2.8365e-10
parameters cgop_hvt=2.79946e-11
parameters cglp_hvt=3.95048e-11
parameters ddlcp_hvt=3.65584e-09
parameters cfp_hvt=1.477e-10 + 4.6e-11 * ccoflag_hvt
parameters ntoxp_hvt=1.38
parameters drdswp_hvt=0
parameters dvthp_hvt=0.0272
parameters dlvthp_hvt=5.2e-10
parameters dwvthp_hvt=5.9e-9
parameters dpvthp_hvt=1.70e-16
parameters dvsatp_hvt=0
parameters dlvsatp_hvt=-0.00058
parameters dwvsatp_hvt=0
parameters dpvsatp_hvt=-6.5e-11
parameters deta0p_hvt=0
parameters dleta0p_hvt=10.2e-10
parameters dweta0p_hvt=0
parameters dpeta0p_hvt=-1e-17
parameters dk2p_hvt=0
parameters dlk2p_hvt=-5.5e-10
parameters dwk2p_hvt=-5.5e-10
parameters dpk2p_hvt=0
parameters dnfactorp_hvt=0
parameters dlnfactorp_hvt=0
parameters dwnfactorp_hvt=0
parameters dpnfactorp_hvt=0
parameters dvoffp_hvt=0
parameters dlvoffp_hvt=6.1e-10
parameters dwvoffp_hvt=-0.5e-10
parameters dpvoffp_hvt=5.6e-17
parameters dpclmp_hvt=0
parameters dlpclmp_hvt=0
parameters dwpclmp_hvt=0
parameters dppclmp_hvt=8.5e-15
parameters du0p_hvt=-0.00000
parameters dlu0p_hvt=20.5e-12
parameters dwu0p_hvt=0.5e-11
parameters dpu0p_hvt=9.9e-18
parameters dcitp_hvt=0
parameters dlcitp_hvt=-4.2e-11
parameters dwcitp_hvt=0
parameters dpcitp_hvt=-1.7e-17
parameters dagsp_hvt=-0.25
parameters dlagsp_hvt=0
parameters dwagsp_hvt=-5.8e-8
parameters dpagsp_hvt=0
parameters da0p_hvt=0
parameters dla0p_hvt=0.8e-7
parameters dwa0p_hvt=1.0e-8
parameters dpa0p_hvt=2.0e-14
parameters datp_hvt=0
parameters dub1p_hvt=0
parameters dlub1p_hvt=0
parameters dua1p_hvt=0
parameters dlua1p_hvt=0
parameters duc1p_hvt=0
parameters dluc1p_hvt=0
parameters dlubp_hvt=9.8e-27
parameters dpubp_hvt=0.58e-33
parameters dlkt1p_hvt=0.2e-8
parameters dpkt1p_hvt=0
parameters dlkt2p_hvt=0
parameters dpkt2p_hvt=0
parameters b1fn_hvt=-1.1E+41   
parameters b2fn_hvt=-2.2E+16   
parameters b3fn_hvt=-7.5E+7 
parameters a1fn_hvt=3.875E+42 
parameters a2fn_hvt=0   
parameters a3fn_hvt=-8E+7  
parameters c1fn_hvt=2.5E+41  
parameters c2fn_hvt=5E+16    
parameters c3fn_hvt=1.7E+8   
parameters b1fp_hvt=-1.163E+42    
parameters b2fp_hvt=0    
parameters b3fp_hvt=-4.25E+9    
parameters a1fp_hvt=2.133E+43    
parameters a2fp_hvt=0    
parameters a3fp_hvt=3.163E+11   
parameters c1fp_hvt=2.35E+42    
parameters c2fp_hvt=3E+13   
parameters c3fp_hvt=1.75E+10   
parameters noian_hvt=a1fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b1fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c1fn_hvt
parameters noibn_hvt=a2fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b2fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c2fn_hvt
parameters noicn_hvt=a3fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b3fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c3fn_hvt
parameters noiap_hvt=a1fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b1fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c1fp_hvt
parameters noibp_hvt=a2fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b2fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c2fp_hvt
parameters noicp_hvt=a3fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b3fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c3fp_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_hvt
endsection ff_hvt
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_hvt
parameters parn1_hvt=0
parameters parn2_hvt=0
parameters parp1_hvt=0
parameters parp2_hvt=0
parameters a1n_hvt=0.8
parameters a1p_hvt=-0.8
parameters a2n_hvt=0
parameters a2p_hvt=0
parameters a3n_hvt=-1
parameters a3p_hvt=1
parameters a4np_hvt=0
parameters toxn_hvt=2e-09 + 6.0000e-11 * a4np_hvt
parameters dxln_hvt=4e-09 * a2n_hvt
parameters dxwn_hvt=8e-09 * a3n_hvt
parameters cjn_hvt=1.32969e-03 * (1 + 0.070 * a1n_hvt)
parameters cjswn_hvt=6.68996e-11 * (1 + 0.070 * a1n_hvt)
parameters cjswgn_hvt=3.35356e-10 * (1 + 0.070 * a1n_hvt)
parameters cgon_hvt=5.17467e-11 * (1 - 0.070 * a4np_hvt)
parameters cgln_hvt=1.33791e-11 * (1 - 0.070 * a4np_hvt)
parameters ddlcn_hvt=3.41415e-09 + 0.0000e+00 * a1n_hvt
parameters ntoxn_hvt=1 +  - 2.2000e-01 * a4np_hvt
parameters cfn_hvt=1.39e-10 * (1 - 0.070 * a4np_hvt) + 4.1e-11 * ccoflag_hvt
parameters dvthn_hvt=0.0174 * a1n_hvt
parameters dlvthn_hvt=6.5e-10 * a1n_hvt
parameters dwvthn_hvt=3.4e-09 * a1n_hvt
parameters dpvthn_hvt=1.68e-16 * a1n_hvt
parameters dk2n_hvt= - 0.0013 * a1n_hvt
parameters dlk2n_hvt=6e-10 * a1n_hvt
parameters dwk2n_hvt=6e-10 * a1n_hvt
parameters dpk2n_hvt=3e-17 * a1n_hvt
parameters dcitn_hvt=0
parameters dlcitn_hvt=9.5e-11 * a1n_hvt
parameters dwcitn_hvt=0
parameters dpcitn_hvt=8.8e-18 * a1n_hvt
parameters dnfactorn_hvt=0
parameters dlnfactorn_hvt=0
parameters dwnfactorn_hvt=0
parameters dpnfactorn_hvt=0
parameters dvoffn_hvt=0
parameters dlvoffn_hvt= - 2.49e-10 * a1n_hvt
parameters dwvoffn_hvt=3.3e-10 * a1n_hvt
parameters dpvoffn_hvt=3.8e-17 * a1n_hvt
parameters dpclmn_hvt=0
parameters dlpclmn_hvt=-2.0e-9
parameters dwpclmn_hvt=0
parameters dppclmn_hvt= - 7.2e-16 * a1n_hvt
parameters dvsatn_hvt=0
parameters dlvsatn_hvt=0.00046 * a1n_hvt
parameters dwvsatn_hvt=0
parameters dpvsatn_hvt=4.12e-11 * a1n_hvt
parameters deta0n_hvt=0
parameters dleta0n_hvt= - 9.2e-10 * a1n_hvt
parameters dweta0n_hvt=0
parameters dpeta0n_hvt= - 5.2e-17 * a1n_hvt
parameters du0n_hvt=0
parameters dlu0n_hvt= - 10.52e-11 * a1n_hvt
parameters dwu0n_hvt= - 3e-12 * a1n_hvt
parameters dpu0n_hvt= - 18e-19 * a1n_hvt
parameters dagsn_hvt=0.2 * a1n_hvt
parameters dlagsn_hvt=0
parameters dwagsn_hvt=2.5e-08 * a1n_hvt
parameters dpagsn_hvt=0
parameters da0n_hvt=0
parameters dla0n_hvt=7e-08
parameters dwa0n_hvt=0
parameters dpa0n_hvt=-1.5e-14
parameters dlatn_hvt=0
parameters dluc1n_hvt=0.11e-17
parameters dlub1n_hvt=0.01e-24
parameters dpatn_hvt=0
parameters dpkt1n_hvt=0
parameters dlubn_hvt= - 8.2e-27 * a1n_hvt
parameters dpubn_hvt= - 5.8e-34 * a1n_hvt
parameters dlkt1n_hvt= - 1.5e-09 * a1n_hvt
parameters dlkt2n_hvt=-4.5e-10
parameters dpkt2n_hvt=0
parameters ss_flag_hvt=0
parameters ff_flag_hvt=0
parameters sf_flag_hvt=1
parameters fs_flag_hvt=0
parameters toxp_hvt=2.2e-09 + 6.0000e-11 * a4np_hvt
parameters dxlp_hvt=4e-09 * a2p_hvt
parameters dxwp_hvt=8e-09 * a3p_hvt
parameters cjp_hvt=1.0800e-03 * (1 + 0.070 * a1p_hvt)
parameters cjswp_hvt=6.4000e-11 * (1 + 0.070 * a1p_hvt)
parameters cjswgp_hvt=3.0500e-10 * (1 + 0.070 * a1p_hvt)
parameters cgop_hvt=2.61632e-11 * (1 - 0.070 * a4np_hvt)
parameters cglp_hvt=3.69204e-11 * (1 - 0.070 * a4np_hvt)
parameters ddlcp_hvt=3.65584e-09 + 0.0000e+00 * a1p_hvt
parameters cfp_hvt=1.38e-10 * (1 - 0.070 * a4np_hvt) + 4.6e-11 * ccoflag_hvt
parameters ntoxp_hvt=1 +  - 3.8000e-01 * a4np_hvt
parameters drdswp_hvt=0
parameters dvthp_hvt= - 0.0272 * a1p_hvt
parameters dlvthp_hvt= - 5.2e-10 * a1p_hvt
parameters dwvthp_hvt= - 5.9e-09 * a1p_hvt
parameters dpvthp_hvt= - 1.7e-16 * a1p_hvt
parameters dvsatp_hvt=0
parameters dlvsatp_hvt=0.00058 * a1p_hvt
parameters dwvsatp_hvt=0
parameters dpvsatp_hvt=6.5e-11 * a1p_hvt
parameters deta0p_hvt=0
parameters dleta0p_hvt= - 1.02e-09 * a1p_hvt
parameters dweta0p_hvt=0
parameters dpeta0p_hvt=1e-17 * a1p_hvt
parameters dk2p_hvt=0
parameters dlk2p_hvt=5.5e-10 * a1p_hvt
parameters dwk2p_hvt=5.5e-10 * a1p_hvt
parameters dpk2p_hvt=0
parameters dnfactorp_hvt=0
parameters dlnfactorp_hvt=0
parameters dwnfactorp_hvt=0
parameters dpnfactorp_hvt=0
parameters dvoffp_hvt=0
parameters dlvoffp_hvt= - 6.1e-10 * a1p_hvt
parameters dwvoffp_hvt=5e-11 * a1p_hvt
parameters dpvoffp_hvt= - 5.6e-17 * a1p_hvt
parameters dpclmp_hvt=0
parameters dlpclmp_hvt=2.0e-8
parameters dwpclmp_hvt=0
parameters dppclmp_hvt= - 5.5e-15 * a1p_hvt
parameters du0p_hvt=0 * a1p_hvt
parameters dlu0p_hvt= - 5.05e-11 * a1p_hvt
parameters dwu0p_hvt= - 5e-12 * a1p_hvt
parameters dpu0p_hvt= - 9.9e-18 * a1p_hvt
parameters dcitp_hvt=0
parameters dlcitp_hvt=4.2e-11 * a1p_hvt
parameters dwcitp_hvt=0
parameters dpcitp_hvt=1.7e-17 * a1p_hvt
parameters dagsp_hvt=0.25 * a1p_hvt
parameters dlagsp_hvt=0
parameters dwagsp_hvt=5.8e-08 * a1p_hvt
parameters dpagsp_hvt=0
parameters da0p_hvt=0
parameters dla0p_hvt= - 8e-08 * a1p_hvt
parameters dwa0p_hvt= - 1e-08 * a1p_hvt
parameters dpa0p_hvt= - 2e-14 * a1p_hvt
parameters datp_hvt=0
parameters dub1p_hvt=0
parameters dlub1p_hvt=0
parameters dua1p_hvt=0
parameters dlua1p_hvt=0
parameters duc1p_hvt=0
parameters dluc1p_hvt=0
parameters dlubp_hvt= - 9.8e-27 * a1p_hvt
parameters dpubp_hvt= - 5.8e-34 * a1p_hvt
parameters dlkt1p_hvt= - 2e-09 * a1p_hvt
parameters dpkt1p_hvt=0
parameters dlkt2p_hvt=0
parameters dpkt2p_hvt=0
parameters b1fn_hvt=-1.1E+41   
parameters b2fn_hvt=-2.2E+16   
parameters b3fn_hvt=-7.5E+7 
parameters a1fn_hvt=3.875E+42 
parameters a2fn_hvt=0   
parameters a3fn_hvt=-8E+7  
parameters c1fn_hvt=2.5E+41  
parameters c2fn_hvt=5E+16    
parameters c3fn_hvt=1.7E+8   
parameters b1fp_hvt=-1.163E+42    
parameters b2fp_hvt=0    
parameters b3fp_hvt=-4.25E+9    
parameters a1fp_hvt=2.133E+43    
parameters a2fp_hvt=0    
parameters a3fp_hvt=3.163E+11   
parameters c1fp_hvt=2.35E+42    
parameters c2fp_hvt=3E+13   
parameters c3fp_hvt=1.75E+10   
parameters noian_hvt=a1fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b1fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c1fn_hvt
parameters noibn_hvt=a2fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b2fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c2fn_hvt
parameters noicn_hvt=a3fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b3fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c3fn_hvt
parameters noiap_hvt=a1fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b1fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c1fp_hvt
parameters noibp_hvt=a2fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b2fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c2fp_hvt
parameters noicp_hvt=a3fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b3fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c3fp_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_hvt
endsection sf_hvt
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_hvt
parameters parn1_hvt=0
parameters parn2_hvt=0
parameters parp1_hvt=0
parameters parp2_hvt=0
parameters a1n_hvt=-0.8
parameters a1p_hvt=0.8
parameters a2n_hvt=0
parameters a2p_hvt=0
parameters a3n_hvt=1
parameters a3p_hvt=-1
parameters a4np_hvt=0
parameters toxn_hvt=2e-09 + 6.0000e-11 * a4np_hvt
parameters dxln_hvt=4e-09 * a2n_hvt
parameters dxwn_hvt=8e-09 * a3n_hvt
parameters cjn_hvt=1.32969e-03 * (1 + 0.070 * a1n_hvt)
parameters cjswn_hvt=6.68996e-11 * (1 + 0.070 * a1n_hvt)
parameters cjswgn_hvt=3.35356e-10 * (1 + 0.070 * a1n_hvt)
parameters cgon_hvt=5.17467e-11 * (1 - 0.070 * a4np_hvt)
parameters cgln_hvt=1.33791e-11 * (1 - 0.070 * a4np_hvt)
parameters ddlcn_hvt=3.41415e-09 + 0.0000e+00 * a1n_hvt
parameters ntoxn_hvt=1 +  - 2.2000e-01 * a4np_hvt
parameters cfn_hvt=1.39e-10 * (1 - 0.070 * a4np_hvt) + 4.1e-11 * ccoflag_hvt
parameters dvthn_hvt=0.0174 * a1n_hvt
parameters dlvthn_hvt=6.5e-10 * a1n_hvt
parameters dwvthn_hvt=3.4e-09 * a1n_hvt
parameters dpvthn_hvt=1.68e-16 * a1n_hvt
parameters dk2n_hvt= - 0.0013 * a1n_hvt
parameters dlk2n_hvt=6e-10 * a1n_hvt
parameters dwk2n_hvt=6e-10 * a1n_hvt
parameters dpk2n_hvt=3e-17 * a1n_hvt
parameters dcitn_hvt=0
parameters dlcitn_hvt=9.5e-11 * a1n_hvt
parameters dwcitn_hvt=0
parameters dpcitn_hvt=8.8e-18 * a1n_hvt
parameters dnfactorn_hvt=0
parameters dlnfactorn_hvt=0
parameters dwnfactorn_hvt=0
parameters dpnfactorn_hvt=0
parameters dvoffn_hvt=0
parameters dlvoffn_hvt= - 2.49e-10 * a1n_hvt
parameters dwvoffn_hvt=3.3e-10 * a1n_hvt
parameters dpvoffn_hvt=3.8e-17 * a1n_hvt
parameters dpclmn_hvt=0
parameters dlpclmn_hvt=2.3e-9
parameters dwpclmn_hvt=0
parameters dppclmn_hvt= - 7.2e-16 * a1n_hvt
parameters dvsatn_hvt=0
parameters dlvsatn_hvt=0.00046 * a1n_hvt
parameters dwvsatn_hvt=0
parameters dpvsatn_hvt=4.12e-11 * a1n_hvt
parameters deta0n_hvt=0
parameters dleta0n_hvt= - 9.2e-10 * a1n_hvt
parameters dweta0n_hvt=0
parameters dpeta0n_hvt= - 5.2e-17 * a1n_hvt
parameters du0n_hvt=0
parameters dlu0n_hvt= - 9.52e-11 * a1n_hvt
parameters dwu0n_hvt= - 3e-12 * a1n_hvt
parameters dpu0n_hvt=4e-19 * a1n_hvt
parameters dagsn_hvt=0.2 * a1n_hvt
parameters dlagsn_hvt=0
parameters dwagsn_hvt=2.5e-08 * a1n_hvt
parameters dpagsn_hvt=0
parameters da0n_hvt=0
parameters dla0n_hvt=-9.0e-08
parameters dwa0n_hvt=0
parameters dpa0n_hvt=1.5e-14
parameters dlatn_hvt=0
parameters dluc1n_hvt=0
parameters dlub1n_hvt=0
parameters dpatn_hvt=0
parameters dpkt1n_hvt=0
parameters dlubn_hvt= - 8.2e-27 * a1n_hvt
parameters dpubn_hvt= - 5.8e-34 * a1n_hvt
parameters dlkt1n_hvt= - 1.5e-09 * a1n_hvt
parameters dlkt2n_hvt=0
parameters dpkt2n_hvt=0
parameters ss_flag_hvt=0
parameters ff_flag_hvt=0
parameters sf_flag_hvt=0
parameters fs_flag_hvt=1
parameters toxp_hvt=2.2e-09 + 6.0000e-11 * a4np_hvt
parameters dxlp_hvt=4e-09 * a2p_hvt
parameters dxwp_hvt=8e-09 * a3p_hvt
parameters cjp_hvt=1.0800e-03 * (1 + 0.070 * a1p_hvt)
parameters cjswp_hvt=6.4000e-11 * (1 + 0.070 * a1p_hvt)
parameters cjswgp_hvt=3.0500e-10 * (1 + 0.070 * a1p_hvt)
parameters cgop_hvt=2.61632e-11 * (1 - 0.070 * a4np_hvt)
parameters cglp_hvt=3.69204e-11 * (1 - 0.070 * a4np_hvt)
parameters ddlcp_hvt=3.65584e-09 + 0.0000e+00 * a1p_hvt
parameters cfp_hvt=1.38e-10 * (1 - 0.070 * a4np_hvt) + 4.6e-11 * ccoflag_hvt
parameters ntoxp_hvt=1 +  - 3.8000e-01 * a4np_hvt
parameters drdswp_hvt=0
parameters dvthp_hvt= - 0.0272 * a1p_hvt
parameters dlvthp_hvt= - 5.2e-10 * a1p_hvt
parameters dwvthp_hvt= - 5.9e-09 * a1p_hvt
parameters dpvthp_hvt= - 1.7e-16 * a1p_hvt
parameters dvsatp_hvt=0
parameters dlvsatp_hvt=0.00058 * a1p_hvt
parameters dwvsatp_hvt=0
parameters dpvsatp_hvt=6.5e-11 * a1p_hvt
parameters deta0p_hvt=0
parameters dleta0p_hvt= - 1.02e-09 * a1p_hvt
parameters dweta0p_hvt=0
parameters dpeta0p_hvt=1e-17 * a1p_hvt
parameters dk2p_hvt=0
parameters dlk2p_hvt=5.5e-10 * a1p_hvt
parameters dwk2p_hvt=5.5e-10 * a1p_hvt
parameters dpk2p_hvt=0
parameters dnfactorp_hvt=0
parameters dlnfactorp_hvt=0
parameters dwnfactorp_hvt=0
parameters dpnfactorp_hvt=0
parameters dvoffp_hvt=0
parameters dlvoffp_hvt= - 6.1e-10 * a1p_hvt
parameters dwvoffp_hvt=5e-11 * a1p_hvt
parameters dpvoffp_hvt= - 5.6e-17 * a1p_hvt
parameters dpclmp_hvt=0
parameters dlpclmp_hvt= - 3.5e-8 * 0
parameters dwpclmp_hvt=0
parameters dppclmp_hvt= - 6.5e-15 * a1p_hvt
parameters du0p_hvt=0 * a1p_hvt
parameters dlu0p_hvt= - 5.55e-11 * a1p_hvt
parameters dwu0p_hvt= - 5e-12 * a1p_hvt
parameters dpu0p_hvt= - 6.9e-18 * a1p_hvt
parameters dcitp_hvt=0
parameters dlcitp_hvt=4.2e-11 * a1p_hvt
parameters dwcitp_hvt=0
parameters dpcitp_hvt=1.7e-17 * a1p_hvt
parameters dagsp_hvt=0.25 * a1p_hvt
parameters dlagsp_hvt=0
parameters dwagsp_hvt=5.8e-08 * a1p_hvt
parameters dpagsp_hvt=0
parameters da0p_hvt=0
parameters dla0p_hvt= - 8e-08 * a1p_hvt
parameters dwa0p_hvt= - 1e-08 * a1p_hvt
parameters dpa0p_hvt= - 2e-14 * a1p_hvt
parameters datp_hvt=0
parameters dub1p_hvt=0
parameters dlub1p_hvt=0
parameters dua1p_hvt=0.1e-9
parameters dlua1p_hvt=0
parameters duc1p_hvt=-0.9e-10
parameters dluc1p_hvt=0
parameters dlubp_hvt= - 9.8e-27 * a1p_hvt
parameters dpubp_hvt= - 6.8e-34 * a1p_hvt
parameters dlkt1p_hvt= - 2e-09 * a1p_hvt
parameters dpkt1p_hvt=0
parameters dlkt2p_hvt=-4.0e-10
parameters dpkt2p_hvt=-0.3e-15
parameters b1fn_hvt=-1.1E+41   
parameters b2fn_hvt=-2.2E+16   
parameters b3fn_hvt=-7.5E+7 
parameters a1fn_hvt=3.875E+42 
parameters a2fn_hvt=0   
parameters a3fn_hvt=-8E+7  
parameters c1fn_hvt=2.5E+41  
parameters c2fn_hvt=5E+16    
parameters c3fn_hvt=1.7E+8   
parameters b1fp_hvt=-1.163E+42    
parameters b2fp_hvt=0    
parameters b3fp_hvt=-4.25E+9    
parameters a1fp_hvt=2.133E+43    
parameters a2fp_hvt=0    
parameters a3fp_hvt=3.163E+11   
parameters c1fp_hvt=2.35E+42    
parameters c2fp_hvt=3E+13   
parameters c3fp_hvt=1.75E+10   
parameters noian_hvt=a1fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b1fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c1fn_hvt
parameters noibn_hvt=a2fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b2fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c2fn_hvt
parameters noicn_hvt=a3fn_hvt * (abs(noiseflagn_hvt) + noiseflagn_hvt) + b3fn_hvt 
+ * (abs(noiseflagn_hvt) - noiseflagn_hvt) + c3fn_hvt
parameters noiap_hvt=a1fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b1fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c1fp_hvt
parameters noibp_hvt=a2fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b2fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c2fp_hvt
parameters noicp_hvt=a3fp_hvt * (abs(noiseflagp_hvt) + noiseflagp_hvt) + b3fp_hvt 
+ * (abs(noiseflagp_hvt) - noiseflagp_hvt) + c3fp_hvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_hvt
endsection fs_hvt
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_lvt
parameters parn1_lvt=0
parameters parn2_lvt=0
parameters parp1_lvt=0
parameters parp2_lvt=0
parameters ss_flag_lvt=0
parameters ff_flag_lvt=0
parameters sf_flag_lvt=0
parameters fs_flag_lvt=0
parameters toxn_lvt=2e-09
parameters dxwn_lvt=0
parameters dxln_lvt=0
parameters dvthn_lvt=0
parameters dlvthn_lvt=0
parameters dwvthn_lvt=0
parameters dpvthn_lvt=0
parameters cjn_lvt=1.207e-03
parameters cjswn_lvt=6.400e-11
parameters cjswgn_lvt=2.970e-10
parameters cgon_lvt=6.331500e-11
parameters cgln_lvt=9.587230e-13
parameters ddlcn_lvt=3.303970e-09
parameters cfn_lvt=1.39e-10 + 4.1e-11 * ccoflag_lvt
parameters drdswn_lvt=0
parameters dnfactorn_lvt=0
parameters dlnfactorn_lvt=0
parameters dwnfactorn_lvt=0
parameters dpnfactorn_lvt=0
parameters du0n_lvt=0
parameters dlu0n_lvt=0
parameters dwu0n_lvt=0
parameters dpu0n_lvt=0
parameters deta0n_lvt=0
parameters dleta0n_lvt=0
parameters dweta0n_lvt=0
parameters dpeta0n_lvt=0
parameters dvsatn_lvt=0
parameters dlvsatn_lvt=0
parameters dwvsatn_lvt=0
parameters dpvsatn_lvt=0
parameters ntoxn_lvt=1
parameters dk2n_lvt=0
parameters dlk2n_lvt=0
parameters dwk2n_lvt=0
parameters dpk2n_lvt=0
parameters dagsn_lvt=0
parameters dpclmn_lvt=0
parameters dppclmn_lvt=0
parameters dlcitn_lvt=0
parameters dwcitn_lvt=0
parameters dpcitn_lvt=0
parameters dlagsn_lvt=0
parameters datn_lvt=0
parameters dla0n_lvt=0
parameters dwa0n_lvt=0
parameters dpa0n_lvt=0
parameters dlatn_lvt=0
parameters dwatn_lvt=0
parameters dpatn_lvt=0
parameters dlkt1n_lvt=0
parameters dwkt1n_lvt=0
parameters dpkt1n_lvt=0
parameters dpagsn_lvt=0
parameters dwagsn_lvt=0
parameters dluan_lvt=0
parameters dpuan_lvt=0
parameters dlubn_lvt=0
parameters dpubn_lvt=0
parameters toxp_lvt=2.2e-09
parameters dxwp_lvt=0
parameters dxlp_lvt=0
parameters dvthp_lvt=0
parameters dlvthp_lvt=0
parameters dwvthp_lvt=0
parameters dpvthp_lvt=0
parameters cjp_lvt=1.020e-03
parameters cjswp_lvt=6.400e-11
parameters cjswgp_lvt=1.950e-10
parameters cgop_lvt=3.241690e-11
parameters cglp_lvt=7.368500e-11
parameters ddlcp_lvt=6.387060e-09
parameters cfp_lvt=1.38e-10 + 4.6e-11 * ccoflag_lvt
parameters drdswp_lvt=0
parameters dnfactorp_lvt=0
parameters dlnfactorp_lvt=0
parameters dwnfactorp_lvt=0
parameters dpnfactorp_lvt=0
parameters du0p_lvt=0
parameters dlu0p_lvt=0
parameters dwu0p_lvt=0
parameters dpu0p_lvt=0
parameters dvoffp_lvt=0
parameters dlvoffp_lvt=0
parameters dwvoffp_lvt=0
parameters dpvoffp_lvt=0
parameters deta0p_lvt=0
parameters dleta0p_lvt=0
parameters dweta0p_lvt=0
parameters dpeta0p_lvt=0
parameters dvsatp_lvt=0
parameters dlvsatp_lvt=0
parameters dwvsatp_lvt=0
parameters dpvsatp_lvt=0
parameters ntoxp_lvt=1
parameters dk2p_lvt=0
parameters dlk2p_lvt=0
parameters dwk2p_lvt=0
parameters dpk2p_lvt=0
parameters dagsp_lvt=0
parameters dlagsp_lvt=0
parameters dwagsp_lvt=0
parameters dpagsp_lvt=0
parameters da0p_lvt=0
parameters dla0p_lvt=0
parameters dwa0p_lvt=0
parameters dpa0p_lvt=0
parameters dpclmp_lvt=0
parameters dlpclmp_lvt=0
parameters dwpclmp_lvt=0
parameters dppclmp_lvt=0
parameters duc1p_lvt=0
parameters ducp_lvt=0
parameters dketap_lvt=0
parameters dlketap_lvt=0
parameters dwketap_lvt=0
parameters dpketap_lvt=0
parameters dlcitp_lvt=0
parameters dwcitp_lvt=0
parameters dpcitp_lvt=0
parameters dlatp_lvt=0
parameters dwatp_lvt=0
parameters dpatp_lvt=0
parameters dlkt1p_lvt=0
parameters dwkt1p_lvt=0
parameters dpkt1p_lvt=0
parameters dluap_lvt=0
parameters dpuap_lvt=0
parameters dlubp_lvt=0
parameters dpubp_lvt=0
parameters b1fn_lvt=-1.363E+41  
parameters b2fn_lvt=0   
parameters b3fn_lvt=-3.721E+7  
parameters a1fn_lvt=1.598E+42  
parameters a2fn_lvt=0   
parameters a3fn_lvt=2.5E+8   
parameters c1fn_lvt=3.050E+41   
parameters c2fn_lvt=5E+12   
parameters c3fn_lvt=7.5E+7  
parameters b1fp_lvt=-4.5E+41   
parameters b2fp_lvt=1.485E+15    
parameters b3fp_lvt=-9.5E+9
parameters a1fp_lvt=1.69E+43   
parameters a2fp_lvt=1.485E+15    
parameters a3fp_lvt=3.5E+10    
parameters c1fp_lvt=1.2E+42  
parameters c2fp_lvt=3E+13    
parameters c3fp_lvt=2E+10 
parameters noian_lvt=a1fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b1fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c1fn_lvt
parameters noibn_lvt=a2fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b2fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c2fn_lvt
parameters noicn_lvt=a3fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b3fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c3fn_lvt
parameters noiap_lvt=a1fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b1fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c1fp_lvt
parameters noibp_lvt=a2fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b2fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c2fp_lvt
parameters noicp_lvt=a3fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b3fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c3fp_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_lvt
endsection tt_lvt
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_lvt
parameters parn1_lvt=0
parameters parn2_lvt=0
parameters parp1_lvt=0
parameters parp2_lvt=0
parameters ss_flag_lvt=1
parameters ff_flag_lvt=0
parameters sf_flag_lvt=0
parameters fs_flag_lvt=0
parameters toxn_lvt=2.06e-09
parameters dxwn_lvt=-8e-09
parameters dxln_lvt=4e-09
parameters dvthn_lvt=0.027
parameters dlvthn_lvt=4.9e-10
parameters dwvthn_lvt=1.7e-9
parameters dpvthn_lvt=2.2e-16
parameters cjn_lvt=1.291e-03
parameters cjswn_lvt=6.848e-11
parameters cjswgn_lvt=3.178e-10
parameters cgon_lvt=5.88830e-11
parameters cgln_lvt=8.91612e-13
parameters ddlcn_lvt=3.30397e-09
parameters cfn_lvt=1.293e-10 + 4.1e-11 * ccoflag_lvt
parameters drdswn_lvt=-1
parameters dnfactorn_lvt=0
parameters dlnfactorn_lvt=0
parameters dwnfactorn_lvt=0
parameters dpnfactorn_lvt=0
parameters du0n_lvt=0
parameters dlu0n_lvt=-2e-10
parameters dwu0n_lvt=0
parameters dpu0n_lvt=0
parameters deta0n_lvt=0
parameters dleta0n_lvt=-9.36e-10
parameters dweta0n_lvt=0
parameters dpeta0n_lvt=-28.5e-17
parameters dvsatn_lvt=0
parameters dlvsatn_lvt=-0.00016
parameters dwvsatn_lvt=0
parameters dpvsatn_lvt=0
parameters ntoxn_lvt=0.52
parameters dk2n_lvt=0.016
parameters dlk2n_lvt=-2.7e-10
parameters dwk2n_lvt=1.3e-09
parameters dpk2n_lvt=8e-17
parameters dagsn_lvt=0.18
parameters dpclmn_lvt=0
parameters dppclmn_lvt=0
parameters dlcitn_lvt=0e-12
parameters dwcitn_lvt=0
parameters dpcitn_lvt=1e-18
parameters dlagsn_lvt=1e-7
parameters datn_lvt=0
parameters dla0n_lvt=-2.4e-7
parameters dwa0n_lvt=2.3e-7
parameters dpa0n_lvt=-2.9e-14
parameters dlatn_lvt=0
parameters dwatn_lvt=0
parameters dpatn_lvt=0
parameters dlkt1n_lvt=0
parameters dwkt1n_lvt=0
parameters dpkt1n_lvt=0
parameters dpagsn_lvt=0
parameters dluan_lvt=0
parameters dpuan_lvt=0
parameters dlubn_lvt=-2.5e-26
parameters dpubn_lvt=0
parameters dwagsn_lvt=-2e-8
parameters toxp_lvt=2.26e-09
parameters dxwp_lvt=-8e-09
parameters dxlp_lvt=4e-09
parameters dvthp_lvt=-0.031
parameters dlvthp_lvt=-3e-10
parameters dwvthp_lvt=-2.0e-9
parameters dpvthp_lvt=-19.12e-17
parameters cjp_lvt=1.091e-03
parameters cjswp_lvt=6.848e-11
parameters cjswgp_lvt=2.087e-10
parameters cgop_lvt=3.01477e-11
parameters cglp_lvt=6.85271e-11
parameters ddlcp_lvt=6.38706e-09
parameters cfp_lvt=1.283e-10 + 4.6e-11 * ccoflag_lvt
parameters drdswp_lvt=-5
parameters dnfactorp_lvt=0
parameters dlnfactorp_lvt=0
parameters dwnfactorp_lvt=0
parameters dpnfactorp_lvt=0
parameters du0p_lvt=0
parameters dlu0p_lvt=0
parameters dwu0p_lvt=0
parameters dpu0p_lvt=-3e-18
parameters dvoffp_lvt=0
parameters dlvoffp_lvt=0
parameters dwvoffp_lvt=0
parameters dpvoffp_lvt=0
parameters deta0p_lvt=0
parameters dleta0p_lvt=-11e-10
parameters dweta0p_lvt=0
parameters dpeta0p_lvt=-1e-17
parameters dvsatp_lvt=0
parameters dlvsatp_lvt=0.0002
parameters dwvsatp_lvt=0
parameters dpvsatp_lvt=0
parameters ntoxp_lvt=0.23
parameters dk2p_lvt=0
parameters dlk2p_lvt=5e-10
parameters dwk2p_lvt=0e-9
parameters dpk2p_lvt=0e-17
parameters dagsp_lvt=0
parameters dlagsp_lvt=11e-8
parameters dwagsp_lvt=-2e-8
parameters dpagsp_lvt=5.2e-14
parameters da0p_lvt=0
parameters dla0p_lvt=1e-8
parameters dwa0p_lvt=0e-9
parameters dpa0p_lvt=-1e-14
parameters dpclmp_lvt=0
parameters dlpclmp_lvt=9e-10
parameters dwpclmp_lvt=0
parameters dppclmp_lvt=-2.5e-16
parameters duc1p_lvt=0
parameters ducp_lvt=0
parameters dketap_lvt=0
parameters dlketap_lvt=0
parameters dwketap_lvt=0
parameters dpketap_lvt=0
parameters dlcitp_lvt=0e-11
parameters dwcitp_lvt=0
parameters dpcitp_lvt=0
parameters dlatp_lvt=0
parameters dwatp_lvt=0
parameters dpatp_lvt=0
parameters dlkt1p_lvt=0
parameters dwkt1p_lvt=0
parameters dpkt1p_lvt=0
parameters dluap_lvt=0
parameters dpuap_lvt=0
parameters dlubp_lvt=0
parameters dpubp_lvt=0
parameters b1fn_lvt=-1.363E+41  
parameters b2fn_lvt=0   
parameters b3fn_lvt=-3.721E+7  
parameters a1fn_lvt=1.598E+42  
parameters a2fn_lvt=0   
parameters a3fn_lvt=2.5E+8   
parameters c1fn_lvt=3.050E+41   
parameters c2fn_lvt=5E+12   
parameters c3fn_lvt=7.5E+7  
parameters b1fp_lvt=-4.5E+41   
parameters b2fp_lvt=1.485E+15    
parameters b3fp_lvt=-9.5E+9
parameters a1fp_lvt=1.69E+43   
parameters a2fp_lvt=1.485E+15    
parameters a3fp_lvt=3.5E+10    
parameters c1fp_lvt=1.2E+42  
parameters c2fp_lvt=3E+13    
parameters c3fp_lvt=2E+10 
parameters noian_lvt=a1fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b1fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c1fn_lvt
parameters noibn_lvt=a2fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b2fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c2fn_lvt
parameters noicn_lvt=a3fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b3fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c3fn_lvt
parameters noiap_lvt=a1fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b1fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c1fp_lvt
parameters noibp_lvt=a2fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b2fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c2fp_lvt
parameters noicp_lvt=a3fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b3fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c3fp_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_lvt
endsection ss_lvt
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_lvt
parameters parn1_lvt=0
parameters parn2_lvt=0
parameters parp1_lvt=0
parameters parp2_lvt=0
parameters ss_flag_lvt=0
parameters ff_flag_lvt=1
parameters sf_flag_lvt=0
parameters fs_flag_lvt=0
parameters toxn_lvt=1.94e-09
parameters dxwn_lvt=8e-09
parameters dxln_lvt=-4e-09
parameters dvthn_lvt=-0.028
parameters dlvthn_lvt=-5.2e-10
parameters dwvthn_lvt=-2.3e-9
parameters dpvthn_lvt=-1.6e-16
parameters cjn_lvt=1.123e-03
parameters cjswn_lvt=5.952e-11
parameters cjswgn_lvt=2.762e-10
parameters cgon_lvt=6.77471e-11
parameters cgln_lvt=1.02583e-12
parameters ddlcn_lvt=3.30397e-09
parameters cfn_lvt=1.487e-10 + 4.1e-11 * ccoflag_lvt
parameters drdswn_lvt=0
parameters dnfactorn_lvt=0
parameters dlnfactorn_lvt=0
parameters dwnfactorn_lvt=0
parameters dpnfactorn_lvt=0
parameters du0n_lvt=0
parameters dlu0n_lvt=2e-10
parameters dwu0n_lvt=0
parameters dpu0n_lvt=0
parameters deta0n_lvt=0
parameters dleta0n_lvt=6e-10
parameters dweta0n_lvt=0
parameters dpeta0n_lvt=19.42e-17
parameters dvsatn_lvt=0
parameters dlvsatn_lvt=0
parameters dwvsatn_lvt=0
parameters dpvsatn_lvt=-3e-11
parameters ntoxn_lvt=1.41
parameters dk2n_lvt=-0.0178
parameters dlk2n_lvt=2e-10
parameters dwk2n_lvt=-1.9e-09
parameters dpk2n_lvt=-1.1e-16
parameters dagsn_lvt=-0.25
parameters dpclmn_lvt=0
parameters dppclmn_lvt=0
parameters dlcitn_lvt=0.5e-10
parameters dwcitn_lvt=0
parameters dpcitn_lvt=-8.2e-18
parameters dlagsn_lvt=-0e-08
parameters datn_lvt=0
parameters dla0n_lvt=3e-7
parameters dwa0n_lvt=-2.3e-7
parameters dpa0n_lvt=2.0e-14
parameters dlatn_lvt=-2e-4
parameters dwatn_lvt=0
parameters dpatn_lvt=0
parameters dlkt1n_lvt=0
parameters dwkt1n_lvt=0
parameters dpkt1n_lvt=0
parameters dpagsn_lvt=-6e-14
parameters dwagsn_lvt=1e-7
parameters dluan_lvt=0e-17
parameters dpuan_lvt=0
parameters dlubn_lvt=2.5e-26
parameters dpubn_lvt=0
parameters toxp_lvt=2.14e-09
parameters dxwp_lvt=8e-09
parameters dxlp_lvt=-4e-09
parameters dvthp_lvt=0.033
parameters dlvthp_lvt=-0.98e-10
parameters dwvthp_lvt=2.8e-9
parameters dpvthp_lvt=19.12e-17
parameters cjp_lvt=9.486e-04
parameters cjswp_lvt=5.952e-11
parameters cjswgp_lvt=1.814e-10
parameters cgop_lvt=3.46861e-11
parameters cglp_lvt=7.88430e-11
parameters ddlcp_lvt=6.38706e-09
parameters cfp_lvt=1.477e-10 + 4.6e-11 * ccoflag_lvt
parameters drdswp_lvt=0
parameters dnfactorp_lvt=0
parameters dlnfactorp_lvt=0
parameters dwnfactorp_lvt=0
parameters dpnfactorp_lvt=0
parameters du0p_lvt=0
parameters dlu0p_lvt=20e-12
parameters dwu0p_lvt=0
parameters dpu0p_lvt=3e-18
parameters dvoffp_lvt=0
parameters dlvoffp_lvt=0
parameters dwvoffp_lvt=0
parameters dpvoffp_lvt=0
parameters deta0p_lvt=0
parameters dleta0p_lvt=5.5e-10
parameters dweta0p_lvt=0
parameters dpeta0p_lvt=-1.5e-17
parameters dvsatp_lvt=0
parameters dlvsatp_lvt=-0.0002
parameters dwvsatp_lvt=0
parameters dpvsatp_lvt=-3e-11
parameters ntoxp_lvt=1.64
parameters dk2p_lvt=0
parameters dlk2p_lvt=-4e-10
parameters dwk2p_lvt=0
parameters dpk2p_lvt=0e-17
parameters dagsp_lvt=0
parameters dlagsp_lvt=-5e-8
parameters dwagsp_lvt=-5e-8
parameters dpagsp_lvt=3e-14
parameters da0p_lvt=0
parameters dla0p_lvt=7e-8
parameters dwa0p_lvt=0
parameters dpa0p_lvt=0.1e-14
parameters dpclmp_lvt=0
parameters dlpclmp_lvt=0
parameters dwpclmp_lvt=0
parameters dppclmp_lvt=1e-16
parameters duc1p_lvt=0
parameters ducp_lvt=0
parameters dketap_lvt=0
parameters dlketap_lvt=0
parameters dwketap_lvt=0
parameters dpketap_lvt=0
parameters dlcitp_lvt=-0.1e-10
parameters dwcitp_lvt=0
parameters dpcitp_lvt=0
parameters dlatp_lvt=0
parameters dwatp_lvt=0
parameters dpatp_lvt=0
parameters dlkt1p_lvt=1e-9
parameters dwkt1p_lvt=0
parameters dpkt1p_lvt=0
parameters dluap_lvt=0
parameters dpuap_lvt=0
parameters dlubp_lvt=1.5e-26
parameters dpubp_lvt=0
parameters b1fn_lvt=-1.363E+41  
parameters b2fn_lvt=0   
parameters b3fn_lvt=-3.721E+7  
parameters a1fn_lvt=1.598E+42  
parameters a2fn_lvt=0   
parameters a3fn_lvt=2.5E+8   
parameters c1fn_lvt=3.050E+41   
parameters c2fn_lvt=5E+12   
parameters c3fn_lvt=7.5E+7  
parameters b1fp_lvt=-4.5E+41   
parameters b2fp_lvt=1.485E+15    
parameters b3fp_lvt=-9.5E+9
parameters a1fp_lvt=1.69E+43   
parameters a2fp_lvt=1.485E+15    
parameters a3fp_lvt=3.5E+10    
parameters c1fp_lvt=1.2E+42  
parameters c2fp_lvt=3E+13    
parameters c3fp_lvt=2E+10 
parameters noian_lvt=a1fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b1fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c1fn_lvt
parameters noibn_lvt=a2fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b2fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c2fn_lvt
parameters noicn_lvt=a3fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b3fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c3fn_lvt
parameters noiap_lvt=a1fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b1fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c1fp_lvt
parameters noibp_lvt=a2fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b2fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c2fp_lvt
parameters noicp_lvt=a3fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b3fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c3fp_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_lvt
endsection ff_lvt
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_lvt
parameters parn1_lvt=0
parameters parn2_lvt=0
parameters parp1_lvt=0
parameters parp2_lvt=0
parameters a1n_lvt=0.8
parameters a1p_lvt=-0.8
parameters a2n_lvt=0
parameters a2p_lvt=0
parameters a3n_lvt=-1
parameters a3p_lvt=1
parameters a4np_lvt=0
parameters ss_flag_lvt=0
parameters ff_flag_lvt=0
parameters sf_flag_lvt=1
parameters fs_flag_lvt=0
parameters toxn_lvt=2e-09 + 6.0000e-11 * a4np_lvt
parameters dxwn_lvt=8e-09 * a3n_lvt
parameters dxln_lvt=4e-09 * a2n_lvt
parameters dvthn_lvt=0.028 * a1n_lvt
parameters dlvthn_lvt=5.2e-10 * a1n_lvt
parameters dwvthn_lvt=2.3e-09 * a1n_lvt
parameters dpvthn_lvt=1.6e-16 * a1n_lvt
parameters cjn_lvt=1.207e-03 * (1 + 0.070 * a1n_lvt)
parameters cjswn_lvt=6.400e-11 * (1 + 0.070 * a1n_lvt)
parameters cjswgn_lvt=2.970e-10 * (1 + 0.070 * a1n_lvt)
parameters cgon_lvt=6.33150e-11 * (1 - 0.070 * a4np_lvt)
parameters cgln_lvt=9.58723e-13 * (1 - 0.070 * a4np_lvt)
parameters ddlcn_lvt=3.30397e-09 + 0.0000e+00 * a1n_lvt
parameters cfn_lvt=1.39e-10 * (1 - 0.070 * a4np_lvt) + 4.1e-11 * ccoflag_lvt
parameters drdswn_lvt=0
parameters dnfactorn_lvt=0
parameters dlnfactorn_lvt=0
parameters dwnfactorn_lvt=0
parameters dpnfactorn_lvt=0
parameters du0n_lvt=0
parameters dlu0n_lvt= - 2e-10 * a1n_lvt
parameters dwu0n_lvt=0
parameters dpu0n_lvt=0
parameters deta0n_lvt=0
parameters dleta0n_lvt= - 8e-10 * a1n_lvt
parameters dweta0n_lvt=0
parameters dpeta0n_lvt= - 2.042e-16 * a1n_lvt
parameters dvsatn_lvt=0
parameters dlvsatn_lvt=0
parameters dwvsatn_lvt=0
parameters dpvsatn_lvt=3e-11 * a1n_lvt
parameters ntoxn_lvt=1 +  - 4.1000e-01 * a4np_lvt
parameters dk2n_lvt=0.0178 * a1n_lvt
parameters dlk2n_lvt= - 2e-10 * a1n_lvt
parameters dwk2n_lvt=1.9e-09 * a1n_lvt
parameters dpk2n_lvt=1.1e-16 * a1n_lvt
parameters dagsn_lvt=0.25 * a1n_lvt
parameters dpclmn_lvt=0
parameters dppclmn_lvt=0
parameters dlcitn_lvt= - 5e-11 * a1n_lvt
parameters dwcitn_lvt=0
parameters dpcitn_lvt=8.2e-18 * a1n_lvt
parameters dlagsn_lvt=2.24e-08 * a1n_lvt
parameters datn_lvt=0
parameters dla0n_lvt= - 5e-08 * a1n_lvt
parameters dwa0n_lvt=2.3e-07 * a1n_lvt
parameters dpa0n_lvt= - 2e-14 * a1n_lvt
parameters dlatn_lvt=0.0002 * a1n_lvt
parameters dwatn_lvt=0
parameters dpatn_lvt=0
parameters dlkt1n_lvt=0
parameters dwkt1n_lvt=0
parameters dpkt1n_lvt=0
parameters dpagsn_lvt=6e-14 * a1n_lvt
parameters dwagsn_lvt= - 0.9e-07 * a1n_lvt
parameters dluan_lvt=0 * a1n_lvt
parameters dpuan_lvt=0
parameters dlubn_lvt= - 2.5e-26 * a1n_lvt
parameters dpubn_lvt=0
parameters toxp_lvt=2.2e-09 + 6.0000e-11 * a4np_lvt
parameters dxwp_lvt=8e-09 * a3p_lvt
parameters dxlp_lvt=4e-09 * a2p_lvt
parameters dvthp_lvt= - 0.033 * a1p_lvt
parameters dlvthp_lvt=0.98e-10 * a1p_lvt
parameters dwvthp_lvt= - 2.8e-09 * a1p_lvt
parameters dpvthp_lvt= - 1.912e-16 * a1p_lvt
parameters cjp_lvt=1.020e-03 * (1 + 0.070 * a1p_lvt)
parameters cjswp_lvt=6.400e-11 * (1 + 0.070 * a1p_lvt)
parameters cjswgp_lvt=1.950e-10 * (1 + 0.070 * a1p_lvt)
parameters cgop_lvt=3.24169e-11 * (1 - 0.070 * a4np_lvt)
parameters cglp_lvt=7.36850e-11 * (1 - 0.070 * a4np_lvt)
parameters ddlcp_lvt=6.38706e-09 + 0.0000e+00 * a1p_lvt
parameters cfp_lvt=1.38e-10 * (1 - 0.070 * a4np_lvt) + 4.6e-11 * ccoflag_lvt
parameters drdswp_lvt=0 * a1p_lvt
parameters dnfactorp_lvt=0
parameters dlnfactorp_lvt=0
parameters dwnfactorp_lvt=0
parameters dpnfactorp_lvt=0
parameters du0p_lvt=0
parameters dlu0p_lvt= - 2e-11 * a1p_lvt
parameters dwu0p_lvt=0
parameters dpu0p_lvt= - 3e-18 * a1p_lvt
parameters dvoffp_lvt=0
parameters dlvoffp_lvt=0
parameters dwvoffp_lvt=0
parameters dpvoffp_lvt=0
parameters deta0p_lvt=0
parameters dleta0p_lvt= - 0.55e-09 * a1p_lvt
parameters dweta0p_lvt=0
parameters dpeta0p_lvt=1.5e-17 * a1p_lvt
parameters dvsatp_lvt=0
parameters dlvsatp_lvt=0.00015 * a1p_lvt
parameters dwvsatp_lvt=0
parameters dpvsatp_lvt=4.2e-11 * a1p_lvt
parameters ntoxp_lvt=1 +  - 6.4000e-01 * a4np_lvt
parameters dk2p_lvt=0
parameters dlk2p_lvt=4e-10 * a1p_lvt
parameters dwk2p_lvt=0
parameters dpk2p_lvt=0 * a1p_lvt
parameters dagsp_lvt=0
parameters dlagsp_lvt=5e-08 * a1p_lvt
parameters dwagsp_lvt=5e-08 * a1p_lvt
parameters dpagsp_lvt=0 * a1p_lvt
parameters da0p_lvt=0
parameters dla0p_lvt=7e-08 * a1p_lvt
parameters dwa0p_lvt=0
parameters dpa0p_lvt= - 2e-14 * a1p_lvt
parameters dpclmp_lvt=0
parameters dlpclmp_lvt=0
parameters dwpclmp_lvt=0
parameters dppclmp_lvt= - 6e-16 * a1p_lvt
parameters duc1p_lvt=0
parameters ducp_lvt=0
parameters dketap_lvt=0
parameters dlketap_lvt=0
parameters dwketap_lvt=0
parameters dpketap_lvt=0
parameters dlcitp_lvt=1e-11 * a1p_lvt
parameters dwcitp_lvt=0
parameters dpcitp_lvt=0
parameters dlatp_lvt=0
parameters dwatp_lvt=0
parameters dpatp_lvt=0
parameters dlkt1p_lvt= - 1e-09 * a1p_lvt
parameters dwkt1p_lvt=0
parameters dpkt1p_lvt=0
parameters dluap_lvt=0
parameters dpuap_lvt=0
parameters dlubp_lvt= - 1.5e-26 * a1p_lvt
parameters dpubp_lvt=0
parameters b1fn_lvt=-1.363E+41  
parameters b2fn_lvt=0   
parameters b3fn_lvt=-3.721E+7  
parameters a1fn_lvt=1.598E+42  
parameters a2fn_lvt=0   
parameters a3fn_lvt=2.5E+8   
parameters c1fn_lvt=3.050E+41   
parameters c2fn_lvt=5E+12   
parameters c3fn_lvt=7.5E+7  
parameters b1fp_lvt=-4.5E+41   
parameters b2fp_lvt=1.485E+15    
parameters b3fp_lvt=-9.5E+9
parameters a1fp_lvt=1.69E+43   
parameters a2fp_lvt=1.485E+15    
parameters a3fp_lvt=3.5E+10    
parameters c1fp_lvt=1.2E+42  
parameters c2fp_lvt=3E+13    
parameters c3fp_lvt=2E+10 
parameters noian_lvt=a1fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b1fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c1fn_lvt
parameters noibn_lvt=a2fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b2fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c2fn_lvt
parameters noicn_lvt=a3fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b3fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c3fn_lvt
parameters noiap_lvt=a1fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b1fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c1fp_lvt
parameters noibp_lvt=a2fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b2fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c2fp_lvt
parameters noicp_lvt=a3fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b3fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c3fp_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_lvt
endsection sf_lvt
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_lvt
parameters parn1_lvt=0
parameters parn2_lvt=0
parameters parp1_lvt=0
parameters parp2_lvt=0
parameters a1n_lvt=-0.8
parameters a1p_lvt=0.8
parameters a2n_lvt=0
parameters a2p_lvt=0
parameters a3n_lvt=1
parameters a3p_lvt=-1
parameters a4np_lvt=0
parameters ss_flag_lvt=0
parameters ff_flag_lvt=0
parameters sf_flag_lvt=0
parameters fs_flag_lvt=1
parameters toxn_lvt=2e-09 + 6.0000e-11 * a4np_lvt
parameters dxwn_lvt=8e-09 * a3n_lvt
parameters dxln_lvt=4e-09 * a2n_lvt
parameters dvthn_lvt=0.028 * a1n_lvt
parameters dlvthn_lvt=5.2e-10 * a1n_lvt
parameters dwvthn_lvt=2.3e-09 * a1n_lvt
parameters dpvthn_lvt=1.6e-16 * a1n_lvt
parameters cjn_lvt=1.207e-03 * (1 + 0.070 * a1n_lvt)
parameters cjswn_lvt=6.400e-11 * (1 + 0.070 * a1n_lvt)
parameters cjswgn_lvt=2.970e-10 * (1 + 0.070 * a1n_lvt)
parameters cgon_lvt=6.33150e-11 * (1 - 0.070 * a4np_lvt)
parameters cgln_lvt=9.58723e-13 * (1 - 0.070 * a4np_lvt)
parameters ddlcn_lvt=3.30397e-09 + 0.0000e+00 * a1n_lvt
parameters cfn_lvt=1.39e-10 * (1 - 0.070 * a4np_lvt) + 4.1e-11 * ccoflag_lvt
parameters drdswn_lvt=0
parameters dnfactorn_lvt=0
parameters dlnfactorn_lvt=0
parameters dwnfactorn_lvt=0
parameters dpnfactorn_lvt=0
parameters du0n_lvt=0
parameters dlu0n_lvt= - 2e-10 * a1n_lvt
parameters dwu0n_lvt=0
parameters dpu0n_lvt=0
parameters deta0n_lvt=0
parameters dleta0n_lvt= - 8e-10 * a1n_lvt
parameters dweta0n_lvt=0
parameters dpeta0n_lvt= - 2.042e-16 * a1n_lvt
parameters dvsatn_lvt=0
parameters dlvsatn_lvt=0
parameters dwvsatn_lvt=0
parameters dpvsatn_lvt=3e-11 * a1n_lvt
parameters ntoxn_lvt=1 +  - 4.1000e-01 * a4np_lvt
parameters dk2n_lvt=0.0178 * a1n_lvt
parameters dlk2n_lvt= - 2e-10 * a1n_lvt
parameters dwk2n_lvt=1.9e-09 * a1n_lvt
parameters dpk2n_lvt=1.1e-16 * a1n_lvt
parameters dagsn_lvt=0.25 * a1n_lvt
parameters dpclmn_lvt=0
parameters dppclmn_lvt=0
parameters dlcitn_lvt= - 5e-11 * a1n_lvt
parameters dwcitn_lvt=0
parameters dpcitn_lvt=8.2e-18 * a1n_lvt
parameters dlagsn_lvt=2.24e-08 * a1n_lvt
parameters datn_lvt=0
parameters dla0n_lvt= - 5e-08 * a1n_lvt
parameters dwa0n_lvt=2.3e-07 * a1n_lvt
parameters dpa0n_lvt= - 2e-14 * a1n_lvt
parameters dlatn_lvt=0.0002 * a1n_lvt
parameters dwatn_lvt=0
parameters dpatn_lvt=0
parameters dlkt1n_lvt=0
parameters dwkt1n_lvt=0
parameters dpkt1n_lvt=0
parameters dpagsn_lvt=6e-14 * a1n_lvt
parameters dwagsn_lvt= - 1e-07 * a1n_lvt
parameters dluan_lvt=0 * a1n_lvt
parameters dpuan_lvt=0
parameters dlubn_lvt= - 2.5e-26 * a1n_lvt
parameters dpubn_lvt=0
parameters toxp_lvt=2.2e-09 + 6.0000e-11 * a4np_lvt
parameters dxwp_lvt=8e-09 * a3p_lvt
parameters dxlp_lvt=4e-09 * a2p_lvt
parameters dvthp_lvt= - 0.033 * a1p_lvt
parameters dlvthp_lvt=0.98e-10 * a1p_lvt
parameters dwvthp_lvt= - 2.8e-09 * a1p_lvt
parameters dpvthp_lvt= - 1.912e-16 * a1p_lvt
parameters cjp_lvt=1.020e-03 * (1 + 0.070 * a1p_lvt)
parameters cjswp_lvt=6.400e-11 * (1 + 0.070 * a1p_lvt)
parameters cjswgp_lvt=1.950e-10 * (1 + 0.070 * a1p_lvt)
parameters cgop_lvt=3.24169e-11 * (1 - 0.070 * a4np_lvt)
parameters cglp_lvt=7.36850e-11 * (1 - 0.070 * a4np_lvt)
parameters ddlcp_lvt=6.38706e-09 + 0.0000e+00 * a1p_lvt
parameters cfp_lvt=1.38e-10 * (1 - 0.070 * a4np_lvt) + 4.6e-11 * ccoflag_lvt
parameters drdswp_lvt=0 * a1p_lvt
parameters dnfactorp_lvt=0
parameters dlnfactorp_lvt=0
parameters dwnfactorp_lvt=0
parameters dpnfactorp_lvt=0
parameters du0p_lvt=0
parameters dlu0p_lvt= - 2e-11 * a1p_lvt
parameters dwu0p_lvt=0
parameters dpu0p_lvt= - 3e-18 * a1p_lvt
parameters dvoffp_lvt=0
parameters dlvoffp_lvt=0
parameters dwvoffp_lvt=0
parameters dpvoffp_lvt=0
parameters deta0p_lvt=0
parameters dleta0p_lvt= - 0.55e-09 * a1p_lvt
parameters dweta0p_lvt=0
parameters dpeta0p_lvt=1.5e-17 * a1p_lvt
parameters dvsatp_lvt=0
parameters dlvsatp_lvt=0.00015 * a1p_lvt
parameters dwvsatp_lvt=0
parameters dpvsatp_lvt=4.2e-11 * a1p_lvt
parameters ntoxp_lvt=1 +  - 6.4000e-01 * a4np_lvt
parameters dk2p_lvt=0
parameters dlk2p_lvt=4e-10 * a1p_lvt
parameters dwk2p_lvt=0
parameters dpk2p_lvt=0 * a1p_lvt
parameters dagsp_lvt=0
parameters dlagsp_lvt=5e-08 * a1p_lvt
parameters dwagsp_lvt=5e-08 * a1p_lvt
parameters dpagsp_lvt=0 * a1p_lvt
parameters da0p_lvt=0
parameters dla0p_lvt=7e-08 * a1p_lvt
parameters dwa0p_lvt=0
parameters dpa0p_lvt= - 2e-14 * a1p_lvt
parameters dpclmp_lvt=0
parameters dlpclmp_lvt=0
parameters dwpclmp_lvt=0
parameters dppclmp_lvt= - 6e-16 * a1p_lvt
parameters duc1p_lvt=0
parameters ducp_lvt=0
parameters dketap_lvt=0
parameters dlketap_lvt=0
parameters dwketap_lvt=0
parameters dpketap_lvt=0
parameters dlcitp_lvt=1e-11 * a1p_lvt
parameters dwcitp_lvt=0
parameters dpcitp_lvt=0
parameters dlatp_lvt=0
parameters dwatp_lvt=0
parameters dpatp_lvt=0
parameters dlkt1p_lvt= - 1e-09 * a1p_lvt
parameters dwkt1p_lvt=0
parameters dpkt1p_lvt=0
parameters dluap_lvt=0
parameters dpuap_lvt=0
parameters dlubp_lvt= - 1.5e-26 * a1p_lvt
parameters dpubp_lvt=0
parameters b1fn_lvt=-1.363E+41  
parameters b2fn_lvt=0   
parameters b3fn_lvt=-3.721E+7  
parameters a1fn_lvt=1.598E+42  
parameters a2fn_lvt=0   
parameters a3fn_lvt=2.5E+8   
parameters c1fn_lvt=3.050E+41   
parameters c2fn_lvt=5E+12   
parameters c3fn_lvt=7.5E+7  
parameters b1fp_lvt=-4.5E+41   
parameters b2fp_lvt=1.485E+15    
parameters b3fp_lvt=-9.5E+9
parameters a1fp_lvt=1.69E+43   
parameters a2fp_lvt=1.485E+15    
parameters a3fp_lvt=3.5E+10    
parameters c1fp_lvt=1.2E+42  
parameters c2fp_lvt=3E+13    
parameters c3fp_lvt=2E+10   
parameters noian_lvt=a1fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b1fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c1fn_lvt
parameters noibn_lvt=a2fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b2fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c2fn_lvt
parameters noicn_lvt=a3fn_lvt * (abs(noiseflagn_lvt) + noiseflagn_lvt) + b3fn_lvt 
+ * (abs(noiseflagn_lvt) - noiseflagn_lvt) + c3fn_lvt
parameters noiap_lvt=a1fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b1fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c1fp_lvt
parameters noibp_lvt=a2fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b2fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c2fp_lvt
parameters noicp_lvt=a3fp_lvt * (abs(noiseflagp_lvt) + noiseflagp_lvt) + b3fp_lvt 
+ * (abs(noiseflagp_lvt) - noiseflagp_lvt) + c3fp_lvt
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_lvt
endsection fs_lvt
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_18
parameters parn1_18=0
parameters parn2_18=0
parameters parp1_18=0
parameters parp2_18=0
parameters toxn_18=5.6e-09
parameters dxln_18=0
parameters dxwn_18=0
parameters cjn_18=0.001051
parameters cjswn_18=1.355e-10
parameters cjswgn_18=1.621e-10
parameters dlcn_18=4.654e-08
parameters cgon_18=3.855e-11
parameters cgln_18=2.513e-10
parameters dvthn_18=0
parameters dlvthn_18=0
parameters dwvthn_18=0
parameters dpvthn_18=0
parameters du0n_18=0
parameters dlu0n_18=0
parameters dwu0n_18=0
parameters dpu0n_18=0
parameters dcitn_18=0
parameters dlcitn_18=0
parameters dwcitn_18=0
parameters dpcitn_18=0
parameters deta0n_18=0
parameters dleta0n_18=0
parameters dweta0n_18=0
parameters dpeta0n_18=0
parameters dk2n_18=0
parameters dlk2n_18=0
parameters dwk2n_18=0
parameters dpk2n_18=0
parameters cfn_18=9e-11 + 2.4e-11 * ccoflag_18
parameters dk2_18=0
parameters dxlp_18=0
parameters dxwp_18=0
parameters toxp_18=5.9e-09
parameters cjp_18=0.00112
parameters cjswp_18=9e-11
parameters cjswgp_18=1.7e-10
parameters dlcp_18=5.49049e-08
parameters cgop_18=5.23324e-11
parameters cglp_18=2.68907e-10
parameters dvthp_18=0
parameters dlvthp_18=0
parameters dwvthp_18=0
parameters dpvthp_18=0
parameters du0p_18=0
parameters dlu0p_18=0
parameters dwu0p_18=0
parameters dpu0p_18=0
parameters dnfactorp_18=0
parameters dlnfactorp_18=0
parameters dwnfactorp_18=0
parameters dpnfactorp_18=0
parameters dcitp_18=0
parameters dlcitp_18=0
parameters dwcitp_18=0
parameters dpcitp_18=0
parameters dvsatp_18=0
parameters dlvsatp_18=0
parameters dwvsatp_18=0
parameters dpvsatp_18=0
parameters dleta0p_18=0
parameters dpeta0p_18=0
parameters dla0p_18=0
parameters dwa0p_18=0
parameters dpa0p_18=0
parameters cfp_18=9e-11 + 2.4e-11 * ccoflag_18
parameters dlkt1p_18=0
parameters b1fn_18=-7.25E+40
parameters b2fn_18=4.75E+22 
parameters b3fn_18=-1.925E+8   
parameters a1fn_18=8.975E+41 
parameters a2fn_18=4.75E+22  
parameters a3fn_18=4.825e+8  
parameters c1fn_18=2.05E+41  
parameters c2fn_18=4E+10    
parameters c3fn_18=5.35e+8 
parameters b1fp_18=-3.55E+41   
parameters b2fp_18=0    
parameters b3fp_18=-2.225E+9    
parameters a1fp_18=1.573E+42    
parameters a2fp_18=0  
parameters a3fp_18=4.825E+9 
parameters c1fp_18=8.05E+41     
parameters c2fp_18=4E+10  
parameters c3fp_18=5.35E+9  
parameters noian_18=a1fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b1fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c1fn_18
parameters noibn_18=a2fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b2fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c2fn_18
parameters noicn_18=a3fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b3fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c3fn_18
parameters noiap_18=a1fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b1fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c1fp_18
parameters noibp_18=a2fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b2fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c2fp_18
parameters noicp_18=a3fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b3fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c3fp_18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_18
endsection tt_18
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_18
parameters parn1_18=0
parameters parn2_18=0
parameters parp1_18=0
parameters parp2_18=0
parameters toxn_18=5.9e-09
parameters dxln_18=1e-08
parameters dxwn_18=-1.2e-08
parameters cjn_18=0.001125
parameters cjswn_18=1.45e-10
parameters cjswgn_18=1.734e-10
parameters dlcn_18=4.654e-08
parameters cgon_18=3.585e-11
parameters cgln_18=2.337e-10
parameters dvthn_18=0.038
parameters dlvthn_18=-2.5e-09
parameters dwvthn_18=5e-10
parameters dpvthn_18=3e-15
parameters du0n_18=0
parameters dlu0n_18=-3e-10
parameters dwu0n_18=-1.5e-10
parameters dpu0n_18=0
parameters dcitn_18=0.0001
parameters dlcitn_18=0
parameters dwcitn_18=-1e-10
parameters dpcitn_18=0
parameters deta0n_18=0
parameters dleta0n_18=0
parameters dweta0n_18=0
parameters dpeta0n_18=0
parameters dk2n_18=0
parameters dlk2n_18=0
parameters dwk2n_18=0
parameters dpk2n_18=0
parameters cfn_18=8.37e-11 + 2.4e-11 * ccoflag_18
parameters dk2_18=0
parameters dxlp_18=1e-08
parameters dxwp_18=-1.2e-08
parameters toxp_18=6.2e-09
parameters cjp_18=0.001198
parameters cjswp_18=9.63e-11
parameters cjswgp_18=1.819e-10
parameters dlcp_18=5.49049e-08
parameters cgop_18=4.8668e-11
parameters cglp_18=2.50083e-10
parameters dvthp_18=-0.015
parameters dlvthp_18=-6e-10
parameters dwvthp_18=-2.9e-09
parameters dpvthp_18=-2.2e-15
parameters du0p_18=0
parameters dlu0p_18=0
parameters dwu0p_18=1e-10
parameters dpu0p_18=0
parameters dnfactorp_18=0
parameters dlnfactorp_18=0
parameters dwnfactorp_18=0
parameters dpnfactorp_18=0
parameters dcitp_18=0
parameters dlcitp_18=0
parameters dwcitp_18=0
parameters dpcitp_18=0
parameters dvsatp_18=0
parameters dlvsatp_18=0
parameters dwvsatp_18=0
parameters dpvsatp_18=-1.1e-09
parameters dleta0p_18=-3e-08
parameters dpeta0p_18=0
parameters dla0p_18=0
parameters dwa0p_18=0
parameters dpa0p_18=1.5e-13
parameters cfp_18=8.37e-11 + 2.4e-11 * ccoflag_18
parameters dlkt1p_18=0
parameters b1fn_18=-7.25E+40
parameters b2fn_18=4.75E+22 
parameters b3fn_18=-1.925E+8   
parameters a1fn_18=8.975E+41 
parameters a2fn_18=4.75E+22  
parameters a3fn_18=4.825e+8  
parameters c1fn_18=2.05E+41  
parameters c2fn_18=4E+10    
parameters c3fn_18=5.35e+8 
parameters b1fp_18=-3.55E+41   
parameters b2fp_18=0    
parameters b3fp_18=-2.225E+9    
parameters a1fp_18=1.573E+42    
parameters a2fp_18=0  
parameters a3fp_18=4.825E+9 
parameters c1fp_18=8.05E+41     
parameters c2fp_18=4E+10  
parameters c3fp_18=5.35E+9  
parameters noian_18=a1fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b1fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c1fn_18
parameters noibn_18=a2fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b2fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c2fn_18
parameters noicn_18=a3fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b3fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c3fn_18
parameters noiap_18=a1fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b1fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c1fp_18
parameters noibp_18=a2fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b2fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c2fp_18
parameters noicp_18=a3fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b3fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c3fp_18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_18
endsection ss_18
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_18
parameters parn1_18=0
parameters parn2_18=0
parameters parp1_18=0
parameters parp2_18=0
parameters toxn_18=5.3e-09
parameters dxln_18=-1e-08
parameters dxwn_18=1.2e-08
parameters cjn_18=0.0009774
parameters cjswn_18=1.26e-10
parameters cjswgn_18=1.508e-10
parameters dlcn_18=4.654e-08
parameters cgon_18=4.125e-11
parameters cgln_18=2.689e-10
parameters dvthn_18=-0.038
parameters dlvthn_18=2.5e-09
parameters dwvthn_18=-5e-10
parameters dpvthn_18=-3.2e-15
parameters du0n_18=0
parameters dlu0n_18=3e-10
parameters dwu0n_18=1e-10
parameters dpu0n_18=-1e-16
parameters dcitn_18=-0.0001
parameters dlcitn_18=0
parameters dwcitn_18=1e-10
parameters dpcitn_18=0
parameters deta0n_18=-0.05
parameters dleta0n_18=0
parameters dweta0n_18=0
parameters dpeta0n_18=0
parameters dk2n_18=0
parameters dlk2n_18=0
parameters dwk2n_18=0
parameters dpk2n_18=0
parameters cfn_18=9.63e-11 + 2.4e-11 * ccoflag_18
parameters dk2_18=0
parameters dxlp_18=-1e-08
parameters dxwp_18=1.2e-08
parameters toxp_18=5.6e-09
parameters cjp_18=0.001042
parameters cjswp_18=8.37e-11
parameters cjswgp_18=1.581e-10
parameters dlcp_18=5.49049e-08
parameters cgop_18=5.5995e-11
parameters cglp_18=2.87729e-10
parameters dvthp_18=0.01
parameters dlvthp_18=2e-10
parameters dwvthp_18=7.9e-09
parameters dpvthp_18=1.5e-15
parameters du0p_18=0
parameters dlu0p_18=1e-11
parameters dwu0p_18=-1e-10
parameters dpu0p_18=0
parameters dnfactorp_18=0
parameters dlnfactorp_18=0
parameters dwnfactorp_18=0
parameters dpnfactorp_18=0
parameters dcitp_18=0
parameters dlcitp_18=-2e-11
parameters dwcitp_18=0
parameters dpcitp_18=0
parameters dvsatp_18=0
parameters dlvsatp_18=0
parameters dwvsatp_18=0
parameters dpvsatp_18=1.1e-09
parameters dleta0p_18=2e-08
parameters dpeta0p_18=0
parameters dla0p_18=0
parameters dwa0p_18=0
parameters dpa0p_18=-9e-14
parameters cfp_18=9.63e-11 + 2.4e-11 * ccoflag_18
parameters dlkt1p_18=5e-09
parameters b1fn_18=-7.25E+40
parameters b2fn_18=4.75E+22 
parameters b3fn_18=-1.925E+8   
parameters a1fn_18=8.975E+41 
parameters a2fn_18=4.75E+22  
parameters a3fn_18=4.825e+8  
parameters c1fn_18=2.05E+41  
parameters c2fn_18=4E+10    
parameters c3fn_18=5.35e+8 
parameters b1fp_18=-3.55E+41   
parameters b2fp_18=0    
parameters b3fp_18=-2.225E+9    
parameters a1fp_18=1.573E+42    
parameters a2fp_18=0  
parameters a3fp_18=4.825E+9 
parameters c1fp_18=8.05E+41     
parameters c2fp_18=4E+10  
parameters c3fp_18=5.35E+9  
parameters noian_18=a1fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b1fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c1fn_18
parameters noibn_18=a2fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b2fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c2fn_18
parameters noicn_18=a3fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b3fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c3fn_18
parameters noiap_18=a1fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b1fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c1fp_18
parameters noibp_18=a2fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b2fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c2fp_18
parameters noicp_18=a3fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b3fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c3fp_18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_18
endsection ff_18
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_18
parameters parn1_18=0
parameters parn2_18=0
parameters parp1_18=0
parameters parp2_18=0
parameters a1n_18=0.8
parameters a1p_18=-0.8
parameters a2n_18=0
parameters a2p_18=0
parameters a3n_18=-1
parameters a3p_18=1
parameters a4np_18=0
parameters toxn_18=5.6e-09 + 3.0000e-010 * a4np_18
parameters dxln_18=1e-008 * a2n_18
parameters dxwn_18=1.2e-008 * a3n_18
parameters cjn_18=0.001051 * (1 + 0.070 * a1n_18)
parameters cjswn_18=1.355e-10 * (1 + 0.070 * a1n_18)
parameters cjswgn_18=1.621e-10 * (1 + 0.070 * a1n_18)
parameters dlcn_18=4.654e-08
parameters cgon_18=3.855e-11 * (1 - 0.070 * a4np_18)
parameters cgln_18=2.513e-10 * (1 - 0.070 * a4np_18)
parameters dvthn_18=0.038 * a1n_18
parameters dlvthn_18= - 2.5e-009 * a1n_18
parameters dwvthn_18=5e-010 * a1n_18
parameters dpvthn_18=3.2e-015 * a1n_18
parameters du0n_18=0
parameters dlu0n_18= - 3e-010 * a1n_18
parameters dwu0n_18= - 1e-010 * a1n_18
parameters dpu0n_18=1e-016 * a1n_18
parameters dcitn_18=0.0001 * a1n_18
parameters dlcitn_18=0
parameters dwcitn_18= - 1e-010 * a1n_18
parameters dpcitn_18=0
parameters deta0n_18=0.05 * a1n_18
parameters dleta0n_18=0
parameters dweta0n_18=0
parameters dpeta0n_18=0
parameters dk2n_18=0
parameters dlk2n_18=0
parameters dwk2n_18=0
parameters dpk2n_18=0
parameters cfn_18=9e-11 * (1 - 0.070 * a4np_18) + 2.4e-11 * ccoflag_18
parameters dk2_18=0
parameters dxlp_18=1e-008 * a2p_18
parameters dxwp_18=1.2e-008 * a3p_18
parameters toxp_18=5.9e-09 + 3.0000e-010 * a4np_18
parameters cjp_18=0.00112 * (1 + 0.070 * a1p_18)
parameters cjswp_18=9e-11 * (1 + 0.070 * a1p_18)
parameters cjswgp_18=1.7e-10 * (1 + 0.070 * a1p_18)
parameters dlcp_18=5.49049e-08
parameters cgop_18=5.23324e-11 * (1 - 0.070 * a4np_18)
parameters cglp_18=2.68907e-10 * (1 - 0.070 * a4np_18)
parameters dvthp_18= - 0.01 * a1p_18
parameters dlvthp_18= - 2e-010 * a1p_18
parameters dwvthp_18= - 7.9e-009 * a1p_18
parameters dpvthp_18= - 1.5e-015 * a1p_18
parameters du0p_18=0
parameters dlu0p_18= - 1e-011 * a1p_18
parameters dwu0p_18=1e-010 * a1p_18
parameters dpu0p_18=0
parameters dnfactorp_18=0
parameters dlnfactorp_18=0
parameters dwnfactorp_18=0
parameters dpnfactorp_18=0
parameters dcitp_18=0
parameters dlcitp_18=2e-011 * a1p_18
parameters dwcitp_18=0
parameters dpcitp_18=0
parameters dvsatp_18=0
parameters dlvsatp_18=0
parameters dwvsatp_18=0
parameters dpvsatp_18= - 1.1e-009 * a1p_18
parameters dleta0p_18= - 2e-008 * a1p_18
parameters dpeta0p_18=0
parameters dla0p_18=0
parameters dwa0p_18=0
parameters dpa0p_18=9e-014 * a1p_18
parameters cfp_18=9e-11 * (1 - 0.070 * a4np_18) + 2.4e-11 * ccoflag_18
parameters dlkt1p_18= - 5e-009 * a1p_18
parameters b1fn_18=-7.25E+40
parameters b2fn_18=4.75E+22 
parameters b3fn_18=-1.925E+8   
parameters a1fn_18=8.975E+41 
parameters a2fn_18=4.75E+22  
parameters a3fn_18=4.825e+8  
parameters c1fn_18=2.05E+41  
parameters c2fn_18=4E+10    
parameters c3fn_18=5.35e+8 
parameters b1fp_18=-3.55E+41   
parameters b2fp_18=0    
parameters b3fp_18=-2.225E+9    
parameters a1fp_18=1.573E+42    
parameters a2fp_18=0  
parameters a3fp_18=4.825E+9 
parameters c1fp_18=8.05E+41     
parameters c2fp_18=4E+10  
parameters c3fp_18=5.35E+9  
parameters noian_18=a1fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b1fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c1fn_18
parameters noibn_18=a2fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b2fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c2fn_18
parameters noicn_18=a3fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b3fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c3fn_18
parameters noiap_18=a1fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b1fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c1fp_18
parameters noibp_18=a2fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b2fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c2fp_18
parameters noicp_18=a3fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b3fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c3fp_18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_18
endsection sf_18
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_18
parameters parn1_18=0
parameters parn2_18=0
parameters parp1_18=0
parameters parp2_18=0
parameters a1n_18=-0.8
parameters a1p_18=0.8
parameters a2n_18=0
parameters a2p_18=0
parameters a3n_18=1
parameters a3p_18=-1
parameters a4np_18=0
parameters toxn_18=5.6e-09 + 3.0000e-010 * a4np_18
parameters dxln_18=1e-008 * a2n_18
parameters dxwn_18=1.2e-008 * a3n_18
parameters cjn_18=0.001051 * (1 + 0.070 * a1n_18)
parameters cjswn_18=1.355e-10 * (1 + 0.070 * a1n_18)
parameters cjswgn_18=1.621e-10 * (1 + 0.070 * a1n_18)
parameters dlcn_18=4.654e-08
parameters cgon_18=3.855e-11 * (1 - 0.070 * a4np_18)
parameters cgln_18=2.513e-10 * (1 - 0.070 * a4np_18)
parameters dvthn_18=0.038 * a1n_18
parameters dlvthn_18= - 2.5e-009 * a1n_18
parameters dwvthn_18=5e-010 * a1n_18
parameters dpvthn_18=3.2e-015 * a1n_18
parameters du0n_18=0
parameters dlu0n_18= - 3e-010 * a1n_18
parameters dwu0n_18= - 1e-010 * a1n_18
parameters dpu0n_18=1e-016 * a1n_18
parameters dcitn_18=0.0001 * a1n_18
parameters dlcitn_18=0
parameters dwcitn_18= - 1e-010 * a1n_18
parameters dpcitn_18=0
parameters deta0n_18=0.05 * a1n_18
parameters dleta0n_18=0
parameters dweta0n_18=0
parameters dpeta0n_18=0
parameters dk2n_18=0
parameters dlk2n_18=0
parameters dwk2n_18=0
parameters dpk2n_18=0
parameters cfn_18=9e-11 * (1 - 0.070 * a4np_18) + 2.4e-11 * ccoflag_18
parameters dk2_18=0
parameters dxlp_18=1e-008 * a2p_18
parameters dxwp_18=1.2e-008 * a3p_18
parameters toxp_18=5.9e-09 + 3.0000e-010 * a4np_18
parameters cjp_18=0.00112 * (1 + 0.070 * a1p_18)
parameters cjswp_18=9e-11 * (1 + 0.070 * a1p_18)
parameters cjswgp_18=1.7e-10 * (1 + 0.070 * a1p_18)
parameters dlcp_18=5.49049e-08
parameters cgop_18=5.23324e-11 * (1 - 0.070 * a4np_18)
parameters cglp_18=2.68907e-10 * (1 - 0.070 * a4np_18)
parameters dvthp_18= - 0.01 * a1p_18
parameters dlvthp_18= - 2e-010 * a1p_18
parameters dwvthp_18= - 7.9e-009 * a1p_18
parameters dpvthp_18= - 1.5e-015 * a1p_18
parameters du0p_18=0
parameters dlu0p_18= - 1e-011 * a1p_18
parameters dwu0p_18=1e-010 * a1p_18
parameters dpu0p_18=0
parameters dnfactorp_18=0
parameters dlnfactorp_18=0
parameters dwnfactorp_18=0
parameters dpnfactorp_18=0
parameters dcitp_18=0
parameters dlcitp_18=2e-011 * a1p_18
parameters dwcitp_18=0
parameters dpcitp_18=0
parameters dvsatp_18=0
parameters dlvsatp_18=0
parameters dwvsatp_18=0
parameters dpvsatp_18= - 1.1e-009 * a1p_18
parameters dleta0p_18= - 2e-008 * a1p_18
parameters dpeta0p_18=0
parameters dla0p_18=0
parameters dwa0p_18=0
parameters dpa0p_18=9e-014 * a1p_18
parameters cfp_18=9e-11 * (1 - 0.070 * a4np_18) + 2.4e-11 * ccoflag_18
parameters dlkt1p_18= - 5e-009 * a1p_18
parameters b1fn_18=-7.25E+40
parameters b2fn_18=4.75E+22 
parameters b3fn_18=-1.925E+8   
parameters a1fn_18=8.975E+41 
parameters a2fn_18=4.75E+22  
parameters a3fn_18=4.825e+8  
parameters c1fn_18=2.05E+41  
parameters c2fn_18=4E+10    
parameters c3fn_18=5.35e+8 
parameters b1fp_18=-3.55E+41   
parameters b2fp_18=0    
parameters b3fp_18=-2.225E+9    
parameters a1fp_18=1.573E+42    
parameters a2fp_18=0  
parameters a3fp_18=4.825E+9 
parameters c1fp_18=8.05E+41     
parameters c2fp_18=4E+10  
parameters c3fp_18=5.35E+9  
parameters noian_18=a1fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b1fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c1fn_18
parameters noibn_18=a2fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b2fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c2fn_18
parameters noicn_18=a3fn_18 * (abs(noiseflagn_18) + noiseflagn_18) + b3fn_18 * (abs(noiseflagn_18) 
+ - noiseflagn_18) + c3fn_18
parameters noiap_18=a1fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b1fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c1fp_18
parameters noibp_18=a2fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b2fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c2fp_18
parameters noicp_18=a3fp_18 * (abs(noiseflagp_18) + noiseflagp_18) + b3fp_18 * (abs(noiseflagp_18) 
+ - noiseflagp_18) + c3fp_18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_18
endsection fs_18
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25
parameters parn1_25=0
parameters parn2_25=0
parameters parp1_25=0
parameters parp2_25=0
parameters toxn_25=5.6e-09
parameters dxln_25=0
parameters dxwn_25=0
parameters cjn_25=1.051e-03
parameters cjswn_25=1.355e-10
parameters cjswgn_25=1.621e-10
parameters dlcn_25=4.654e-08
parameters cgon_25=3.855e-11
parameters cgln_25=2.513e-10
parameters dvthn_25=0
parameters dlvthn_25=0
parameters dwvthn_25=0
parameters dpvthn_25=0
parameters du0n_25=0
parameters dlu0n_25=0
parameters dwu0n_25=0
parameters dpu0n_25=0
parameters dcitn_25=0
parameters dlcitn_25=0
parameters dwcitn_25=0
parameters dpcitn_25=0
parameters dk2n_25=0
parameters dlk2n_25=0
parameters dwk2n_25=0
parameters dpk2n_25=0
parameters cfn_25=9.0000e-11 + 2.4e-11 * ccoflag_25
parameters dk2_25=0
parameters dxlp_25=0
parameters dxwp_25=0
parameters toxp_25=5.9e-09
parameters cjp_25=0.00112
parameters cjswp_25=9e-11
parameters cjswgp_25=1.7e-10
parameters dlcp_25=5.49049e-08
parameters cgop_25=5.23324e-11
parameters cglp_25=2.68907e-10
parameters dvthp_25=0
parameters dlvthp_25=0
parameters dwvthp_25=0
parameters dpvthp_25=0
parameters du0p_25=0
parameters dlu0p_25=0
parameters dwu0p_25=0
parameters dpu0p_25=0
parameters dnfactorp_25=0
parameters dlnfactorp_25=0
parameters dwnfactorp_25=0
parameters dpnfactorp_25=0
parameters dcitp_25=0
parameters dlcitp_25=0
parameters dwcitp_25=0
parameters dpcitp_25=0
parameters dvsatp_25=0
parameters dlvsatp_25=0
parameters dwvsatp_25=0
parameters dpvsatp_25=0
parameters dleta0p_25=0
parameters dpeta0p_25=0
parameters dla0p_25=0
parameters dwa0p_25=0
parameters dpa0p_25=0
parameters cfp_25=9e-11 + 2.4e-11 * ccoflag_25
parameters b1fn_25=-7.25E+40
parameters b2fn_25=4.75E+22 
parameters b3fn_25=-1.925E+8   
parameters a1fn_25=8.975E+41 
parameters a2fn_25=4.75E+22  
parameters a3fn_25=4.825e+8  
parameters c1fn_25=2.05E+41  
parameters c2fn_25=4E+10    
parameters c3fn_25=5.35e+8 
parameters b1fp_25=-3.55E+41   
parameters b2fp_25=0    
parameters b3fp_25=-2.225E+9    
parameters a1fp_25=1.573E+42    
parameters a2fp_25=0  
parameters a3fp_25=4.825E+9 
parameters c1fp_25=8.05E+41     
parameters c2fp_25=4E+10  
parameters c3fp_25=5.35E+9  
parameters noian_25=a1fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b1fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c1fn_25
parameters noibn_25=a2fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b2fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c2fn_25
parameters noicn_25=a3fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b3fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c3fn_25
parameters noiap_25=a1fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b1fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c1fp_25
parameters noibp_25=a2fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b2fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c2fp_25
parameters noicp_25=a3fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b3fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c3fp_25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25
endsection tt_25
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25
parameters parn1_25=0
parameters parn2_25=0
parameters parp1_25=0
parameters parp2_25=0
parameters toxn_25=5.9e-09
parameters dxln_25=1e-08
parameters dxwn_25=-1.2e-08
parameters cjn_25=1.125e-03
parameters cjswn_25=1.450e-10
parameters cjswgn_25=1.734e-10
parameters dlcn_25=4.654e-08
parameters cgon_25=3.585e-11
parameters cgln_25=2.337e-10
parameters dvthn_25=0.038
parameters dlvthn_25=-2.5e-09
parameters dwvthn_25=5e-10
parameters dpvthn_25=3e-15
parameters du0n_25=0
parameters dlu0n_25=-3e-10
parameters dwu0n_25=-1.5e-10
parameters dpu0n_25=0
parameters dcitn_25=0.0001
parameters dlcitn_25=0
parameters dwcitn_25=-1e-10
parameters dpcitn_25=0
parameters dk2n_25=0
parameters dlk2n_25=0
parameters dwk2n_25=0
parameters dpk2n_25=0
parameters cfn_25=8.370e-11 + 2.4e-11 * ccoflag_25
parameters dk2_25=0
parameters dxlp_25=1e-08
parameters dxwp_25=-1.2e-08
parameters toxp_25=6.2e-09
parameters cjp_25=0.001198
parameters cjswp_25=9.63e-11
parameters cjswgp_25=1.819e-10
parameters dlcp_25=5.49049e-08
parameters cgop_25=4.8668e-11
parameters cglp_25=2.50083e-10
parameters dvthp_25=-0.015
parameters dlvthp_25=-6e-10
parameters dwvthp_25=-2.9e-09
parameters dpvthp_25=-2.2e-15
parameters du0p_25=0
parameters dlu0p_25=0
parameters dwu0p_25=1e-10
parameters dpu0p_25=0
parameters dnfactorp_25=0
parameters dlnfactorp_25=0
parameters dwnfactorp_25=0
parameters dpnfactorp_25=0
parameters dcitp_25=0
parameters dlcitp_25=0
parameters dwcitp_25=0
parameters dpcitp_25=0
parameters dvsatp_25=0
parameters dlvsatp_25=0
parameters dwvsatp_25=0
parameters dpvsatp_25=-1.1e-09
parameters dleta0p_25=-3e-08
parameters dpeta0p_25=0
parameters dla0p_25=0
parameters dwa0p_25=0
parameters dpa0p_25=1.5e-13
parameters cfp_25=8.37e-11 + 2.4e-11 * ccoflag_25
parameters b1fn_25=-7.25E+40
parameters b2fn_25=4.75E+22 
parameters b3fn_25=-1.925E+8   
parameters a1fn_25=8.975E+41 
parameters a2fn_25=4.75E+22  
parameters a3fn_25=4.825e+8  
parameters c1fn_25=2.05E+41  
parameters c2fn_25=4E+10    
parameters c3fn_25=5.35e+8 
parameters b1fp_25=-3.55E+41   
parameters b2fp_25=0    
parameters b3fp_25=-2.225E+9    
parameters a1fp_25=1.573E+42    
parameters a2fp_25=0  
parameters a3fp_25=4.825E+9 
parameters c1fp_25=8.05E+41     
parameters c2fp_25=4E+10  
parameters c3fp_25=5.35E+9  
parameters noian_25=a1fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b1fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c1fn_25
parameters noibn_25=a2fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b2fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c2fn_25
parameters noicn_25=a3fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b3fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c3fn_25
parameters noiap_25=a1fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b1fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c1fp_25
parameters noibp_25=a2fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b2fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c2fp_25
parameters noicp_25=a3fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b3fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c3fp_25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25
endsection ss_25
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25
parameters parn1_25=0
parameters parn2_25=0
parameters parp1_25=0
parameters parp2_25=0
parameters toxn_25=5.3e-09
parameters dxln_25=-1e-08
parameters dxwn_25=1.2e-08
parameters cjn_25=9.774e-04
parameters cjswn_25=1.260e-10
parameters cjswgn_25=1.508e-10
parameters dlcn_25=4.654e-08
parameters cgon_25=4.125e-11
parameters cgln_25=2.689e-10
parameters dvthn_25=-0.038
parameters dlvthn_25=2.5e-09
parameters dwvthn_25=-5e-10
parameters dpvthn_25=-3.2e-15
parameters du0n_25=0
parameters dlu0n_25=3e-10
parameters dwu0n_25=1e-10
parameters dpu0n_25=-1e-16
parameters dcitn_25=-0.0001
parameters dlcitn_25=0
parameters dwcitn_25=1e-10
parameters dpcitn_25=0
parameters dk2n_25=0
parameters dlk2n_25=0
parameters dwk2n_25=0
parameters dpk2n_25=0
parameters cfn_25=9.630e-11 + 2.4e-11 * ccoflag_25
parameters dk2_25=0
parameters dxlp_25=-1e-08
parameters dxwp_25=1.2e-08
parameters toxp_25=5.6e-09
parameters cjp_25=0.001042
parameters cjswp_25=8.37e-11
parameters cjswgp_25=1.581e-10
parameters dlcp_25=5.49049e-08
parameters cgop_25=5.5995e-11
parameters cglp_25=2.87729e-10
parameters dvthp_25=0.01
parameters dlvthp_25=2.2e-09
parameters dwvthp_25=7.9e-09
parameters dpvthp_25=1.5e-15
parameters du0p_25=0
parameters dlu0p_25=1e-11
parameters dwu0p_25=-1e-10
parameters dpu0p_25=0
parameters dnfactorp_25=0
parameters dlnfactorp_25=0
parameters dwnfactorp_25=0
parameters dpnfactorp_25=0
parameters dcitp_25=0
parameters dlcitp_25=0
parameters dwcitp_25=0
parameters dpcitp_25=0
parameters dvsatp_25=0
parameters dlvsatp_25=0
parameters dwvsatp_25=0
parameters dpvsatp_25=1.1e-09
parameters dleta0p_25=2e-08
parameters dpeta0p_25=0
parameters dla0p_25=0
parameters dwa0p_25=0
parameters dpa0p_25=-9e-14
parameters cfp_25=9.63e-11 + 2.4e-11 * ccoflag_25
parameters b1fn_25=-7.25E+40
parameters b2fn_25=4.75E+22 
parameters b3fn_25=-1.925E+8   
parameters a1fn_25=8.975E+41 
parameters a2fn_25=4.75E+22  
parameters a3fn_25=4.825e+8  
parameters c1fn_25=2.05E+41  
parameters c2fn_25=4E+10    
parameters c3fn_25=5.35e+8 
parameters b1fp_25=-3.55E+41   
parameters b2fp_25=0    
parameters b3fp_25=-2.225E+9    
parameters a1fp_25=1.573E+42    
parameters a2fp_25=0  
parameters a3fp_25=4.825E+9 
parameters c1fp_25=8.05E+41     
parameters c2fp_25=4E+10  
parameters c3fp_25=5.35E+9  
parameters noian_25=a1fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b1fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c1fn_25
parameters noibn_25=a2fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b2fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c2fn_25
parameters noicn_25=a3fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b3fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c3fn_25
parameters noiap_25=a1fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b1fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c1fp_25
parameters noibp_25=a2fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b2fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c2fp_25
parameters noicp_25=a3fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b3fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c3fp_25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25
endsection ff_25
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25
parameters parn1_25=0
parameters parn2_25=0
parameters parp1_25=0
parameters parp2_25=0
parameters a1n_25=0.8
parameters a1p_25=-0.8
parameters a2n_25=0
parameters a2p_25=0
parameters a3n_25=-1
parameters a3p_25=1
parameters a4np_25=0
parameters toxn_25=5.6e-09 + 3.0000e-010 * a4np_25
parameters dxln_25=1e-008 * a2n_25
parameters dxwn_25=1.2e-008 * a3n_25
parameters cjn_25=1.051e-03 * (1 + 0.070 * a1n_25)
parameters cjswn_25=1.355e-10 * (1 + 0.070 * a1n_25)
parameters cjswgn_25=1.621e-10 * (1 + 0.070 * a1n_25)
parameters dlcn_25=4.654e-08
parameters cgon_25=3.855e-11 * (1 - 0.070 * a4np_25)
parameters cgln_25=2.513e-10 * (1 - 0.070 * a4np_25)
parameters dvthn_25=0.038 * a1n_25
parameters dlvthn_25= - 2.5e-009 * a1n_25
parameters dwvthn_25=5e-010 * a1n_25
parameters dpvthn_25=3.2e-015 * a1n_25
parameters du0n_25=0
parameters dlu0n_25= - 3e-010 * a1n_25
parameters dwu0n_25= - 1e-010 * a1n_25
parameters dpu0n_25=1e-016 * a1n_25
parameters dcitn_25=0.0001 * a1n_25
parameters dlcitn_25=0
parameters dwcitn_25= - 1e-010 * a1n_25
parameters dpcitn_25=0
parameters dk2n_25=0
parameters dlk2n_25=0
parameters dwk2n_25=0
parameters dpk2n_25=0
parameters cfn_25=9.0000e-11 * (1 - 0.070 * a4np_25) + 2.4e-11 * ccoflag_25
parameters dk2_25=0
parameters dxlp_25=1e-008 * a2p_25
parameters dxwp_25=1.2e-008 * a3p_25
parameters toxp_25=5.9e-09 + 3.0000e-010 * a4np_25
parameters cjp_25=0.00112 * (1 + 0.070 * a1p_25)
parameters cjswp_25=9e-11 * (1 + 0.070 * a1p_25)
parameters cjswgp_25=1.7e-10 * (1 + 0.070 * a1p_25)
parameters dlcp_25=5.49049e-08
parameters cgop_25=5.23324e-11 +  - 3.8059e-011 * a1p_25
parameters cglp_25=2.68907e-10 +  - 4.0471e-011 * a1p_25
parameters dvthp_25= - 0.01 * a1p_25
parameters dlvthp_25= - 2.2e-009 * a1p_25
parameters dwvthp_25= - 7.9e-009 * a1p_25
parameters dpvthp_25= - 1.5e-015 * a1p_25
parameters du0p_25=0
parameters dlu0p_25= - 1e-011 * a1p_25
parameters dwu0p_25=1e-010 * a1p_25
parameters dpu0p_25=0
parameters dnfactorp_25=0
parameters dlnfactorp_25=0
parameters dwnfactorp_25=0
parameters dpnfactorp_25=0
parameters dcitp_25=0
parameters dlcitp_25=0
parameters dwcitp_25=0
parameters dpcitp_25=0
parameters dvsatp_25=0
parameters dlvsatp_25=0
parameters dwvsatp_25=0
parameters dpvsatp_25= - 1.1e-009 * a1p_25
parameters dleta0p_25= - 2e-008 * a1p_25
parameters dpeta0p_25=0
parameters dla0p_25=0
parameters dwa0p_25=0
parameters dpa0p_25=9e-014 * a1p_25
parameters cfp_25=9e-11 * (1 - 0.070 * a4np_25) + 2.4e-11 * ccoflag_25
parameters b1fn_25=-7.25E+40
parameters b2fn_25=4.75E+22 
parameters b3fn_25=-1.925E+8   
parameters a1fn_25=8.975E+41 
parameters a2fn_25=4.75E+22  
parameters a3fn_25=4.825e+8  
parameters c1fn_25=2.05E+41  
parameters c2fn_25=4E+10    
parameters c3fn_25=5.35e+8 
parameters b1fp_25=-3.55E+41   
parameters b2fp_25=0    
parameters b3fp_25=-2.225E+9    
parameters a1fp_25=1.573E+42    
parameters a2fp_25=0  
parameters a3fp_25=4.825E+9 
parameters c1fp_25=8.05E+41     
parameters c2fp_25=4E+10  
parameters c3fp_25=5.35E+9  
parameters noian_25=a1fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b1fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c1fn_25
parameters noibn_25=a2fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b2fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c2fn_25
parameters noicn_25=a3fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b3fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c3fn_25
parameters noiap_25=a1fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b1fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c1fp_25
parameters noibp_25=a2fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b2fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c2fp_25
parameters noicp_25=a3fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b3fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c3fp_25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25
endsection sf_25
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25
parameters parn1_25=0
parameters parn2_25=0
parameters parp1_25=0
parameters parp2_25=0
parameters a1n_25=-0.8
parameters a1p_25=0.8
parameters a2n_25=0
parameters a2p_25=0
parameters a3n_25=1
parameters a3p_25=-1
parameters a4np_25=0
parameters toxn_25=5.6e-09 + 3.0000e-010 * a4np_25
parameters dxln_25=1e-008 * a2n_25
parameters dxwn_25=1.2e-008 * a3n_25
parameters cjn_25=1.051e-03 * (1 + 0.070 * a1n_25)
parameters cjswn_25=1.355e-10 * (1 + 0.070 * a1n_25)
parameters cjswgn_25=1.621e-10 * (1 + 0.070 * a1n_25)
parameters dlcn_25=4.654e-08
parameters cgon_25=3.855e-11 * (1 - 0.070 * a4np_25)
parameters cgln_25=2.513e-10 * (1 - 0.070 * a4np_25)
parameters dvthn_25=0.038 * a1n_25
parameters dlvthn_25= - 2.5e-009 * a1n_25
parameters dwvthn_25=5e-010 * a1n_25
parameters dpvthn_25=3.2e-015 * a1n_25
parameters du0n_25=0
parameters dlu0n_25= - 3e-010 * a1n_25
parameters dwu0n_25= - 1e-010 * a1n_25
parameters dpu0n_25=1e-016 * a1n_25
parameters dcitn_25=0.0001 * a1n_25
parameters dlcitn_25=0
parameters dwcitn_25= - 1e-010 * a1n_25
parameters dpcitn_25=0
parameters dk2n_25=0
parameters dlk2n_25=0
parameters dwk2n_25=0
parameters dpk2n_25=0
parameters cfn_25=9.0000e-11 * (1 - 0.070 * a4np_25) + 2.4e-11 * ccoflag_25
parameters dk2_25=0
parameters dxlp_25=1e-008 * a2p_25
parameters dxwp_25=1.2e-008 * a3p_25
parameters toxp_25=5.9e-09 + 3.0000e-010 * a4np_25
parameters cjp_25=0.00112 * (1 + 0.070 * a1p_25)
parameters cjswp_25=9e-11 * (1 + 0.070 * a1p_25)
parameters cjswgp_25=1.7e-10 * (1 + 0.070 * a1p_25)
parameters dlcp_25=5.49049e-08
parameters cgop_25=5.23324e-11 +  - 3.8059e-011 * a1p_25
parameters cglp_25=2.68907e-10 +  - 4.0471e-011 * a1p_25
parameters dvthp_25= - 0.01 * a1p_25
parameters dlvthp_25= - 2.2e-009 * a1p_25
parameters dwvthp_25= - 7.9e-009 * a1p_25
parameters dpvthp_25= - 1.5e-015 * a1p_25
parameters du0p_25=0
parameters dlu0p_25= - 1e-011 * a1p_25
parameters dwu0p_25=1e-010 * a1p_25
parameters dpu0p_25=0
parameters dnfactorp_25=0
parameters dlnfactorp_25=0
parameters dwnfactorp_25=0
parameters dpnfactorp_25=0
parameters dcitp_25=0
parameters dlcitp_25=0
parameters dwcitp_25=0
parameters dpcitp_25=0
parameters dvsatp_25=0
parameters dlvsatp_25=0
parameters dwvsatp_25=0
parameters dpvsatp_25= - 1.1e-009 * a1p_25
parameters dleta0p_25= - 2e-008 * a1p_25
parameters dpeta0p_25=0
parameters dla0p_25=0
parameters dwa0p_25=0
parameters dpa0p_25=9e-014 * a1p_25
parameters cfp_25=9e-11 * (1 - 0.070 * a4np_25) + 2.4e-11 * ccoflag_25
parameters b1fn_25=-7.25E+40
parameters b2fn_25=4.75E+22 
parameters b3fn_25=-1.925E+8   
parameters a1fn_25=8.975E+41 
parameters a2fn_25=4.75E+22  
parameters a3fn_25=4.825e+8  
parameters c1fn_25=2.05E+41  
parameters c2fn_25=4E+10    
parameters c3fn_25=5.35e+8 
parameters b1fp_25=-3.55E+41   
parameters b2fp_25=0    
parameters b3fp_25=-2.225E+9    
parameters a1fp_25=1.573E+42    
parameters a2fp_25=0  
parameters a3fp_25=4.825E+9 
parameters c1fp_25=8.05E+41     
parameters c2fp_25=4E+10  
parameters c3fp_25=5.35E+9   
parameters noian_25=a1fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b1fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c1fn_25
parameters noibn_25=a2fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b2fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c2fn_25
parameters noicn_25=a3fn_25 * (abs(noiseflagn_25) + noiseflagn_25) + b3fn_25 * (abs(noiseflagn_25) 
+ - noiseflagn_25) + c3fn_25
parameters noiap_25=a1fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b1fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c1fp_25
parameters noibp_25=a2fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b2fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c2fp_25
parameters noicp_25=a3fp_25 * (abs(noiseflagp_25) + noiseflagp_25) + b3fp_25 * (abs(noiseflagp_25) 
+ - noiseflagp_25) + c3fp_25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25
endsection fs_25
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25ud18
parameters parn1_25ud18=0
parameters parn2_25ud18=0
parameters parp1_25ud18=0
parameters parp2_25ud18=0
parameters toxn_25ud18=5.6e-09
parameters dxln_25ud18=0
parameters dxwn_25ud18=0
parameters cjn_25ud18=0.001051
parameters cjswn_25ud18=1.355e-10
parameters cjswgn_25ud18=1.621e-10
parameters dlcn_25ud18=4.654e-08
parameters cgon_25ud18=3.855e-11
parameters cgln_25ud18=2.513e-10
parameters dvthn_25ud18=0
parameters dlvthn_25ud18=0
parameters dwvthn_25ud18=0
parameters dpvthn_25ud18=0
parameters du0n_25ud18=0
parameters dlu0n_25ud18=0
parameters dwu0n_25ud18=0
parameters dpu0n_25ud18=0
parameters dcitn_25ud18=0
parameters dlcitn_25ud18=0
parameters dwcitn_25ud18=0
parameters dpcitn_25ud18=0
parameters deta0n_25ud18=0
parameters dleta0n_25ud18=0
parameters dweta0n_25ud18=0
parameters dpeta0n_25ud18=0
parameters dk2n_25ud18=0
parameters dlk2n_25ud18=0
parameters dwk2n_25ud18=0
parameters dpk2n_25ud18=0
parameters cfn_25ud18=9e-11 + 2.4e-11 * ccoflag_25ud18
parameters dk2_25ud18=0
parameters dxlp_25ud18=0
parameters dxwp_25ud18=0
parameters toxp_25ud18=5.9e-09
parameters cjp_25ud18=0.00112
parameters cjswp_25ud18=9e-11
parameters cjswgp_25ud18=1.7e-10
parameters dlcp_25ud18=5.49049e-08
parameters cgop_25ud18=5.23324e-11
parameters cglp_25ud18=2.68907e-10
parameters dvthp_25ud18=0
parameters dlvthp_25ud18=0
parameters dwvthp_25ud18=0
parameters dpvthp_25ud18=0
parameters du0p_25ud18=0
parameters dlu0p_25ud18=0
parameters dwu0p_25ud18=0
parameters dpu0p_25ud18=0
parameters dnfactorp_25ud18=0
parameters dlnfactorp_25ud18=0
parameters dwnfactorp_25ud18=0
parameters dpnfactorp_25ud18=0
parameters dcitp_25ud18=0
parameters dlcitp_25ud18=0
parameters dwcitp_25ud18=0
parameters dpcitp_25ud18=0
parameters dvsatp_25ud18=0
parameters dlvsatp_25ud18=0
parameters dwvsatp_25ud18=0
parameters dpvsatp_25ud18=0
parameters dleta0p_25ud18=0
parameters dpeta0p_25ud18=0
parameters dla0p_25ud18=0
parameters dwa0p_25ud18=0
parameters dpa0p_25ud18=0
parameters cfp_25ud18=9e-11 + 2.4e-11 * ccoflag_25ud18
parameters dlkt1p_25ud18=0
parameters b1fn_25ud18=-7.25E+40
parameters b2fn_25ud18=4.75E+22 
parameters b3fn_25ud18=-1.925E+8   
parameters a1fn_25ud18=8.975E+41 
parameters a2fn_25ud18=4.75E+22  
parameters a3fn_25ud18=4.825e+8  
parameters c1fn_25ud18=2.05E+41  
parameters c2fn_25ud18=4E+10    
parameters c3fn_25ud18=5.35e+8 
parameters b1fp_25ud18=-3.55E+41   
parameters b2fp_25ud18=0    
parameters b3fp_25ud18=-2.225E+9    
parameters a1fp_25ud18=1.573E+42    
parameters a2fp_25ud18=0  
parameters a3fp_25ud18=4.825E+9 
parameters c1fp_25ud18=8.05E+41     
parameters c2fp_25ud18=4E+10  
parameters c3fp_25ud18=5.35E+9  
parameters noian_25ud18=a1fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b1fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c1fn_25ud18
parameters noibn_25ud18=a2fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b2fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c2fn_25ud18
parameters noicn_25ud18=a3fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b3fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c3fn_25ud18
parameters noiap_25ud18=a1fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b1fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c1fp_25ud18
parameters noibp_25ud18=a2fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b2fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c2fp_25ud18
parameters noicp_25ud18=a3fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b3fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c3fp_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25ud18
endsection tt_25ud18
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25ud18
parameters parn1_25ud18=0
parameters parn2_25ud18=0
parameters parp1_25ud18=0
parameters parp2_25ud18=0
parameters toxn_25ud18=5.9e-09
parameters dxln_25ud18=1e-08
parameters dxwn_25ud18=-1.2e-08
parameters cjn_25ud18=0.001125
parameters cjswn_25ud18=1.45e-10
parameters cjswgn_25ud18=1.734e-10
parameters dlcn_25ud18=4.654e-08
parameters cgon_25ud18=3.585e-11
parameters cgln_25ud18=2.337e-10
parameters dvthn_25ud18=0.038
parameters dlvthn_25ud18=-2.5e-09
parameters dwvthn_25ud18=5e-10
parameters dpvthn_25ud18=3e-15
parameters du0n_25ud18=0
parameters dlu0n_25ud18=-3e-10
parameters dwu0n_25ud18=-1.5e-10
parameters dpu0n_25ud18=0
parameters dcitn_25ud18=0.0001
parameters dlcitn_25ud18=0
parameters dwcitn_25ud18=-1e-10
parameters dpcitn_25ud18=0
parameters deta0n_25ud18=0
parameters dleta0n_25ud18=0
parameters dweta0n_25ud18=0
parameters dpeta0n_25ud18=0
parameters dk2n_25ud18=0
parameters dlk2n_25ud18=0
parameters dwk2n_25ud18=0
parameters dpk2n_25ud18=0
parameters cfn_25ud18=8.37e-11 + 2.4e-11 * ccoflag_25ud18
parameters dk2_25ud18=0
parameters dxlp_25ud18=1e-08
parameters dxwp_25ud18=-1.2e-08
parameters toxp_25ud18=6.2e-09
parameters cjp_25ud18=0.001198
parameters cjswp_25ud18=9.63e-11
parameters cjswgp_25ud18=1.819e-10
parameters dlcp_25ud18=5.49049e-08
parameters cgop_25ud18=4.8668e-11
parameters cglp_25ud18=2.50083e-10
parameters dvthp_25ud18=-0.015
parameters dlvthp_25ud18=-6e-10
parameters dwvthp_25ud18=-2.9e-09
parameters dpvthp_25ud18=-2.2e-15
parameters du0p_25ud18=0
parameters dlu0p_25ud18=0
parameters dwu0p_25ud18=1e-10
parameters dpu0p_25ud18=0
parameters dnfactorp_25ud18=0
parameters dlnfactorp_25ud18=0
parameters dwnfactorp_25ud18=0
parameters dpnfactorp_25ud18=0
parameters dcitp_25ud18=0
parameters dlcitp_25ud18=0
parameters dwcitp_25ud18=0
parameters dpcitp_25ud18=0
parameters dvsatp_25ud18=0
parameters dlvsatp_25ud18=0
parameters dwvsatp_25ud18=0
parameters dpvsatp_25ud18=-1.1e-09
parameters dleta0p_25ud18=-3e-08
parameters dpeta0p_25ud18=0
parameters dla0p_25ud18=0
parameters dwa0p_25ud18=0
parameters dpa0p_25ud18=1.5e-13
parameters cfp_25ud18=8.37e-11 + 2.4e-11 * ccoflag_25ud18
parameters dlkt1p_25ud18=0
parameters b1fn_25ud18=-7.25E+40
parameters b2fn_25ud18=4.75E+22 
parameters b3fn_25ud18=-1.925E+8   
parameters a1fn_25ud18=8.975E+41 
parameters a2fn_25ud18=4.75E+22  
parameters a3fn_25ud18=4.825e+8  
parameters c1fn_25ud18=2.05E+41  
parameters c2fn_25ud18=4E+10    
parameters c3fn_25ud18=5.35e+8 
parameters b1fp_25ud18=-3.55E+41   
parameters b2fp_25ud18=0    
parameters b3fp_25ud18=-2.225E+9    
parameters a1fp_25ud18=1.573E+42    
parameters a2fp_25ud18=0  
parameters a3fp_25ud18=4.825E+9 
parameters c1fp_25ud18=8.05E+41     
parameters c2fp_25ud18=4E+10  
parameters c3fp_25ud18=5.35E+9  
parameters noian_25ud18=a1fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b1fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c1fn_25ud18
parameters noibn_25ud18=a2fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b2fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c2fn_25ud18
parameters noicn_25ud18=a3fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b3fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c3fn_25ud18
parameters noiap_25ud18=a1fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b1fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c1fp_25ud18
parameters noibp_25ud18=a2fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b2fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c2fp_25ud18
parameters noicp_25ud18=a3fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b3fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c3fp_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25ud18
endsection ss_25ud18
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25ud18
parameters parn1_25ud18=0
parameters parn2_25ud18=0
parameters parp1_25ud18=0
parameters parp2_25ud18=0
parameters toxn_25ud18=5.3e-09
parameters dxln_25ud18=-1e-08
parameters dxwn_25ud18=1.2e-08
parameters cjn_25ud18=0.0009774
parameters cjswn_25ud18=1.26e-10
parameters cjswgn_25ud18=1.508e-10
parameters dlcn_25ud18=4.654e-08
parameters cgon_25ud18=4.125e-11
parameters cgln_25ud18=2.689e-10
parameters dvthn_25ud18=-0.038
parameters dlvthn_25ud18=2.5e-09
parameters dwvthn_25ud18=-5e-10
parameters dpvthn_25ud18=-3.2e-15
parameters du0n_25ud18=0
parameters dlu0n_25ud18=3e-10
parameters dwu0n_25ud18=1e-10
parameters dpu0n_25ud18=-1e-16
parameters dcitn_25ud18=-0.0001
parameters dlcitn_25ud18=0
parameters dwcitn_25ud18=1e-10
parameters dpcitn_25ud18=0
parameters deta0n_25ud18=-0.05
parameters dleta0n_25ud18=0
parameters dweta0n_25ud18=0
parameters dpeta0n_25ud18=0
parameters dk2n_25ud18=0
parameters dlk2n_25ud18=0
parameters dwk2n_25ud18=0
parameters dpk2n_25ud18=0
parameters cfn_25ud18=9.63e-11 + 2.4e-11 * ccoflag_25ud18
parameters dk2_25ud18=0
parameters dxlp_25ud18=-1e-08
parameters dxwp_25ud18=1.2e-08
parameters toxp_25ud18=5.6e-09
parameters cjp_25ud18=0.001042
parameters cjswp_25ud18=8.37e-11
parameters cjswgp_25ud18=1.581e-10
parameters dlcp_25ud18=5.49049e-08
parameters cgop_25ud18=5.5995e-11
parameters cglp_25ud18=2.87729e-10
parameters dvthp_25ud18=0.01
parameters dlvthp_25ud18=2e-10
parameters dwvthp_25ud18=7.9e-09
parameters dpvthp_25ud18=1.5e-15
parameters du0p_25ud18=0
parameters dlu0p_25ud18=1e-11
parameters dwu0p_25ud18=-1e-10
parameters dpu0p_25ud18=0
parameters dnfactorp_25ud18=0
parameters dlnfactorp_25ud18=0
parameters dwnfactorp_25ud18=0
parameters dpnfactorp_25ud18=0
parameters dcitp_25ud18=0
parameters dlcitp_25ud18=-2e-11
parameters dwcitp_25ud18=0
parameters dpcitp_25ud18=0
parameters dvsatp_25ud18=0
parameters dlvsatp_25ud18=0
parameters dwvsatp_25ud18=0
parameters dpvsatp_25ud18=1.1e-09
parameters dleta0p_25ud18=2e-08
parameters dpeta0p_25ud18=0
parameters dla0p_25ud18=0
parameters dwa0p_25ud18=0
parameters dpa0p_25ud18=-9e-14
parameters cfp_25ud18=9.63e-11 + 2.4e-11 * ccoflag_25ud18
parameters dlkt1p_25ud18=5e-09
parameters b1fn_25ud18=-7.25E+40
parameters b2fn_25ud18=4.75E+22 
parameters b3fn_25ud18=-1.925E+8   
parameters a1fn_25ud18=8.975E+41 
parameters a2fn_25ud18=4.75E+22  
parameters a3fn_25ud18=4.825e+8  
parameters c1fn_25ud18=2.05E+41  
parameters c2fn_25ud18=4E+10    
parameters c3fn_25ud18=5.35e+8 
parameters b1fp_25ud18=-3.55E+41   
parameters b2fp_25ud18=0    
parameters b3fp_25ud18=-2.225E+9    
parameters a1fp_25ud18=1.573E+42    
parameters a2fp_25ud18=0  
parameters a3fp_25ud18=4.825E+9 
parameters c1fp_25ud18=8.05E+41     
parameters c2fp_25ud18=4E+10  
parameters c3fp_25ud18=5.35E+9  
parameters noian_25ud18=a1fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b1fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c1fn_25ud18
parameters noibn_25ud18=a2fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b2fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c2fn_25ud18
parameters noicn_25ud18=a3fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b3fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c3fn_25ud18
parameters noiap_25ud18=a1fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b1fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c1fp_25ud18
parameters noibp_25ud18=a2fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b2fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c2fp_25ud18
parameters noicp_25ud18=a3fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b3fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c3fp_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25ud18
endsection ff_25ud18
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25ud18
parameters parn1_25ud18=0
parameters parn2_25ud18=0
parameters parp1_25ud18=0
parameters parp2_25ud18=0
parameters a1n_25ud18=0.8
parameters a1p_25ud18=-0.8
parameters a2n_25ud18=0
parameters a2p_25ud18=0
parameters a3n_25ud18=-1
parameters a3p_25ud18=1
parameters a4np_25ud18=0
parameters toxn_25ud18=5.6e-09 + 3.0000e-010 * a4np_25ud18
parameters dxln_25ud18=1e-008 * a2n_25ud18
parameters dxwn_25ud18=1.2e-008 * a3n_25ud18
parameters cjn_25ud18=0.001051 * (1 + 0.070 * a1n_25ud18)
parameters cjswn_25ud18=1.355e-10 * (1 + 0.070 * a1n_25ud18)
parameters cjswgn_25ud18=1.621e-10 * (1 + 0.070 * a1n_25ud18)
parameters dlcn_25ud18=4.654e-08
parameters cgon_25ud18=3.855e-11 * (1 - 0.070 * a4np_25ud18)
parameters cgln_25ud18=2.513e-10 * (1 - 0.070 * a4np_25ud18)
parameters dvthn_25ud18=0.038 * a1n_25ud18
parameters dlvthn_25ud18= - 2.5e-009 * a1n_25ud18
parameters dwvthn_25ud18=5e-010 * a1n_25ud18
parameters dpvthn_25ud18=3.2e-015 * a1n_25ud18
parameters du0n_25ud18=0
parameters dlu0n_25ud18= - 3e-010 * a1n_25ud18
parameters dwu0n_25ud18= - 1e-010 * a1n_25ud18
parameters dpu0n_25ud18=1e-016 * a1n_25ud18
parameters dcitn_25ud18=0.0001 * a1n_25ud18
parameters dlcitn_25ud18=0
parameters dwcitn_25ud18= - 1e-010 * a1n_25ud18
parameters dpcitn_25ud18=0
parameters deta0n_25ud18=0.05 * a1n_25ud18
parameters dleta0n_25ud18=0
parameters dweta0n_25ud18=0
parameters dpeta0n_25ud18=0
parameters dk2n_25ud18=0
parameters dlk2n_25ud18=0
parameters dwk2n_25ud18=0
parameters dpk2n_25ud18=0
parameters cfn_25ud18=9e-11 * (1 - 0.070 * a4np_25ud18) + 2.4e-11 * ccoflag_25ud18
parameters dk2_25ud18=0
parameters dxlp_25ud18=1e-008 * a2p_25ud18
parameters dxwp_25ud18=1.2e-008 * a3p_25ud18
parameters toxp_25ud18=5.9e-09 + 3.0000e-010 * a4np_25ud18
parameters cjp_25ud18=0.00112 * (1 + 0.070 * a1p_25ud18)
parameters cjswp_25ud18=9e-11 * (1 + 0.070 * a1p_25ud18)
parameters cjswgp_25ud18=1.7e-10 * (1 + 0.070 * a1p_25ud18)
parameters dlcp_25ud18=5.49049e-08
parameters cgop_25ud18=5.23324e-11 * (1 - 0.070 * a4np_25ud18)
parameters cglp_25ud18=2.68907e-10 * (1 - 0.070 * a4np_25ud18)
parameters dvthp_25ud18= - 0.01 * a1p_25ud18
parameters dlvthp_25ud18= - 2e-010 * a1p_25ud18
parameters dwvthp_25ud18= - 7.9e-009 * a1p_25ud18
parameters dpvthp_25ud18= - 1.5e-015 * a1p_25ud18
parameters du0p_25ud18=0
parameters dlu0p_25ud18= - 1e-011 * a1p_25ud18
parameters dwu0p_25ud18=1e-010 * a1p_25ud18
parameters dpu0p_25ud18=0
parameters dnfactorp_25ud18=0
parameters dlnfactorp_25ud18=0
parameters dwnfactorp_25ud18=0
parameters dpnfactorp_25ud18=0
parameters dcitp_25ud18=0
parameters dlcitp_25ud18=2e-011 * a1p_25ud18
parameters dwcitp_25ud18=0
parameters dpcitp_25ud18=0
parameters dvsatp_25ud18=0
parameters dlvsatp_25ud18=0
parameters dwvsatp_25ud18=0
parameters dpvsatp_25ud18= - 1.1e-009 * a1p_25ud18
parameters dleta0p_25ud18= - 2e-008 * a1p_25ud18
parameters dpeta0p_25ud18=0
parameters dla0p_25ud18=0
parameters dwa0p_25ud18=0
parameters dpa0p_25ud18=9e-014 * a1p_25ud18
parameters cfp_25ud18=9e-11 * (1 - 0.070 * a4np_25ud18) + 2.4e-11 * ccoflag_25ud18
parameters dlkt1p_25ud18= - 5e-009 * a1p_25ud18
parameters b1fn_25ud18=-7.25E+40
parameters b2fn_25ud18=4.75E+22 
parameters b3fn_25ud18=-1.925E+8   
parameters a1fn_25ud18=8.975E+41 
parameters a2fn_25ud18=4.75E+22  
parameters a3fn_25ud18=4.825e+8  
parameters c1fn_25ud18=2.05E+41  
parameters c2fn_25ud18=4E+10    
parameters c3fn_25ud18=5.35e+8 
parameters b1fp_25ud18=-3.55E+41   
parameters b2fp_25ud18=0    
parameters b3fp_25ud18=-2.225E+9    
parameters a1fp_25ud18=1.573E+42    
parameters a2fp_25ud18=0  
parameters a3fp_25ud18=4.825E+9 
parameters c1fp_25ud18=8.05E+41     
parameters c2fp_25ud18=4E+10  
parameters c3fp_25ud18=5.35E+9  
parameters noian_25ud18=a1fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b1fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c1fn_25ud18
parameters noibn_25ud18=a2fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b2fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c2fn_25ud18
parameters noicn_25ud18=a3fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b3fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c3fn_25ud18
parameters noiap_25ud18=a1fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b1fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c1fp_25ud18
parameters noibp_25ud18=a2fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b2fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c2fp_25ud18
parameters noicp_25ud18=a3fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b3fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c3fp_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25ud18
endsection sf_25ud18
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25ud18
parameters parn1_25ud18=0
parameters parn2_25ud18=0
parameters parp1_25ud18=0
parameters parp2_25ud18=0
parameters a1n_25ud18=-0.8
parameters a1p_25ud18=0.8
parameters a2n_25ud18=0
parameters a2p_25ud18=0
parameters a3n_25ud18=1
parameters a3p_25ud18=-1
parameters a4np_25ud18=0
parameters toxn_25ud18=5.6e-09 + 3.0000e-010 * a4np_25ud18
parameters dxln_25ud18=1e-008 * a2n_25ud18
parameters dxwn_25ud18=1.2e-008 * a3n_25ud18
parameters cjn_25ud18=0.001051 * (1 + 0.070 * a1n_25ud18)
parameters cjswn_25ud18=1.355e-10 * (1 + 0.070 * a1n_25ud18)
parameters cjswgn_25ud18=1.621e-10 * (1 + 0.070 * a1n_25ud18)
parameters dlcn_25ud18=4.654e-08
parameters cgon_25ud18=3.855e-11 * (1 - 0.070 * a4np_25ud18)
parameters cgln_25ud18=2.513e-10 * (1 - 0.070 * a4np_25ud18)
parameters dvthn_25ud18=0.038 * a1n_25ud18
parameters dlvthn_25ud18= - 2.5e-009 * a1n_25ud18
parameters dwvthn_25ud18=5e-010 * a1n_25ud18
parameters dpvthn_25ud18=3.2e-015 * a1n_25ud18
parameters du0n_25ud18=0
parameters dlu0n_25ud18= - 3e-010 * a1n_25ud18
parameters dwu0n_25ud18= - 1e-010 * a1n_25ud18
parameters dpu0n_25ud18=1e-016 * a1n_25ud18
parameters dcitn_25ud18=0.0001 * a1n_25ud18
parameters dlcitn_25ud18=0
parameters dwcitn_25ud18= - 1e-010 * a1n_25ud18
parameters dpcitn_25ud18=0
parameters deta0n_25ud18=0.05 * a1n_25ud18
parameters dleta0n_25ud18=0
parameters dweta0n_25ud18=0
parameters dpeta0n_25ud18=0
parameters dk2n_25ud18=0
parameters dlk2n_25ud18=0
parameters dwk2n_25ud18=0
parameters dpk2n_25ud18=0
parameters cfn_25ud18=9e-11 * (1 - 0.070 * a4np_25ud18) + 2.4e-11 * ccoflag_25ud18
parameters dk2_25ud18=0
parameters dxlp_25ud18=1e-008 * a2p_25ud18
parameters dxwp_25ud18=1.2e-008 * a3p_25ud18
parameters toxp_25ud18=5.9e-09 + 3.0000e-010 * a4np_25ud18
parameters cjp_25ud18=0.00112 * (1 + 0.070 * a1p_25ud18)
parameters cjswp_25ud18=9e-11 * (1 + 0.070 * a1p_25ud18)
parameters cjswgp_25ud18=1.7e-10 * (1 + 0.070 * a1p_25ud18)
parameters dlcp_25ud18=5.49049e-08
parameters cgop_25ud18=5.23324e-11 * (1 - 0.070 * a4np_25ud18)
parameters cglp_25ud18=2.68907e-10 * (1 - 0.070 * a4np_25ud18)
parameters dvthp_25ud18= - 0.01 * a1p_25ud18
parameters dlvthp_25ud18= - 2e-010 * a1p_25ud18
parameters dwvthp_25ud18= - 7.9e-009 * a1p_25ud18
parameters dpvthp_25ud18= - 1.5e-015 * a1p_25ud18
parameters du0p_25ud18=0
parameters dlu0p_25ud18= - 1e-011 * a1p_25ud18
parameters dwu0p_25ud18=1e-010 * a1p_25ud18
parameters dpu0p_25ud18=0
parameters dnfactorp_25ud18=0
parameters dlnfactorp_25ud18=0
parameters dwnfactorp_25ud18=0
parameters dpnfactorp_25ud18=0
parameters dcitp_25ud18=0
parameters dlcitp_25ud18=2e-011 * a1p_25ud18
parameters dwcitp_25ud18=0
parameters dpcitp_25ud18=0
parameters dvsatp_25ud18=0
parameters dlvsatp_25ud18=0
parameters dwvsatp_25ud18=0
parameters dpvsatp_25ud18= - 1.1e-009 * a1p_25ud18
parameters dleta0p_25ud18= - 2e-008 * a1p_25ud18
parameters dpeta0p_25ud18=0
parameters dla0p_25ud18=0
parameters dwa0p_25ud18=0
parameters dpa0p_25ud18=9e-014 * a1p_25ud18
parameters cfp_25ud18=9e-11 * (1 - 0.070 * a4np_25ud18) + 2.4e-11 * ccoflag_25ud18
parameters dlkt1p_25ud18= - 5e-009 * a1p_25ud18
parameters b1fn_25ud18=-7.25E+40
parameters b2fn_25ud18=4.75E+22 
parameters b3fn_25ud18=-1.925E+8   
parameters a1fn_25ud18=8.975E+41 
parameters a2fn_25ud18=4.75E+22  
parameters a3fn_25ud18=4.825e+8  
parameters c1fn_25ud18=2.05E+41  
parameters c2fn_25ud18=4E+10    
parameters c3fn_25ud18=5.35e+8 
parameters b1fp_25ud18=-3.55E+41   
parameters b2fp_25ud18=0    
parameters b3fp_25ud18=-2.225E+9    
parameters a1fp_25ud18=1.573E+42    
parameters a2fp_25ud18=0  
parameters a3fp_25ud18=4.825E+9 
parameters c1fp_25ud18=8.05E+41     
parameters c2fp_25ud18=4E+10  
parameters c3fp_25ud18=5.35E+9  
parameters noian_25ud18=a1fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b1fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c1fn_25ud18
parameters noibn_25ud18=a2fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b2fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c2fn_25ud18
parameters noicn_25ud18=a3fn_25ud18 * (abs(noiseflagn_25ud18) + noiseflagn_25ud18) 
+ + b3fn_25ud18 * (abs(noiseflagn_25ud18) - noiseflagn_25ud18) + c3fn_25ud18
parameters noiap_25ud18=a1fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b1fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c1fp_25ud18
parameters noibp_25ud18=a2fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b2fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c2fp_25ud18
parameters noicp_25ud18=a3fp_25ud18 * (abs(noiseflagp_25ud18) + noiseflagp_25ud18) 
+ + b3fp_25ud18 * (abs(noiseflagp_25ud18) - noiseflagp_25ud18) + c3fp_25ud18
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25ud18
endsection fs_25ud18
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25od33
parameters parn1_25od33=0
parameters parn2_25od33=0
parameters parp1_25od33=0
parameters parp2_25od33=0
parameters toxn_25od33=5.6e-09
parameters dxln_25od33=0
parameters dxwn_25od33=0
parameters cjn_25od33=0.001051
parameters cjswn_25od33=1.355e-10
parameters cjswgn_25od33=1.621e-10
parameters dlcn_25od33=4.654e-08
parameters cgon_25od33=3.855e-11
parameters cgln_25od33=2.513e-10
parameters dvthn_25od33=0
parameters dlvthn_25od33=0
parameters dwvthn_25od33=0
parameters dpvthn_25od33=0
parameters du0n_25od33=0
parameters dlu0n_25od33=0
parameters dwu0n_25od33=0
parameters dpu0n_25od33=0
parameters dcitn_25od33=0
parameters dlcitn_25od33=0
parameters dwcitn_25od33=0
parameters dpcitn_25od33=0
parameters dk2n_25od33=0
parameters dlk2n_25od33=0
parameters dwk2n_25od33=0
parameters dpk2n_25od33=0
parameters cfn_25od33=9e-11 + 2.4e-11 * ccoflag_25od33
parameters dk2_25od33=0
parameters dxlp_25od33=0
parameters dxwp_25od33=0
parameters toxp_25od33=5.9e-09
parameters cjp_25od33=0.00112
parameters cjswp_25od33=9e-11
parameters cjswgp_25od33=1.7e-10
parameters dlcp_25od33=5.49049e-08
parameters cgop_25od33=5.23324e-11
parameters cglp_25od33=2.68907e-10
parameters dvthp_25od33=0
parameters dlvthp_25od33=0
parameters dwvthp_25od33=0
parameters dpvthp_25od33=0
parameters du0p_25od33=0
parameters dlu0p_25od33=0
parameters dwu0p_25od33=0
parameters dpu0p_25od33=0
parameters dnfactorp_25od33=0
parameters dlnfactorp_25od33=0
parameters dwnfactorp_25od33=0
parameters dpnfactorp_25od33=0
parameters dcitp_25od33=0
parameters dlcitp_25od33=0
parameters dwcitp_25od33=0
parameters dpcitp_25od33=0
parameters dvsatp_25od33=0
parameters dlvsatp_25od33=0
parameters dwvsatp_25od33=0
parameters dpvsatp_25od33=0
parameters dleta0p_25od33=0
parameters dpeta0p_25od33=0
parameters dla0p_25od33=0
parameters dwa0p_25od33=0
parameters dpa0p_25od33=0
parameters dlk2_25od33=0
parameters dwk2_25od33=0
parameters dpk2_25od33=0
parameters cfp_25od33=9e-11 + 2.4e-11 * ccoflag_25od33
parameters b1fn_25od33=-7.25E+40
parameters b2fn_25od33=4.75E+22 
parameters b3fn_25od33=-1.925E+8   
parameters a1fn_25od33=8.975E+41 
parameters a2fn_25od33=4.75E+22  
parameters a3fn_25od33=4.825e+8  
parameters c1fn_25od33=2.05E+41  
parameters c2fn_25od33=4E+10    
parameters c3fn_25od33=5.35e+8 
parameters b1fp_25od33=-3.55E+41   
parameters b2fp_25od33=0    
parameters b3fp_25od33=-2.225E+9    
parameters a1fp_25od33=1.573E+42    
parameters a2fp_25od33=0  
parameters a3fp_25od33=4.825E+9 
parameters c1fp_25od33=8.05E+41     
parameters c2fp_25od33=4E+10  
parameters c3fp_25od33=5.35E+9  
parameters noian_25od33=a1fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b1fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c1fn_25od33
parameters noibn_25od33=a2fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b2fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c2fn_25od33
parameters noicn_25od33=a3fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b3fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c3fn_25od33
parameters noiap_25od33=a1fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b1fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c1fp_25od33
parameters noibp_25od33=a2fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b2fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c2fp_25od33
parameters noicp_25od33=a3fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b3fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c3fp_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25od33
endsection tt_25od33
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25od33
parameters parn1_25od33=0
parameters parn2_25od33=0
parameters parp1_25od33=0
parameters parp2_25od33=0
parameters toxn_25od33=5.9e-09
parameters dxln_25od33=1e-08
parameters dxwn_25od33=-1.2e-08
parameters cjn_25od33=0.001125
parameters cjswn_25od33=1.45e-10
parameters cjswgn_25od33=1.734e-10
parameters dlcn_25od33=4.654e-08
parameters cgon_25od33=3.585e-11
parameters cgln_25od33=2.337e-10
parameters dvthn_25od33=0.038
parameters dlvthn_25od33=-2.5e-09
parameters dwvthn_25od33=5e-10
parameters dpvthn_25od33=3e-15
parameters du0n_25od33=0
parameters dlu0n_25od33=-3e-10
parameters dwu0n_25od33=-1.5e-10
parameters dpu0n_25od33=0
parameters dcitn_25od33=0.0001
parameters dlcitn_25od33=0
parameters dwcitn_25od33=-1e-10
parameters dpcitn_25od33=0
parameters dk2n_25od33=0
parameters dlk2n_25od33=0
parameters dwk2n_25od33=0
parameters dpk2n_25od33=0
parameters cfn_25od33=8.37e-11 + 2.4e-11 * ccoflag_25od33
parameters dk2_25od33=0
parameters dxlp_25od33=1e-08
parameters dxwp_25od33=-1.2e-08
parameters toxp_25od33=6.2e-09
parameters cjp_25od33=0.001198
parameters cjswp_25od33=9.63e-11
parameters cjswgp_25od33=1.819e-10
parameters dlcp_25od33=5.49049e-08
parameters cgop_25od33=4.8668e-11
parameters cglp_25od33=2.50083e-10
parameters dvthp_25od33=-0.015
parameters dlvthp_25od33=-6e-10
parameters dwvthp_25od33=-2.9e-09
parameters dpvthp_25od33=-2.2e-15
parameters du0p_25od33=0
parameters dlu0p_25od33=0
parameters dwu0p_25od33=1e-10
parameters dpu0p_25od33=-3.9e-16
parameters dnfactorp_25od33=0
parameters dlnfactorp_25od33=0
parameters dwnfactorp_25od33=0
parameters dpnfactorp_25od33=0
parameters dcitp_25od33=0
parameters dlcitp_25od33=-0e-11
parameters dwcitp_25od33=-1e-10
parameters dpcitp_25od33=-0e-17
parameters dvsatp_25od33=0
parameters dlvsatp_25od33=0
parameters dwvsatp_25od33=0
parameters dpvsatp_25od33=2.1e-09
parameters dleta0p_25od33=-3e-08
parameters dpeta0p_25od33=0
parameters dla0p_25od33=0
parameters dwa0p_25od33=0
parameters dpa0p_25od33=2e-14
parameters dlk2_25od33=0
parameters dwk2_25od33=0
parameters dpk2_25od33=3e-15
parameters cfp_25od33=8.37e-11 + 2.4e-11 * ccoflag_25od33
parameters b1fn_25od33=-7.25E+40
parameters b2fn_25od33=4.75E+22 
parameters b3fn_25od33=-1.925E+8   
parameters a1fn_25od33=8.975E+41 
parameters a2fn_25od33=4.75E+22  
parameters a3fn_25od33=4.825e+8  
parameters c1fn_25od33=2.05E+41  
parameters c2fn_25od33=4E+10    
parameters c3fn_25od33=5.35e+8 
parameters b1fp_25od33=-3.55E+41   
parameters b2fp_25od33=0    
parameters b3fp_25od33=-2.225E+9    
parameters a1fp_25od33=1.573E+42    
parameters a2fp_25od33=0  
parameters a3fp_25od33=4.825E+9 
parameters c1fp_25od33=8.05E+41     
parameters c2fp_25od33=4E+10  
parameters c3fp_25od33=5.35E+9  
parameters noian_25od33=a1fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b1fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c1fn_25od33
parameters noibn_25od33=a2fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b2fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c2fn_25od33
parameters noicn_25od33=a3fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b3fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c3fn_25od33
parameters noiap_25od33=a1fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b1fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c1fp_25od33
parameters noibp_25od33=a2fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b2fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c2fp_25od33
parameters noicp_25od33=a3fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b3fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c3fp_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25od33
endsection ss_25od33
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25od33
parameters parn1_25od33=0
parameters parn2_25od33=0
parameters parp1_25od33=0
parameters parp2_25od33=0
parameters toxn_25od33=5.3e-09
parameters dxln_25od33=-1e-08
parameters dxwn_25od33=1.2e-08
parameters cjn_25od33=0.0009774
parameters cjswn_25od33=1.26e-10
parameters cjswgn_25od33=1.508e-10
parameters dlcn_25od33=4.654e-08
parameters cgon_25od33=4.125e-11
parameters cgln_25od33=2.689e-10
parameters dvthn_25od33=-0.038
parameters dlvthn_25od33=2.5e-09
parameters dwvthn_25od33=-5e-10
parameters dpvthn_25od33=-3.2e-15
parameters du0n_25od33=0
parameters dlu0n_25od33=3e-10
parameters dwu0n_25od33=1e-10
parameters dpu0n_25od33=-1e-16
parameters dcitn_25od33=-0.0001
parameters dlcitn_25od33=0
parameters dwcitn_25od33=1e-10
parameters dpcitn_25od33=0
parameters dk2n_25od33=0
parameters dlk2n_25od33=0
parameters dwk2n_25od33=0
parameters dpk2n_25od33=0
parameters cfn_25od33=9.63e-11 + 2.4e-11 * ccoflag_25od33
parameters dk2_25od33=0
parameters dxlp_25od33=-1e-08
parameters dxwp_25od33=1.2e-08
parameters toxp_25od33=5.6e-09
parameters cjp_25od33=0.001042
parameters cjswp_25od33=8.37e-11
parameters cjswgp_25od33=1.581e-10
parameters dlcp_25od33=5.49049e-08
parameters cgop_25od33=5.5995e-11
parameters cglp_25od33=2.87729e-10
parameters dvthp_25od33=0.01
parameters dlvthp_25od33=2.2e-09
parameters dwvthp_25od33=7.9e-09
parameters dpvthp_25od33=1.5e-15
parameters du0p_25od33=0
parameters dlu0p_25od33=1e-11
parameters dwu0p_25od33=-1e-10
parameters dpu0p_25od33=3e-16
parameters dnfactorp_25od33=0
parameters dlnfactorp_25od33=0
parameters dwnfactorp_25od33=0
parameters dpnfactorp_25od33=0
parameters dcitp_25od33=0
parameters dlcitp_25od33=0
parameters dwcitp_25od33=0
parameters dpcitp_25od33=0
parameters dvsatp_25od33=0
parameters dlvsatp_25od33=-0.001
parameters dwvsatp_25od33=0
parameters dpvsatp_25od33=-1.5e-09
parameters dleta0p_25od33=2e-08
parameters dpeta0p_25od33=0
parameters dla0p_25od33=0
parameters dwa0p_25od33=0
parameters dpa0p_25od33=0
parameters dlk2_25od33=0
parameters dwk2_25od33=0
parameters dpk2_25od33=-3e-15
parameters cfp_25od33=9.63e-11 + 2.4e-11 * ccoflag_25od33
parameters b1fn_25od33=-7.25E+40
parameters b2fn_25od33=4.75E+22 
parameters b3fn_25od33=-1.925E+8   
parameters a1fn_25od33=8.975E+41 
parameters a2fn_25od33=4.75E+22  
parameters a3fn_25od33=4.825e+8  
parameters c1fn_25od33=2.05E+41  
parameters c2fn_25od33=4E+10    
parameters c3fn_25od33=5.35e+8 
parameters b1fp_25od33=-3.55E+41   
parameters b2fp_25od33=0    
parameters b3fp_25od33=-2.225E+9    
parameters a1fp_25od33=1.573E+42    
parameters a2fp_25od33=0  
parameters a3fp_25od33=4.825E+9 
parameters c1fp_25od33=8.05E+41     
parameters c2fp_25od33=4E+10  
parameters c3fp_25od33=5.35E+9  
parameters noian_25od33=a1fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b1fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c1fn_25od33
parameters noibn_25od33=a2fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b2fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c2fn_25od33
parameters noicn_25od33=a3fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b3fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c3fn_25od33
parameters noiap_25od33=a1fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b1fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c1fp_25od33
parameters noibp_25od33=a2fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b2fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c2fp_25od33
parameters noicp_25od33=a3fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b3fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c3fp_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25od33
endsection ff_25od33
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25od33
parameters parn1_25od33=0
parameters parn2_25od33=0
parameters parp1_25od33=0
parameters parp2_25od33=0
parameters a1n_25od33=0.8
parameters a1p_25od33=-0.8
parameters a2n_25od33=0
parameters a2p_25od33=0
parameters a3n_25od33=-1
parameters a3p_25od33=1
parameters a4np_25od33=0
parameters toxn_25od33=5.6e-09 + 3.0000e-010 * a4np_25od33
parameters dxln_25od33=1e-008 * a2n_25od33
parameters dxwn_25od33=1.2e-008 * a3n_25od33
parameters cjn_25od33=0.001051 * (1 + 0.070 * a1n_25od33)
parameters cjswn_25od33=1.355e-10 * (1 + 0.070 * a1n_25od33)
parameters cjswgn_25od33=1.621e-10 * (1 + 0.070 * a1n_25od33)
parameters dlcn_25od33=4.654e-08
parameters cgon_25od33=3.855e-11 * (1 - 0.070 * a4np_25od33)
parameters cgln_25od33=2.513e-10 * (1 - 0.070 * a4np_25od33)
parameters dvthn_25od33=0.038 * a1n_25od33
parameters dlvthn_25od33= - 2.5e-009 * a1n_25od33
parameters dwvthn_25od33=5e-010 * a1n_25od33
parameters dpvthn_25od33=3.2e-015 * a1n_25od33
parameters du0n_25od33=0
parameters dlu0n_25od33= - 3e-010 * a1n_25od33
parameters dwu0n_25od33= - 1e-010 * a1n_25od33
parameters dpu0n_25od33=1e-016 * a1n_25od33
parameters dcitn_25od33=0.0001 * a1n_25od33
parameters dlcitn_25od33=0
parameters dwcitn_25od33= - 1e-010 * a1n_25od33
parameters dpcitn_25od33=0
parameters dk2n_25od33=0
parameters dlk2n_25od33=0
parameters dwk2n_25od33=0
parameters dpk2n_25od33=0
parameters cfn_25od33=9e-11 * (1 - 0.070 * a4np_25od33) + 2.4e-11 * ccoflag_25od33
parameters dk2_25od33=0
parameters dxlp_25od33=1e-008 * a2p_25od33
parameters dxwp_25od33=1.2e-008 * a3p_25od33
parameters toxp_25od33=5.9e-09 + 3.0000e-010 * a4np_25od33
parameters cjp_25od33=0.00112 * (1 + 0.070 * a1p_25od33)
parameters cjswp_25od33=9e-11 * (1 + 0.070 * a1p_25od33)
parameters cjswgp_25od33=1.7e-10 * (1 + 0.070 * a1p_25od33)
parameters dlcp_25od33=5.49049e-08
parameters cgop_25od33=5.23324e-11 * (1 - 0.070 * a4np_25od33)
parameters cglp_25od33=2.68907e-10 * (1 - 0.070 * a4np_25od33)
parameters dvthp_25od33= - 0.01 * a1p_25od33
parameters dlvthp_25od33= - 2.2e-009 * a1p_25od33
parameters dwvthp_25od33= - 7.9e-009 * a1p_25od33
parameters dpvthp_25od33= - 1.5e-015 * a1p_25od33
parameters du0p_25od33=0
parameters dlu0p_25od33= - 1e-011 * a1p_25od33
parameters dwu0p_25od33=1e-010 * a1p_25od33
parameters dpu0p_25od33= - 3e-016 * a1p_25od33
parameters dnfactorp_25od33=0
parameters dlnfactorp_25od33=0
parameters dwnfactorp_25od33=0
parameters dpnfactorp_25od33=0
parameters dcitp_25od33=0
parameters dlcitp_25od33=0
parameters dwcitp_25od33=0
parameters dpcitp_25od33=0
parameters dvsatp_25od33=0
parameters dlvsatp_25od33=0.001 * a1p_25od33
parameters dwvsatp_25od33=0
parameters dpvsatp_25od33=1.5e-009 * a1p_25od33
parameters dleta0p_25od33= - 2e-008 * a1p_25od33
parameters dpeta0p_25od33=0
parameters dla0p_25od33=0
parameters dwa0p_25od33=0
parameters dpa0p_25od33=0
parameters dlk2_25od33=0
parameters dwk2_25od33=0
parameters dpk2_25od33=3e-015 * a1p_25od33
parameters cfp_25od33=9e-11 * (1 - 0.070 * a4np_25od33) + 2.4e-11 * ccoflag_25od33
parameters b1fn_25od33=-7.25E+40
parameters b2fn_25od33=4.75E+22 
parameters b3fn_25od33=-1.925E+8   
parameters a1fn_25od33=8.975E+41 
parameters a2fn_25od33=4.75E+22  
parameters a3fn_25od33=4.825e+8  
parameters c1fn_25od33=2.05E+41  
parameters c2fn_25od33=4E+10    
parameters c3fn_25od33=5.35e+8 
parameters b1fp_25od33=-3.55E+41   
parameters b2fp_25od33=0    
parameters b3fp_25od33=-2.225E+9    
parameters a1fp_25od33=1.573E+42    
parameters a2fp_25od33=0  
parameters a3fp_25od33=4.825E+9 
parameters c1fp_25od33=8.05E+41     
parameters c2fp_25od33=4E+10  
parameters c3fp_25od33=5.35E+9  
parameters noian_25od33=a1fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b1fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c1fn_25od33
parameters noibn_25od33=a2fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b2fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c2fn_25od33
parameters noicn_25od33=a3fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b3fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c3fn_25od33
parameters noiap_25od33=a1fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b1fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c1fp_25od33
parameters noibp_25od33=a2fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b2fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c2fp_25od33
parameters noicp_25od33=a3fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b3fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c3fp_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25od33
endsection sf_25od33
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_25od33
parameters parn1_25od33=0
parameters parn2_25od33=0
parameters parp1_25od33=0
parameters parp2_25od33=0
parameters a1n_25od33=-0.8
parameters a1p_25od33=0.8
parameters a2n_25od33=0
parameters a2p_25od33=0
parameters a3n_25od33=1
parameters a3p_25od33=-1
parameters a4np_25od33=0
parameters toxn_25od33=5.6e-09 + 3.0000e-010 * a4np_25od33
parameters dxln_25od33=1e-008 * a2n_25od33
parameters dxwn_25od33=1.2e-008 * a3n_25od33
parameters cjn_25od33=0.001051 * (1 + 0.070 * a1n_25od33)
parameters cjswn_25od33=1.355e-10 * (1 + 0.070 * a1n_25od33)
parameters cjswgn_25od33=1.621e-10 * (1 + 0.070 * a1n_25od33)
parameters dlcn_25od33=4.654e-08
parameters cgon_25od33=3.855e-11 * (1 - 0.070 * a4np_25od33)
parameters cgln_25od33=2.513e-10 * (1 - 0.070 * a4np_25od33)
parameters dvthn_25od33=0.038 * a1n_25od33
parameters dlvthn_25od33= - 2.5e-009 * a1n_25od33
parameters dwvthn_25od33=5e-010 * a1n_25od33
parameters dpvthn_25od33=3.2e-015 * a1n_25od33
parameters du0n_25od33=0
parameters dlu0n_25od33= - 3e-010 * a1n_25od33
parameters dwu0n_25od33= - 1e-010 * a1n_25od33
parameters dpu0n_25od33=1e-016 * a1n_25od33
parameters dcitn_25od33=0.0001 * a1n_25od33
parameters dlcitn_25od33=0
parameters dwcitn_25od33= - 1e-010 * a1n_25od33
parameters dpcitn_25od33=0
parameters dk2n_25od33=0
parameters dlk2n_25od33=0
parameters dwk2n_25od33=0
parameters dpk2n_25od33=0
parameters cfn_25od33=9e-11 * (1 - 0.070 * a4np_25od33) + 2.4e-11 * ccoflag_25od33
parameters dk2_25od33=0
parameters dxlp_25od33=1e-008 * a2p_25od33
parameters dxwp_25od33=1.2e-008 * a3p_25od33
parameters toxp_25od33=5.9e-09 + 3.0000e-010 * a4np_25od33
parameters cjp_25od33=0.00112 * (1 + 0.070 * a1p_25od33)
parameters cjswp_25od33=9e-11 * (1 + 0.070 * a1p_25od33)
parameters cjswgp_25od33=1.7e-10 * (1 + 0.070 * a1p_25od33)
parameters dlcp_25od33=5.49049e-08
parameters cgop_25od33=5.23324e-11 * (1 - 0.070 * a4np_25od33)
parameters cglp_25od33=2.68907e-10 * (1 - 0.070 * a4np_25od33)
parameters dvthp_25od33= - 0.01 * a1p_25od33
parameters dlvthp_25od33= - 2.2e-009 * a1p_25od33
parameters dwvthp_25od33= - 7.9e-009 * a1p_25od33
parameters dpvthp_25od33= - 1.5e-015 * a1p_25od33
parameters du0p_25od33=0
parameters dlu0p_25od33= - 1e-011 * a1p_25od33
parameters dwu0p_25od33=1e-010 * a1p_25od33
parameters dpu0p_25od33= - 3e-016 * a1p_25od33
parameters dnfactorp_25od33=0
parameters dlnfactorp_25od33=0
parameters dwnfactorp_25od33=0
parameters dpnfactorp_25od33=0
parameters dcitp_25od33=0
parameters dlcitp_25od33=0
parameters dwcitp_25od33=0
parameters dpcitp_25od33=0
parameters dvsatp_25od33=0
parameters dlvsatp_25od33=0.001 * a1p_25od33
parameters dwvsatp_25od33=0
parameters dpvsatp_25od33=1.5e-009 * a1p_25od33
parameters dleta0p_25od33= - 2e-008 * a1p_25od33
parameters dpeta0p_25od33=0
parameters dla0p_25od33=0
parameters dwa0p_25od33=0
parameters dpa0p_25od33=0
parameters dlk2_25od33=0
parameters dwk2_25od33=0
parameters dpk2_25od33=3e-015 * a1p_25od33
parameters cfp_25od33=9e-11 * (1 - 0.070 * a4np_25od33) + 2.4e-11 * ccoflag_25od33
parameters b1fn_25od33=-7.25E+40
parameters b2fn_25od33=4.75E+22 
parameters b3fn_25od33=-1.925E+8   
parameters a1fn_25od33=8.975E+41 
parameters a2fn_25od33=4.75E+22  
parameters a3fn_25od33=4.825e+8  
parameters c1fn_25od33=2.05E+41  
parameters c2fn_25od33=4E+10    
parameters c3fn_25od33=5.35e+8 
parameters b1fp_25od33=-3.55E+41   
parameters b2fp_25od33=0    
parameters b3fp_25od33=-2.225E+9    
parameters a1fp_25od33=1.573E+42    
parameters a2fp_25od33=0  
parameters a3fp_25od33=4.825E+9 
parameters c1fp_25od33=8.05E+41     
parameters c2fp_25od33=4E+10  
parameters c3fp_25od33=5.35E+9  
parameters noian_25od33=a1fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b1fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c1fn_25od33
parameters noibn_25od33=a2fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b2fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c2fn_25od33
parameters noicn_25od33=a3fn_25od33 * (abs(noiseflagn_25od33) + noiseflagn_25od33) 
+ + b3fn_25od33 * (abs(noiseflagn_25od33) - noiseflagn_25od33) + c3fn_25od33
parameters noiap_25od33=a1fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b1fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c1fp_25od33
parameters noibp_25od33=a2fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b2fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c2fp_25od33
parameters noicp_25od33=a3fp_25od33 * (abs(noiseflagp_25od33) + noiseflagp_25od33) 
+ + b3fp_25od33 * (abs(noiseflagp_25od33) - noiseflagp_25od33) + c3fp_25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_25od33
endsection fs_25od33
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_33
parameters parn1_33=0
parameters parn2_33=0
parameters parp1_33=0
parameters parp2_33=0
parameters toxn_33=5.6e-09
parameters dxln_33=0
parameters dxwn_33=0
parameters cjn_33=0.001051
parameters cjswn_33=1.355e-10
parameters cjswgn_33=1.621e-10
parameters dlcn_33=4.654e-08
parameters cgon_33=3.855e-11
parameters cgln_33=2.513e-10
parameters dvthn_33=0
parameters dlvthn_33=0
parameters dwvthn_33=0
parameters dpvthn_33=0
parameters du0n_33=0
parameters dlu0n_33=0
parameters dwu0n_33=0
parameters dpu0n_33=0
parameters dcitn_33=0
parameters dlcitn_33=0
parameters dwcitn_33=0
parameters dpcitn_33=0
parameters dk2n_33=0
parameters dlk2n_33=0
parameters dwk2n_33=0
parameters dpk2n_33=0
parameters cfn_33=9e-11 + 2.4e-11 * ccoflag_33
parameters dk2_33=0
parameters dxlp_33=0
parameters dxwp_33=0
parameters toxp_33=5.9e-09
parameters cjp_33=0.00112
parameters cjswp_33=9e-11
parameters cjswgp_33=1.7e-10
parameters dlcp_33=5.49049e-08
parameters cgop_33=5.23324e-11
parameters cglp_33=2.68907e-10
parameters dvthp_33=0
parameters dlvthp_33=0
parameters dwvthp_33=0
parameters dpvthp_33=0
parameters du0p_33=0
parameters dlu0p_33=0
parameters dwu0p_33=0
parameters dpu0p_33=0
parameters dnfactorp_33=0
parameters dlnfactorp_33=0
parameters dwnfactorp_33=0
parameters dpnfactorp_33=0
parameters dcitp_33=0
parameters dlcitp_33=0
parameters dwcitp_33=0
parameters dpcitp_33=0
parameters dvsatp_33=0
parameters dlvsatp_33=0
parameters dwvsatp_33=0
parameters dpvsatp_33=0
parameters dleta0p_33=0
parameters dpeta0p_33=0
parameters dla0p_33=0
parameters dwa0p_33=0
parameters dpa0p_33=0
parameters dlk2_33=0
parameters dwk2_33=0
parameters dpk2_33=0
parameters cfp_33=9e-11 + 2.4e-11 * ccoflag_33
parameters b1fn_33=-7.25E+40
parameters b2fn_33=4.75E+22 
parameters b3fn_33=-1.925E+8   
parameters a1fn_33=8.975E+41 
parameters a2fn_33=4.75E+22  
parameters a3fn_33=4.825e+8  
parameters c1fn_33=2.05E+41  
parameters c2fn_33=4E+10    
parameters c3fn_33=5.35e+8 
parameters b1fp_33=-3.55E+41   
parameters b2fp_33=0    
parameters b3fp_33=-2.225E+9    
parameters a1fp_33=1.573E+42    
parameters a2fp_33=0  
parameters a3fp_33=4.825E+9 
parameters c1fp_33=8.05E+41     
parameters c2fp_33=4E+10  
parameters c3fp_33=5.35E+9   
parameters noian_33=a1fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b1fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c1fn_33
parameters noibn_33=a2fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b2fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c2fn_33
parameters noicn_33=a3fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b3fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c3fn_33
parameters noiap_33=a1fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b1fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c1fp_33
parameters noibp_33=a2fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b2fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c2fp_33
parameters noicp_33=a3fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b3fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c3fp_33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_33
endsection tt_33
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_33
parameters parn1_33=0
parameters parn2_33=0
parameters parp1_33=0
parameters parp2_33=0
parameters toxn_33=5.9e-09
parameters dxln_33=1e-08
parameters dxwn_33=-1.2e-08
parameters cjn_33=0.001125
parameters cjswn_33=1.45e-10
parameters cjswgn_33=1.734e-10
parameters dlcn_33=4.654e-08
parameters cgon_33=3.585e-11
parameters cgln_33=2.337e-10
parameters dvthn_33=0.038
parameters dlvthn_33=-2.5e-09
parameters dwvthn_33=5e-10
parameters dpvthn_33=3e-15
parameters du0n_33=0
parameters dlu0n_33=-3e-10
parameters dwu0n_33=-1.5e-10
parameters dpu0n_33=0
parameters dcitn_33=0.0001
parameters dlcitn_33=0
parameters dwcitn_33=-1e-10
parameters dpcitn_33=0
parameters dk2n_33=0
parameters dlk2n_33=0
parameters dwk2n_33=0
parameters dpk2n_33=0
parameters cfn_33=8.37e-11 + 2.4e-11 * ccoflag_33
parameters dk2_33=0
parameters dxlp_33=1e-08
parameters dxwp_33=-1.2e-08
parameters toxp_33=6.2e-09
parameters cjp_33=0.001198
parameters cjswp_33=9.63e-11
parameters cjswgp_33=1.819e-10
parameters dlcp_33=5.49049e-08
parameters cgop_33=4.8668e-11
parameters cglp_33=2.50083e-10
parameters dvthp_33=-0.015
parameters dlvthp_33=-6e-10
parameters dwvthp_33=-2.9e-09
parameters dpvthp_33=-2.2e-15
parameters du0p_33=0
parameters dlu0p_33=0
parameters dwu0p_33=1e-10
parameters dpu0p_33=-3.9e-16
parameters dnfactorp_33=0
parameters dlnfactorp_33=0
parameters dwnfactorp_33=0
parameters dpnfactorp_33=0
parameters dcitp_33=0
parameters dlcitp_33=-0e-11
parameters dwcitp_33=-1e-10
parameters dpcitp_33=-0e-17
parameters dvsatp_33=0
parameters dlvsatp_33=0
parameters dwvsatp_33=0
parameters dpvsatp_33=2.1e-09
parameters dleta0p_33=-3e-08
parameters dpeta0p_33=0
parameters dla0p_33=0
parameters dwa0p_33=0
parameters dpa0p_33=2e-14
parameters dlk2_33=0
parameters dwk2_33=0
parameters dpk2_33=3e-15
parameters cfp_33=8.37e-11 + 2.4e-11 * ccoflag_33
parameters b1fn_33=-7.25E+40
parameters b2fn_33=4.75E+22 
parameters b3fn_33=-1.925E+8   
parameters a1fn_33=8.975E+41 
parameters a2fn_33=4.75E+22  
parameters a3fn_33=4.825e+8  
parameters c1fn_33=2.05E+41  
parameters c2fn_33=4E+10    
parameters c3fn_33=5.35e+8 
parameters b1fp_33=-3.55E+41   
parameters b2fp_33=0    
parameters b3fp_33=-2.225E+9    
parameters a1fp_33=1.573E+42    
parameters a2fp_33=0  
parameters a3fp_33=4.825E+9 
parameters c1fp_33=8.05E+41     
parameters c2fp_33=4E+10  
parameters c3fp_33=5.35E+9  
parameters noian_33=a1fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b1fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c1fn_33
parameters noibn_33=a2fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b2fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c2fn_33
parameters noicn_33=a3fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b3fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c3fn_33
parameters noiap_33=a1fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b1fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c1fp_33
parameters noibp_33=a2fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b2fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c2fp_33
parameters noicp_33=a3fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b3fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c3fp_33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_33
endsection ss_33
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_33
parameters parn1_33=0
parameters parn2_33=0
parameters parp1_33=0
parameters parp2_33=0
parameters toxn_33=5.3e-09
parameters dxln_33=-1e-08
parameters dxwn_33=1.2e-08
parameters cjn_33=0.0009774
parameters cjswn_33=1.26e-10
parameters cjswgn_33=1.508e-10
parameters dlcn_33=4.654e-08
parameters cgon_33=4.125e-11
parameters cgln_33=2.689e-10
parameters dvthn_33=-0.038
parameters dlvthn_33=2.5e-09
parameters dwvthn_33=-5e-10
parameters dpvthn_33=-3.2e-15
parameters du0n_33=0
parameters dlu0n_33=3e-10
parameters dwu0n_33=1e-10
parameters dpu0n_33=-1e-16
parameters dcitn_33=-0.0001
parameters dlcitn_33=0
parameters dwcitn_33=1e-10
parameters dpcitn_33=0
parameters dk2n_33=0
parameters dlk2n_33=0
parameters dwk2n_33=0
parameters dpk2n_33=0
parameters cfn_33=9.63e-11 + 2.4e-11 * ccoflag_33
parameters dk2_33=0
parameters dxlp_33=-1e-08
parameters dxwp_33=1.2e-08
parameters toxp_33=5.6e-09
parameters cjp_33=0.001042
parameters cjswp_33=8.37e-11
parameters cjswgp_33=1.581e-10
parameters dlcp_33=5.49049e-08
parameters cgop_33=5.5995e-11
parameters cglp_33=2.87729e-10
parameters dvthp_33=0.01
parameters dlvthp_33=2.2e-09
parameters dwvthp_33=7.9e-09
parameters dpvthp_33=1.5e-15
parameters du0p_33=0
parameters dlu0p_33=1e-11
parameters dwu0p_33=-1e-10
parameters dpu0p_33=3e-16
parameters dnfactorp_33=0
parameters dlnfactorp_33=0
parameters dwnfactorp_33=0
parameters dpnfactorp_33=0
parameters dcitp_33=0
parameters dlcitp_33=0
parameters dwcitp_33=0
parameters dpcitp_33=0
parameters dvsatp_33=0
parameters dlvsatp_33=-0.001
parameters dwvsatp_33=0
parameters dpvsatp_33=-1.5e-09
parameters dleta0p_33=2e-08
parameters dpeta0p_33=0
parameters dla0p_33=0
parameters dwa0p_33=0
parameters dpa0p_33=0
parameters dlk2_33=0
parameters dwk2_33=0
parameters dpk2_33=-3e-15
parameters cfp_33=9.63e-11 + 2.4e-11 * ccoflag_33
parameters b1fn_33=-7.25E+40
parameters b2fn_33=4.75E+22 
parameters b3fn_33=-1.925E+8   
parameters a1fn_33=8.975E+41 
parameters a2fn_33=4.75E+22  
parameters a3fn_33=4.825e+8  
parameters c1fn_33=2.05E+41  
parameters c2fn_33=4E+10    
parameters c3fn_33=5.35e+8 
parameters b1fp_33=-3.55E+41   
parameters b2fp_33=0    
parameters b3fp_33=-2.225E+9    
parameters a1fp_33=1.573E+42    
parameters a2fp_33=0  
parameters a3fp_33=4.825E+9 
parameters c1fp_33=8.05E+41     
parameters c2fp_33=4E+10  
parameters c3fp_33=5.35E+9   
parameters noian_33=a1fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b1fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c1fn_33
parameters noibn_33=a2fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b2fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c2fn_33
parameters noicn_33=a3fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b3fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c3fn_33
parameters noiap_33=a1fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b1fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c1fp_33
parameters noibp_33=a2fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b2fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c2fp_33
parameters noicp_33=a3fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b3fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c3fp_33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_33
endsection ff_33
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_33
parameters parn1_33=0
parameters parn2_33=0
parameters parp1_33=0
parameters parp2_33=0
parameters a1n_33=0.8
parameters a1p_33=-0.8
parameters a2n_33=0
parameters a2p_33=0
parameters a3n_33=-1
parameters a3p_33=1
parameters a4np_33=0
parameters toxn_33=5.6e-09 + 3.0000e-010 * a4np_33
parameters dxln_33=1e-008 * a2n_33
parameters dxwn_33=1.2e-008 * a3n_33
parameters cjn_33=0.001051 * (1 + 0.070 * a1n_33)
parameters cjswn_33=1.355e-10 * (1 + 0.070 * a1n_33)
parameters cjswgn_33=1.621e-10 * (1 + 0.070 * a1n_33)
parameters dlcn_33=4.654e-08
parameters cgon_33=3.855e-11 * (1 - 0.070 * a4np_33)
parameters cgln_33=2.513e-10 * (1 - 0.070 * a4np_33)
parameters dvthn_33=0.038 * a1n_33
parameters dlvthn_33= - 2.5e-009 * a1n_33
parameters dwvthn_33=5e-010 * a1n_33
parameters dpvthn_33=3.2e-015 * a1n_33
parameters du0n_33=0
parameters dlu0n_33= - 3e-010 * a1n_33
parameters dwu0n_33= - 1e-010 * a1n_33
parameters dpu0n_33=1e-016 * a1n_33
parameters dcitn_33=0.0001 * a1n_33
parameters dlcitn_33=0
parameters dwcitn_33= - 1e-010 * a1n_33
parameters dpcitn_33=0
parameters dk2n_33=0
parameters dlk2n_33=0
parameters dwk2n_33=0
parameters dpk2n_33=0
parameters cfn_33=9e-11 * (1 - 0.070 * a4np_33) + 2.4e-11 * ccoflag_33
parameters dk2_33=0
parameters dxlp_33=1e-008 * a2p_33
parameters dxwp_33=1.2e-008 * a3p_33
parameters toxp_33=5.9e-09 + 3.0000e-010 * a4np_33
parameters cjp_33=0.00112 * (1 + 0.070 * a1p_33)
parameters cjswp_33=9e-11 * (1 + 0.070 * a1p_33)
parameters cjswgp_33=1.7e-10 * (1 + 0.070 * a1p_33)
parameters dlcp_33=5.49049e-08
parameters cgop_33=5.23324e-11 * (1 - 0.070 * a4np_33)
parameters cglp_33=2.68907e-10 * (1 - 0.070 * a4np_33)
parameters dvthp_33= - 0.01 * a1p_33
parameters dlvthp_33= - 2.2e-009 * a1p_33
parameters dwvthp_33= - 7.9e-009 * a1p_33
parameters dpvthp_33= - 1.5e-015 * a1p_33
parameters du0p_33=0
parameters dlu0p_33= - 1e-011 * a1p_33
parameters dwu0p_33=1e-010 * a1p_33
parameters dpu0p_33= - 3e-016 * a1p_33
parameters dnfactorp_33=0
parameters dlnfactorp_33=0
parameters dwnfactorp_33=0
parameters dpnfactorp_33=0
parameters dcitp_33=0
parameters dlcitp_33=0
parameters dwcitp_33=0
parameters dpcitp_33=0
parameters dvsatp_33=0
parameters dlvsatp_33=0.001 * a1p_33
parameters dwvsatp_33=0
parameters dpvsatp_33=1.5e-009 * a1p_33
parameters dleta0p_33= - 2e-008 * a1p_33
parameters dpeta0p_33=0
parameters dla0p_33=0
parameters dwa0p_33=0
parameters dpa0p_33=0
parameters dlk2_33=0
parameters dwk2_33=0
parameters dpk2_33=3e-015 * a1p_33
parameters cfp_33=9e-11 * (1 - 0.070 * a4np_33) + 2.4e-11 * ccoflag_33
parameters b1fn_33=-7.25E+40
parameters b2fn_33=4.75E+22 
parameters b3fn_33=-1.925E+8   
parameters a1fn_33=8.975E+41 
parameters a2fn_33=4.75E+22  
parameters a3fn_33=4.825e+8  
parameters c1fn_33=2.05E+41  
parameters c2fn_33=4E+10    
parameters c3fn_33=5.35e+8 
parameters b1fp_33=-3.55E+41   
parameters b2fp_33=0    
parameters b3fp_33=-2.225E+9    
parameters a1fp_33=1.573E+42    
parameters a2fp_33=0  
parameters a3fp_33=4.825E+9 
parameters c1fp_33=8.05E+41     
parameters c2fp_33=4E+10  
parameters c3fp_33=5.35E+9  
parameters noian_33=a1fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b1fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c1fn_33
parameters noibn_33=a2fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b2fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c2fn_33
parameters noicn_33=a3fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b3fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c3fn_33
parameters noiap_33=a1fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b1fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c1fp_33
parameters noibp_33=a2fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b2fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c2fp_33
parameters noicp_33=a3fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b3fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c3fp_33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_33
endsection sf_33
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_33
parameters parn1_33=0
parameters parn2_33=0
parameters parp1_33=0
parameters parp2_33=0
parameters a1n_33=-0.8
parameters a1p_33=0.8
parameters a2n_33=0
parameters a2p_33=0
parameters a3n_33=1
parameters a3p_33=-1
parameters a4np_33=0
parameters toxn_33=5.6e-09 + 3.0000e-010 * a4np_33
parameters dxln_33=1e-008 * a2n_33
parameters dxwn_33=1.2e-008 * a3n_33
parameters cjn_33=0.001051 * (1 + 0.070 * a1n_33)
parameters cjswn_33=1.355e-10 * (1 + 0.070 * a1n_33)
parameters cjswgn_33=1.621e-10 * (1 + 0.070 * a1n_33)
parameters dlcn_33=4.654e-08
parameters cgon_33=3.855e-11 * (1 - 0.070 * a4np_33)
parameters cgln_33=2.513e-10 * (1 - 0.070 * a4np_33)
parameters dvthn_33=0.038 * a1n_33
parameters dlvthn_33= - 2.5e-009 * a1n_33
parameters dwvthn_33=5e-010 * a1n_33
parameters dpvthn_33=3.2e-015 * a1n_33
parameters du0n_33=0
parameters dlu0n_33= - 3e-010 * a1n_33
parameters dwu0n_33= - 1e-010 * a1n_33
parameters dpu0n_33=1e-016 * a1n_33
parameters dcitn_33=0.0001 * a1n_33
parameters dlcitn_33=0
parameters dwcitn_33= - 1e-010 * a1n_33
parameters dpcitn_33=0
parameters dk2n_33=0
parameters dlk2n_33=0
parameters dwk2n_33=0
parameters dpk2n_33=0
parameters cfn_33=9e-11 * (1 - 0.070 * a4np_33) + 2.4e-11 * ccoflag_33
parameters dk2_33=0
parameters dxlp_33=1e-008 * a2p_33
parameters dxwp_33=1.2e-008 * a3p_33
parameters toxp_33=5.9e-09 + 3.0000e-010 * a4np_33
parameters cjp_33=0.00112 * (1 + 0.070 * a1p_33)
parameters cjswp_33=9e-11 * (1 + 0.070 * a1p_33)
parameters cjswgp_33=1.7e-10 * (1 + 0.070 * a1p_33)
parameters dlcp_33=5.49049e-08
parameters cgop_33=5.23324e-11 * (1 - 0.070 * a4np_33)
parameters cglp_33=2.68907e-10 * (1 - 0.070 * a4np_33)
parameters dvthp_33= - 0.01 * a1p_33
parameters dlvthp_33= - 2.2e-009 * a1p_33
parameters dwvthp_33= - 7.9e-009 * a1p_33
parameters dpvthp_33= - 1.5e-015 * a1p_33
parameters du0p_33=0
parameters dlu0p_33= - 1e-011 * a1p_33
parameters dwu0p_33=1e-010 * a1p_33
parameters dpu0p_33= - 3e-016 * a1p_33
parameters dnfactorp_33=0
parameters dlnfactorp_33=0
parameters dwnfactorp_33=0
parameters dpnfactorp_33=0
parameters dcitp_33=0
parameters dlcitp_33=0
parameters dwcitp_33=0
parameters dpcitp_33=0
parameters dvsatp_33=0
parameters dlvsatp_33=0.001 * a1p_33
parameters dwvsatp_33=0
parameters dpvsatp_33=1.5e-009 * a1p_33
parameters dleta0p_33= - 2e-008 * a1p_33
parameters dpeta0p_33=0
parameters dla0p_33=0
parameters dwa0p_33=0
parameters dpa0p_33=0
parameters dlk2_33=0
parameters dwk2_33=0
parameters dpk2_33=3e-015 * a1p_33
parameters cfp_33=9e-11 * (1 - 0.070 * a4np_33) + 2.4e-11 * ccoflag_33
parameters b1fn_33=-7.25E+40
parameters b2fn_33=4.75E+22 
parameters b3fn_33=-1.925E+8   
parameters a1fn_33=8.975E+41 
parameters a2fn_33=4.75E+22  
parameters a3fn_33=4.825e+8  
parameters c1fn_33=2.05E+41  
parameters c2fn_33=4E+10    
parameters c3fn_33=5.35e+8 
parameters b1fp_33=-3.55E+41   
parameters b2fp_33=0    
parameters b3fp_33=-2.225E+9    
parameters a1fp_33=1.573E+42    
parameters a2fp_33=0  
parameters a3fp_33=4.825E+9 
parameters c1fp_33=8.05E+41     
parameters c2fp_33=4E+10  
parameters c3fp_33=5.35E+9   
parameters noian_33=a1fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b1fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c1fn_33
parameters noibn_33=a2fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b2fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c2fn_33
parameters noicn_33=a3fn_33 * (abs(noiseflagn_33) + noiseflagn_33) + b3fn_33 * (abs(noiseflagn_33) 
+ - noiseflagn_33) + c3fn_33
parameters noiap_33=a1fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b1fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c1fp_33
parameters noibp_33=a2fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b2fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c2fp_33
parameters noicp_33=a3fp_33 * (abs(noiseflagp_33) + noiseflagp_33) + b3fp_33 * (abs(noiseflagp_33) 
+ - noiseflagp_33) + c3fp_33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_33
endsection fs_33
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_na
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na
parameters parn1_na=0
parameters parn2_na=0
parameters toxn_na=2e-09
parameters dxln_na=0
parameters dxwn_na=0
parameters dvthn_na=0
parameters dlvthn_na=0
parameters dwvthn_na=0
parameters dpvthn_na=0
parameters cjn_na=0.000162
parameters cjswn_na=1.27e-10
parameters cjswgn_na=2.95e-10
parameters cgon_na=1.423060e-10
parameters cgln_na=4.913760e-12
parameters ddlcn_na=5.107660e-09
parameters cfn_na=1.39e-10 + 4.1e-11 * ccoflag_na
parameters dnfactorn_na=0
parameters dlnfactorn_na=0
parameters dwnfactorn_na=0
parameters dpnfactorn_na=0
parameters du0n_na=0
parameters dlu0n_na=0
parameters dwu0n_na=0
parameters dpu0n_na=0
parameters deta0n_na=0
parameters dleta0n_na=0
parameters dweta0n_na=0
parameters dpeta0n_na=0
parameters drdswn_na=0
parameters dcdscdn_na=0
parameters dk2n_na=0
parameters dlk2n_na=0
parameters dwk2n_na=0
parameters dpk2n_na=0
parameters dcitn_na=0
parameters dlcitn_na=0
parameters dwcitn_na=0
parameters dpcitn_na=0
parameters ntoxn_na=1
parameters dagsn_na=0
parameters dlagsn_na=0
parameters dwagsn_na=0
parameters dpagsn_na=0
parameters dla0_na=0
parameters dvsat_na=0
parameters dlvsat_na=0
parameters dwvsat_na=0
parameters dpvsat_na=0
parameters b1fn_na=-5.625e+41   
parameters b2fn_na=-6.75e+13
parameters b3fn_na=-1.125e+7 
parameters a1fn_na=4.413e+42   
parameters a2fn_na=0   
parameters a3fn_na=-1.175e+7 
parameters c1fn_na=1.175e+42  
parameters c2fn_na=1.5e+14  
parameters c3fn_na=2.35e+7   
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na
endsection tt_na
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_na
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na
parameters parn1_na=0
parameters parn2_na=0
parameters toxn_na=2.06e-09
parameters dxln_na=5e-09
parameters dxwn_na=-8e-09
parameters dvthn_na=0.031
parameters dlvthn_na=3.85e-09
parameters dwvthn_na=1.3e-09
parameters dpvthn_na=0
parameters cjn_na=1.73340e-04
parameters cjswn_na=1.35890e-10
parameters cjswgn_na=3.15650e-10
parameters cgon_na=1.32345e-10
parameters cgln_na=4.56980e-12
parameters ddlcn_na=5.10766e-09
parameters cfn_na=1.293e-10 + 4.1e-11 * ccoflag_na
parameters dnfactorn_na=0
parameters dlnfactorn_na=0
parameters dwnfactorn_na=0
parameters dpnfactorn_na=0
parameters du0n_na=-0.001
parameters dlu0n_na=8.2e-10
parameters dwu0n_na=-4e-10
parameters dpu0n_na=10e-17
parameters deta0n_na=0
parameters dleta0n_na=0
parameters dweta0n_na=0
parameters dpeta0n_na=0
parameters drdswn_na=2.0
parameters dcdscdn_na=0
parameters dk2n_na=0.005
parameters dlk2n_na=0
parameters dwk2n_na=0
parameters dpk2n_na=0
parameters dcitn_na=6e-4
parameters dlcitn_na=0
parameters dwcitn_na=0
parameters dpcitn_na=0
parameters ntoxn_na=0.91
parameters dagsn_na=0
parameters dlagsn_na=0.8e-07
parameters dwagsn_na=0
parameters dpagsn_na=0
parameters dla0_na=0
parameters dvsat_na=0
parameters dlvsat_na=0
parameters dwvsat_na=0
parameters dpvsat_na=0
parameters b1fn_na=-5.625e+41   
parameters b2fn_na=-6.75e+13
parameters b3fn_na=-1.125e+7 
parameters a1fn_na=4.413e+42   
parameters a2fn_na=0   
parameters a3fn_na=-1.175e+7 
parameters c1fn_na=1.175e+42  
parameters c2fn_na=1.5e+14  
parameters c3fn_na=2.35e+7    
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na
endsection ss_na
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_na
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na
parameters parn1_na=0
parameters parn2_na=0
parameters toxn_na=1.94e-09
parameters dxln_na=-5e-09
parameters dxwn_na=8e-09
parameters dvthn_na=-0.030
parameters dlvthn_na=-3.5e-09
parameters dwvthn_na=-2.3e-09
parameters dpvthn_na=0
parameters cjn_na=1.50660e-04
parameters cjswn_na=1.18110e-10
parameters cjswgn_na=2.74350e-10
parameters cgon_na=1.52267e-10
parameters cgln_na=5.25772e-12
parameters ddlcn_na=5.10766e-09
parameters cfn_na=1.487e-10 + 4.1e-11 * ccoflag_na
parameters dnfactorn_na=0
parameters dlnfactorn_na=0
parameters dwnfactorn_na=0
parameters dpnfactorn_na=0
parameters du0n_na=0.001
parameters dlu0n_na=-6.0e-10
parameters dwu0n_na=-8e-11
parameters dpu0n_na=2.4e-17
parameters deta0n_na=0
parameters dleta0n_na=0
parameters dweta0n_na=0
parameters dpeta0n_na=0
parameters drdswn_na=1
parameters dcdscdn_na=0
parameters dk2n_na=-0.005
parameters dlk2n_na=0
parameters dwk2n_na=0
parameters dpk2n_na=0
parameters dcitn_na=0
parameters dlcitn_na=-3e-11
parameters dwcitn_na=0
parameters dpcitn_na=0
parameters ntoxn_na=1.11
parameters dagsn_na=0
parameters dlagsn_na=-0.0e-07
parameters dwagsn_na=-1e-8
parameters dpagsn_na=0
parameters dla0_na=0
parameters dvsat_na=0
parameters dlvsat_na=0
parameters dwvsat_na=0
parameters dpvsat_na=0
parameters b1fn_na=-5.625e+41   
parameters b2fn_na=-6.75e+13
parameters b3fn_na=-1.125e+7 
parameters a1fn_na=4.413e+42   
parameters a2fn_na=0   
parameters a3fn_na=-1.175e+7 
parameters c1fn_na=1.175e+42  
parameters c2fn_na=1.5e+14  
parameters c3fn_na=2.35e+7    
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na
endsection ff_na
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_na
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na
parameters parn1_na=0
parameters parn2_na=0
parameters a1n_na=0.8
parameters a1p_na=-0.8
parameters a2n_na=0
parameters a2p_na=0
parameters a3n_na=-1
parameters a3p_na=1
parameters a4np_na=0
parameters toxn_na=2e-09 + 6.0000e-11 * a4np_na
parameters dxln_na=5e-09 * a2n_na
parameters dxwn_na=8e-09 * a3n_na
parameters dvthn_na=0.03 * a1n_na
parameters dlvthn_na=3.5e-09 * a1n_na
parameters dwvthn_na=2.3e-09 * a1n_na
parameters dpvthn_na=0
parameters cjn_na=1.62000e-04 * (1 + 0.07 * a1n_na)
parameters cjswn_na=1.27000e-10 * (1 + 0.07 * a1n_na)
parameters cjswgn_na=2.95e-10 * (1 + 0.07 * a1n_na)
parameters cgon_na=1.42306e-10 * (1 - 0.820 * a4np_na)
parameters cgln_na=4.91376e-12 * (1 + 0.633 * a4np_na)
parameters ddlcn_na=5.10766e-09
parameters cfn_na=1.39e-10 * (1 - 0.070 * a4np_na) + 4.1e-11 * ccoflag_na
parameters dnfactorn_na=0
parameters dlnfactorn_na=0
parameters dwnfactorn_na=0
parameters dpnfactorn_na=0
parameters du0n_na= - 0.001 * a1n_na
parameters dlu0n_na=3e-10
parameters dwu0n_na=8e-11 * a1n_na
parameters dpu0n_na= - 2.4e-17 * a1n_na
parameters deta0n_na=0
parameters dleta0n_na=0
parameters dweta0n_na=0
parameters dpeta0n_na=0
parameters drdswn_na= - 1 * a1n_na
parameters dcdscdn_na=0
parameters dk2n_na=0.005 * a1n_na
parameters dlk2n_na=0
parameters dwk2n_na=0
parameters dpk2n_na=0
parameters dcitn_na=0
parameters dlcitn_na=3e-11 * a1n_na
parameters dwcitn_na=0
parameters dpcitn_na=0
parameters ntoxn_na=1 +  - 1.1000e-01 * a4np_na
parameters dagsn_na=0
parameters dlagsn_na=0 * a1n_na
parameters dwagsn_na=1e-08 * a1n_na
parameters dpagsn_na=0
parameters dla0_na=0
parameters dvsat_na=0
parameters dlvsat_na=0
parameters dwvsat_na=0
parameters dpvsat_na=0
parameters b1fn_na=-5.625e+41   
parameters b2fn_na=-6.75e+13
parameters b3fn_na=-1.125e+7 
parameters a1fn_na=4.413e+42   
parameters a2fn_na=0   
parameters a3fn_na=-1.175e+7 
parameters c1fn_na=1.175e+42  
parameters c2fn_na=1.5e+14  
parameters c3fn_na=2.35e+7      
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na
endsection sf_na
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_na
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na
parameters parn1_na=0
parameters parn2_na=0
parameters a1n_na=-0.8
parameters a1p_na=0.8
parameters a2n_na=0
parameters a2p_na=0
parameters a3n_na=1
parameters a3p_na=-1
parameters a4np_na=0
parameters toxn_na=2e-09 + 6.0000e-11 * a4np_na
parameters dxln_na=5e-09 * a2n_na
parameters dxwn_na=8e-09 * a3n_na
parameters dvthn_na=0.03 * a1n_na
parameters dlvthn_na=3.5e-09 * a1n_na
parameters dwvthn_na=2.3e-09 * a1n_na
parameters dpvthn_na=0
parameters cjn_na=0.000162 * (1 + 0.07 * a1n_na)
parameters cjswn_na=1.27e-10 * (1 + 0.07 * a1n_na)
parameters cjswgn_na=2.95e-10 * (1 + 0.07 * a1n_na)
parameters cgon_na=1.42306e-10 * (1 - 0.820 * a4np_na)
parameters cgln_na=4.91376e-12 * (1 + 0.633 * a4np_na)
parameters ddlcn_na=5.10766e-09
parameters cfn_na=1.39e-10 * (1 - 0.070 * a4np_na) + 4.1e-11 * ccoflag_na
parameters dnfactorn_na=0
parameters dlnfactorn_na=0
parameters dwnfactorn_na=0
parameters dpnfactorn_na=0
parameters du0n_na= - 0.001 * a1n_na
parameters dlu0n_na=-2.5e-10
parameters dwu0n_na=8e-11 * a1n_na
parameters dpu0n_na= - 2.4e-17 * a1n_na
parameters deta0n_na=0
parameters dleta0n_na=0
parameters dweta0n_na=0
parameters dpeta0n_na=0
parameters drdswn_na= - 1 * a1n_na
parameters dcdscdn_na=0
parameters dk2n_na=0.005 * a1n_na
parameters dlk2n_na=0
parameters dwk2n_na=0
parameters dpk2n_na=0
parameters dcitn_na=0
parameters dlcitn_na=3e-11 * a1n_na
parameters dwcitn_na=0
parameters dpcitn_na=0
parameters ntoxn_na=1 +  - 1.1000e-01 * a4np_na
parameters dagsn_na=0
parameters dlagsn_na=0 * a1n_na
parameters dwagsn_na=1e-08 * a1n_na
parameters dpagsn_na=0
parameters dla0_na=0
parameters dvsat_na=0
parameters dlvsat_na=0
parameters dwvsat_na=0
parameters dpvsat_na=0
parameters b1fn_na=-5.625e+41   
parameters b2fn_na=-6.75e+13
parameters b3fn_na=-1.125e+7 
parameters a1fn_na=4.413e+42   
parameters a2fn_na=0   
parameters a3fn_na=-1.175e+7 
parameters c1fn_na=1.175e+42  
parameters c2fn_na=1.5e+14  
parameters c3fn_na=2.35e+7    
parameters noian_na=a1fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b1fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c1fn_na
parameters noibn_na=a2fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b2fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c2fn_na
parameters noicn_na=a3fn_na * (abs(noiseflagn_na) + noiseflagn_na) + b3fn_na * (abs(noiseflagn_na) 
+ - noiseflagn_na) + c3fn_na
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na
endsection fs_na
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25
parameters parn1_na25=0
parameters parn2_na25=0
parameters toxn_na25=5.6e-09
parameters dxln_na25=0
parameters dxwn_na25=0
parameters cjn_na25=0.000145159
parameters cjswn_na25=1.69e-10
parameters cjswgn_na25=1.17763e-10
parameters cgon_na25=5.47859e-11
parameters cgln_na25=7.57836e-10
parameters ddlcn_na25=1.30153e-07
parameters dvthn_na25=0
parameters dlvthn_na25=0
parameters dwvthn_na25=0
parameters dpvthn_na25=0
parameters du0n_na25=0
parameters dlu0n_na25=0
parameters dwu0n_na25=0
parameters dpu0n_na25=0
parameters dcitn_na25=0
parameters dlcitn_na25=0
parameters dwcitn_na25=0
parameters dpcitn_na25=0
parameters dnfactorn_na25=0
parameters dlnfactorn_na25=0
parameters dwnfactorn_na25=0
parameters dpnfactorn_na25=0
parameters dvsatn_na25=0
parameters dlvsatn_na25=0
parameters dwvsatn_na25=0
parameters dpvsatn_na25=0
parameters deta0n_na25=0
parameters dleta0n_na25=0
parameters dweta0n_na25=0
parameters dpeta0n_na25=0
parameters cfn_na25=9e-11 + 2.4e-11 * ccoflag_na25
parameters b1fn_na25=-6e+40
parameters b2fn_na25=-1.5e+24
parameters b3fn_na25=-1.35e+8   
parameters a1fn_na25=3e+41   
parameters a2fn_na25=0   
parameters a3fn_na25=1.35e+9   
parameters c1fn_na25=2e+41     
parameters c2fn_na25=7.5e+24     
parameters c3fn_na25=3e+8     
parameters noian_na25=a1fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b1fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c1fn_na25
parameters noibn_na25=a2fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b2fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c2fn_na25
parameters noicn_na25=a3fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b3fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c3fn_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25
endsection tt_na25
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25
parameters parn1_na25=0
parameters parn2_na25=0
parameters toxn_na25=5.9e-09
parameters dxln_na25=1e-08
parameters dxwn_na25=-1.2e-08
parameters cjn_na25=0.00015532
parameters cjswn_na25=1.808e-10
parameters cjswgn_na25=1.26006e-10
parameters cgon_na25=5.09509e-11
parameters cgln_na25=7.04787e-10
parameters ddlcn_na25=1.30153e-07
parameters dvthn_na25=0.045
parameters dlvthn_na25=3.5e-08
parameters dwvthn_na25=1.3e-09
parameters dpvthn_na25=-6.5e-16
parameters du0n_na25=-0.002
parameters dlu0n_na25=0
parameters dwu0n_na25=0
parameters dpu0n_na25=-1e-16
parameters dcitn_na25=0
parameters dlcitn_na25=0
parameters dwcitn_na25=0
parameters dpcitn_na25=0
parameters dnfactorn_na25=0
parameters dlnfactorn_na25=0
parameters dwnfactorn_na25=0
parameters dpnfactorn_na25=0
parameters dvsatn_na25=0
parameters dlvsatn_na25=0
parameters dwvsatn_na25=0
parameters dpvsatn_na25=0
parameters deta0n_na25=0
parameters dleta0n_na25=0
parameters dweta0n_na25=0
parameters dpeta0n_na25=0
parameters cfn_na25=8.37e-11 + 2.4e-11 * ccoflag_na25
parameters b1fn_na25=-6e+40
parameters b2fn_na25=-1.5e+24
parameters b3fn_na25=-1.35e+8   
parameters a1fn_na25=3e+41   
parameters a2fn_na25=0   
parameters a3fn_na25=1.35e+9   
parameters c1fn_na25=2e+41     
parameters c2fn_na25=7.5e+24     
parameters c3fn_na25=3e+8       
parameters noian_na25=a1fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b1fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c1fn_na25
parameters noibn_na25=a2fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b2fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c2fn_na25
parameters noicn_na25=a3fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b3fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c3fn_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25
endsection ss_na25
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25
parameters parn1_na25=0
parameters parn2_na25=0
parameters toxn_na25=5.3e-09
parameters dxln_na25=-1e-08
parameters dxwn_na25=1.2e-08
parameters cjn_na25=0.000134998
parameters cjswn_na25=1.572e-10
parameters cjswgn_na25=1.09519e-10
parameters cgon_na25=5.86209e-11
parameters cgln_na25=8.10885e-10
parameters ddlcn_na25=1.30153e-07
parameters dvthn_na25=-0.0515
parameters dlvthn_na25=-3.3e-08
parameters dwvthn_na25=1.05e-09
parameters dpvthn_na25=6.5e-16
parameters du0n_na25=0.0017
parameters dlu0n_na25=0
parameters dwu0n_na25=0
parameters dpu0n_na25=1e-16
parameters dcitn_na25=0.003
parameters dlcitn_na25=0
parameters dwcitn_na25=0
parameters dpcitn_na25=0
parameters dnfactorn_na25=0
parameters dlnfactorn_na25=0
parameters dwnfactorn_na25=0
parameters dpnfactorn_na25=0
parameters dvsatn_na25=0
parameters dlvsatn_na25=0
parameters dwvsatn_na25=0
parameters dpvsatn_na25=0
parameters deta0n_na25=0
parameters dleta0n_na25=0
parameters dweta0n_na25=0
parameters dpeta0n_na25=0
parameters cfn_na25=9.63e-11 + 2.4e-11 * ccoflag_na25
parameters b1fn_na25=-6e+40
parameters b2fn_na25=-1.5e+24
parameters b3fn_na25=-1.35e+8   
parameters a1fn_na25=3e+41   
parameters a2fn_na25=0   
parameters a3fn_na25=1.35e+9   
parameters c1fn_na25=2e+41     
parameters c2fn_na25=7.5e+24     
parameters c3fn_na25=3e+8       
parameters noian_na25=a1fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b1fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c1fn_na25
parameters noibn_na25=a2fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b2fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c2fn_na25
parameters noicn_na25=a3fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b3fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c3fn_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25
endsection ff_na25
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25
parameters parn1_na25=0
parameters parn2_na25=0
parameters a1n_na25=0.8
parameters a1p_na25=-0.8
parameters a2n_na25=0
parameters a2p_na25=0
parameters a3n_na25=-0.8
parameters a3p_na25=1
parameters a4np_na25=0
parameters toxn_na25=5.6e-09 + 3.0000e-10 * a4np_na25
parameters dxln_na25=1e-08 * a2n_na25
parameters dxwn_na25=1.2e-08 * a3n_na25
parameters cjn_na25=0.000145159 * (1 + 0.070 * a1n_na25)
parameters cjswn_na25=1.69e-10 * (1 + 0.070 * a1n_na25)
parameters cjswgn_na25=1.17763e-10 * (1 + 0.070 * a1n_na25)
parameters cgon_na25=5.47859e-11 * (1 - 0.070 * a4np_na25)
parameters cgln_na25=7.57836e-10 * (1 - 0.070 * a4np_na25)
parameters ddlcn_na25=1.30153e-07
parameters dvthn_na25=0.0515 * a1n_na25
parameters dlvthn_na25=3.3e-08 * a1n_na25
parameters dwvthn_na25= - 1.05e-09 * a1n_na25
parameters dpvthn_na25= - 6.5e-16 * a1n_na25
parameters du0n_na25= - 0.0017 * a1n_na25
parameters dlu0n_na25=0
parameters dwu0n_na25=0
parameters dpu0n_na25= - 1e-16 * a1n_na25
parameters dcitn_na25= - 0.003 * a1n_na25
parameters dlcitn_na25=0
parameters dwcitn_na25=0
parameters dpcitn_na25=0
parameters dnfactorn_na25=0
parameters dlnfactorn_na25=0
parameters dwnfactorn_na25=0
parameters dpnfactorn_na25=0
parameters dvsatn_na25=0
parameters dlvsatn_na25=0
parameters dwvsatn_na25=0
parameters dpvsatn_na25=0
parameters deta0n_na25=0
parameters dleta0n_na25=0
parameters dweta0n_na25=0
parameters dpeta0n_na25=0
parameters cfn_na25=9e-11 * (1 - 0.070 * a4np_na25) + 2.4e-11 * ccoflag_na25
parameters b1fn_na25=-6e+40
parameters b2fn_na25=-1.5e+24
parameters b3fn_na25=-1.35e+8   
parameters a1fn_na25=3e+41   
parameters a2fn_na25=0   
parameters a3fn_na25=1.35e+9   
parameters c1fn_na25=2e+41     
parameters c2fn_na25=7.5e+24     
parameters c3fn_na25=3e+8     
parameters noian_na25=a1fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b1fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c1fn_na25
parameters noibn_na25=a2fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b2fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c2fn_na25
parameters noicn_na25=a3fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b3fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c3fn_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25
endsection sf_na25
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25
parameters parn1_na25=0
parameters parn2_na25=0
parameters a1n_na25=-0.8
parameters a1p_na25=0.8
parameters a2n_na25=0
parameters a2p_na25=0
parameters a3n_na25=0.8
parameters a3p_na25=-1
parameters a4np_na25=0
parameters toxn_na25=5.6e-09 + 3.0000e-10 * a4np_na25
parameters dxln_na25=1e-08 * a2n_na25
parameters dxwn_na25=1.2e-08 * a3n_na25
parameters cjn_na25=0.000145159 * (1 + 0.070 * a1n_na25)
parameters cjswn_na25=1.69e-10 * (1 + 0.070 * a1n_na25)
parameters cjswgn_na25=1.17763e-10 * (1 + 0.070 * a1n_na25)
parameters cgon_na25=5.47859e-11 * (1 - 0.070 * a4np_na25)
parameters cgln_na25=7.57836e-10 * (1 - 0.070 * a4np_na25)
parameters ddlcn_na25=1.30153e-07
parameters dvthn_na25=0.0515 * a1n_na25
parameters dlvthn_na25=3.3e-08 * a1n_na25
parameters dwvthn_na25= - 1.05e-09 * a1n_na25
parameters dpvthn_na25= - 6.5e-16 * a1n_na25
parameters du0n_na25= - 0.0017 * a1n_na25
parameters dlu0n_na25=0
parameters dwu0n_na25=0
parameters dpu0n_na25= - 1e-16 * a1n_na25
parameters dcitn_na25= - 0.003 * a1n_na25
parameters dlcitn_na25=0
parameters dwcitn_na25=0
parameters dpcitn_na25=0
parameters dnfactorn_na25=0
parameters dlnfactorn_na25=0
parameters dwnfactorn_na25=0
parameters dpnfactorn_na25=0
parameters dvsatn_na25=0
parameters dlvsatn_na25=0
parameters dwvsatn_na25=0
parameters dpvsatn_na25=0
parameters deta0n_na25=0
parameters dleta0n_na25=0
parameters dweta0n_na25=0
parameters dpeta0n_na25=0
parameters cfn_na25=9e-11 * (1 - 0.070 * a4np_na25) + 2.4e-11 * ccoflag_na25
parameters b1fn_na25=-6e+40
parameters b2fn_na25=-1.5e+24
parameters b3fn_na25=-1.35e+8   
parameters a1fn_na25=3e+41   
parameters a2fn_na25=0   
parameters a3fn_na25=1.35e+9   
parameters c1fn_na25=2e+41     
parameters c2fn_na25=7.5e+24     
parameters c3fn_na25=3e+8         
parameters noian_na25=a1fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b1fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c1fn_na25
parameters noibn_na25=a2fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b2fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c2fn_na25
parameters noicn_na25=a3fn_na25 * (abs(noiseflagn_na25) + noiseflagn_na25) + b3fn_na25 
+ * (abs(noiseflagn_na25) - noiseflagn_na25) + c3fn_na25
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25
endsection fs_na25
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25od33
parameters parn1_na25od33=0
parameters parn2_na25od33=0
parameters parp1_na25od33=0
parameters parp2_na25od33=0
parameters toxn_na25od33=5.6e-09
parameters dxln_na25od33=0
parameters dxwn_na25od33=0
parameters cjn_na25od33=0.000145159
parameters cjswn_na25od33=1.69e-10
parameters cjswgn_na25od33=1.17763e-10
parameters cgon_na25od33=5.47859e-11
parameters cgln_na25od33=7.57836e-10
parameters ddlcn_na25od33=1.30153e-07
parameters dvthn_na25od33=0
parameters dlvthn_na25od33=0
parameters dwvthn_na25od33=0
parameters dpvthn_na25od33=0
parameters du0n_na25od33=0
parameters dlu0n_na25od33=0
parameters dwu0n_na25od33=0
parameters dpu0n_na25od33=0
parameters dcitn_na25od33=0
parameters dlcitn_na25od33=0
parameters dwcitn_na25od33=0
parameters dpcitn_na25od33=0
parameters dnfactorn_na25od33=0
parameters dlnfactorn_na25od33=0
parameters dwnfactorn_na25od33=0
parameters dpnfactorn_na25od33=0
parameters dvsatn_na25od33=0
parameters dlvsatn_na25od33=0
parameters dwvsatn_na25od33=0
parameters dpvsatn_na25od33=0
parameters deta0n_na25od33=0
parameters dleta0n_na25od33=0
parameters dweta0n_na25od33=0
parameters dpeta0n_na25od33=0
parameters cfn_na25od33=9e-11 + 2.4e-11 * ccoflag_na25od33
parameters b1fn_na25od33=-6e+40
parameters b2fn_na25od33=-1.5e+24
parameters b3fn_na25od33=-1.35e+8   
parameters a1fn_na25od33=3e+41   
parameters a2fn_na25od33=0   
parameters a3fn_na25od33=1.35e+9   
parameters c1fn_na25od33=2e+41     
parameters c2fn_na25od33=7.5e+24     
parameters c3fn_na25od33=3e+8       
parameters noian_na25od33=a1fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b1fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c1fn_na25od33
parameters noibn_na25od33=a2fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b2fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c2fn_na25od33
parameters noicn_na25od33=a3fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b3fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c3fn_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25od33
endsection tt_na25od33
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25od33
parameters parn1_na25od33=0
parameters parn2_na25od33=0
parameters parp1_na25od33=0
parameters parp2_na25od33=0
parameters toxn_na25od33=5.9e-09
parameters dxln_na25od33=1e-08
parameters dxwn_na25od33=-1.2e-08
parameters cjn_na25od33=0.00015532
parameters cjswn_na25od33=1.808e-10
parameters cjswgn_na25od33=1.26006e-10
parameters cgon_na25od33=5.09509e-11
parameters cgln_na25od33=7.04787e-10
parameters ddlcn_na25od33=1.30153e-07
parameters dvthn_na25od33=0.045
parameters dlvthn_na25od33=3.5e-08
parameters dwvthn_na25od33=1.3e-09
parameters dpvthn_na25od33=-6.5e-16
parameters du0n_na25od33=-0.002
parameters dlu0n_na25od33=0
parameters dwu0n_na25od33=0
parameters dpu0n_na25od33=-1e-16
parameters dcitn_na25od33=0
parameters dlcitn_na25od33=0
parameters dwcitn_na25od33=0
parameters dpcitn_na25od33=0
parameters dnfactorn_na25od33=0
parameters dlnfactorn_na25od33=0
parameters dwnfactorn_na25od33=0
parameters dpnfactorn_na25od33=0
parameters dvsatn_na25od33=0
parameters dlvsatn_na25od33=0
parameters dwvsatn_na25od33=0
parameters dpvsatn_na25od33=0
parameters deta0n_na25od33=0
parameters dleta0n_na25od33=0
parameters dweta0n_na25od33=0
parameters dpeta0n_na25od33=0
parameters cfn_na25od33=8.37e-11 + 2.4e-11 * ccoflag_na25od33
parameters b1fn_na25od33=-6e+40
parameters b2fn_na25od33=-1.5e+24
parameters b3fn_na25od33=-1.35e+8   
parameters a1fn_na25od33=3e+41   
parameters a2fn_na25od33=0   
parameters a3fn_na25od33=1.35e+9   
parameters c1fn_na25od33=2e+41     
parameters c2fn_na25od33=7.5e+24     
parameters c3fn_na25od33=3e+8       
parameters noian_na25od33=a1fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b1fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c1fn_na25od33
parameters noibn_na25od33=a2fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b2fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c2fn_na25od33
parameters noicn_na25od33=a3fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b3fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c3fn_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25od33
endsection ss_na25od33
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25od33
parameters parn1_na25od33=0
parameters parn2_na25od33=0
parameters parp1_na25od33=0
parameters parp2_na25od33=0
parameters toxn_na25od33=5.3e-09
parameters dxln_na25od33=-1e-08
parameters dxwn_na25od33=1.2e-08
parameters cjn_na25od33=0.000134998
parameters cjswn_na25od33=1.572e-10
parameters cjswgn_na25od33=1.09519e-10
parameters cgon_na25od33=5.86209e-11
parameters cgln_na25od33=8.10885e-10
parameters ddlcn_na25od33=1.30153e-07
parameters dvthn_na25od33=-0.0515
parameters dlvthn_na25od33=-3.3e-08
parameters dwvthn_na25od33=1.05e-09
parameters dpvthn_na25od33=6.5e-16
parameters du0n_na25od33=0.0017
parameters dlu0n_na25od33=0
parameters dwu0n_na25od33=0
parameters dpu0n_na25od33=1e-16
parameters dcitn_na25od33=0.003
parameters dlcitn_na25od33=0
parameters dwcitn_na25od33=0
parameters dpcitn_na25od33=0
parameters dnfactorn_na25od33=0
parameters dlnfactorn_na25od33=0
parameters dwnfactorn_na25od33=0
parameters dpnfactorn_na25od33=0
parameters dvsatn_na25od33=0
parameters dlvsatn_na25od33=0
parameters dwvsatn_na25od33=0
parameters dpvsatn_na25od33=0
parameters deta0n_na25od33=0
parameters dleta0n_na25od33=0
parameters dweta0n_na25od33=0
parameters dpeta0n_na25od33=0
parameters cfn_na25od33=9.63e-11 + 2.4e-11 * ccoflag_na25od33
parameters b1fn_na25od33=-6e+40
parameters b2fn_na25od33=-1.5e+24
parameters b3fn_na25od33=-1.35e+8   
parameters a1fn_na25od33=3e+41   
parameters a2fn_na25od33=0   
parameters a3fn_na25od33=1.35e+9   
parameters c1fn_na25od33=2e+41     
parameters c2fn_na25od33=7.5e+24     
parameters c3fn_na25od33=3e+8       
parameters noian_na25od33=a1fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b1fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c1fn_na25od33
parameters noibn_na25od33=a2fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b2fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c2fn_na25od33
parameters noicn_na25od33=a3fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b3fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c3fn_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25od33
endsection ff_na25od33
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25od33
parameters parn1_na25od33=0
parameters parn2_na25od33=0
parameters parp1_na25od33=0
parameters parp2_na25od33=0
parameters toxn_na25od33=5.6e-09
parameters dxln_na25od33=0
parameters dxwn_na25od33=0
parameters cjn_na25od33=0.00015532
parameters cjswn_na25od33=1.808e-10
parameters cjswgn_na25od33=1.26006e-10
parameters cgon_na25od33=5.47859e-11
parameters cgln_na25od33=7.57836e-10
parameters ddlcn_na25od33=1.30153e-07
parameters dvthn_na25od33=0.045
parameters dlvthn_na25od33=3.5e-08
parameters dwvthn_na25od33=1.3e-09
parameters dpvthn_na25od33=-6.5e-16
parameters du0n_na25od33=-0.002
parameters dlu0n_na25od33=0
parameters dwu0n_na25od33=0
parameters dpu0n_na25od33=-1e-16
parameters dcitn_na25od33=0
parameters dlcitn_na25od33=0
parameters dwcitn_na25od33=0
parameters dpcitn_na25od33=0
parameters dnfactorn_na25od33=0
parameters dlnfactorn_na25od33=0
parameters dwnfactorn_na25od33=0
parameters dpnfactorn_na25od33=0
parameters dvsatn_na25od33=0
parameters dlvsatn_na25od33=0
parameters dwvsatn_na25od33=0
parameters dpvsatn_na25od33=0
parameters deta0n_na25od33=0
parameters dleta0n_na25od33=0
parameters dweta0n_na25od33=0
parameters dpeta0n_na25od33=0
parameters cfn_na25od33=9e-11 + 2.4e-11 * ccoflag_na25od33
parameters b1fn_na25od33=-6e+40
parameters b2fn_na25od33=-1.5e+24
parameters b3fn_na25od33=-1.35e+8   
parameters a1fn_na25od33=3e+41   
parameters a2fn_na25od33=0   
parameters a3fn_na25od33=1.35e+9   
parameters c1fn_na25od33=2e+41     
parameters c2fn_na25od33=7.5e+24     
parameters c3fn_na25od33=3e+8        
parameters noian_na25od33=a1fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b1fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c1fn_na25od33
parameters noibn_na25od33=a2fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b2fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c2fn_na25od33
parameters noicn_na25od33=a3fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b3fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c3fn_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25od33
endsection sf_na25od33
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na25od33
parameters parn1_na25od33=0
parameters parn2_na25od33=0
parameters parp1_na25od33=0
parameters parp2_na25od33=0
parameters toxn_na25od33=5.6e-09
parameters dxln_na25od33=0
parameters dxwn_na25od33=0
parameters cjn_na25od33=0.000134998
parameters cjswn_na25od33=1.572e-10
parameters cjswgn_na25od33=1.09519e-10
parameters cgon_na25od33=5.47859e-11
parameters cgln_na25od33=7.57836e-10
parameters ddlcn_na25od33=1.30153e-07
parameters dvthn_na25od33=-0.0515
parameters dlvthn_na25od33=-3.3e-08
parameters dwvthn_na25od33=1.05e-09
parameters dpvthn_na25od33=6.5e-16
parameters du0n_na25od33=0.0017
parameters dlu0n_na25od33=0
parameters dwu0n_na25od33=0
parameters dpu0n_na25od33=1e-16
parameters dcitn_na25od33=0.003
parameters dlcitn_na25od33=0
parameters dwcitn_na25od33=0
parameters dpcitn_na25od33=0
parameters dnfactorn_na25od33=0
parameters dlnfactorn_na25od33=0
parameters dwnfactorn_na25od33=0
parameters dpnfactorn_na25od33=0
parameters dvsatn_na25od33=0
parameters dlvsatn_na25od33=0
parameters dwvsatn_na25od33=0
parameters dpvsatn_na25od33=0
parameters deta0n_na25od33=0
parameters dleta0n_na25od33=0
parameters dweta0n_na25od33=0
parameters dpeta0n_na25od33=0
parameters cfn_na25od33=9e-11 + 2.4e-11 * ccoflag_na25od33
parameters b1fn_na25od33=-6e+40
parameters b2fn_na25od33=-1.5e+24
parameters b3fn_na25od33=-1.35e+8   
parameters a1fn_na25od33=3e+41   
parameters a2fn_na25od33=0   
parameters a3fn_na25od33=1.35e+9   
parameters c1fn_na25od33=2e+41     
parameters c2fn_na25od33=7.5e+24     
parameters c3fn_na25od33=3e+8        
parameters noian_na25od33=a1fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b1fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c1fn_na25od33
parameters noibn_na25od33=a2fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b2fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c2fn_na25od33
parameters noicn_na25od33=a3fn_na25od33 * (abs(noiseflagn_na25od33) + noiseflagn_na25od33) 
+ + b3fn_na25od33 * (abs(noiseflagn_na25od33) - noiseflagn_na25od33) + c3fn_na25od33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na25od33
endsection fs_na25od33
 
// **************************     LIBRARY OF TYPICAL CASE     ***************************

section tt_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na33
parameters parn1_na33=0
parameters parn2_na33=0
parameters parp1_na33=0
parameters parp2_na33=0
parameters toxn_na33=5.6e-09
parameters dxln_na33=0
parameters dxwn_na33=0
parameters cjn_na33=0.000145159
parameters cjswn_na33=1.69e-10
parameters cjswgn_na33=1.17763e-10
parameters cgon_na33=5.47859e-11
parameters cgln_na33=7.57836e-10
parameters ddlcn_na33=1.30153e-07
parameters dvthn_na33=0
parameters dlvthn_na33=0
parameters dwvthn_na33=0
parameters dpvthn_na33=0
parameters du0n_na33=0
parameters dlu0n_na33=0
parameters dwu0n_na33=0
parameters dpu0n_na33=0
parameters dcitn_na33=0
parameters dlcitn_na33=0
parameters dwcitn_na33=0
parameters dpcitn_na33=0
parameters dnfactorn_na33=0
parameters dlnfactorn_na33=0
parameters dwnfactorn_na33=0
parameters dpnfactorn_na33=0
parameters dvsatn_na33=0
parameters dlvsatn_na33=0
parameters dwvsatn_na33=0
parameters dpvsatn_na33=0
parameters deta0n_na33=0
parameters dleta0n_na33=0
parameters dweta0n_na33=0
parameters dpeta0n_na33=0
parameters cfn_na33=9e-11 + 2.4e-11 * ccoflag_na33
parameters b1fn_na33=-6e+40
parameters b2fn_na33=-1.5e+24
parameters b3fn_na33=-1.35e+8   
parameters a1fn_na33=3e+41   
parameters a2fn_na33=0   
parameters a3fn_na33=1.35e+9   
parameters c1fn_na33=2e+41     
parameters c2fn_na33=7.5e+24     
parameters c3fn_na33=3e+8       
parameters noian_na33=a1fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b1fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c1fn_na33
parameters noibn_na33=a2fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b2fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c2fn_na33
parameters noicn_na33=a3fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b3fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c3fn_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na33
endsection tt_na33
 
// **************************     LIBRARY OF SNSP CORNER CASE     ***************************

section ss_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na33
parameters parn1_na33=0
parameters parn2_na33=0
parameters parp1_na33=0
parameters parp2_na33=0
parameters toxn_na33=5.9e-09
parameters dxln_na33=1e-08
parameters dxwn_na33=-1.2e-08
parameters cjn_na33=0.00015532
parameters cjswn_na33=1.808e-10
parameters cjswgn_na33=1.26006e-10
parameters cgon_na33=5.09509e-11
parameters cgln_na33=7.04787e-10
parameters ddlcn_na33=1.30153e-07
parameters dvthn_na33=0.045
parameters dlvthn_na33=3.5e-08
parameters dwvthn_na33=1.3e-09
parameters dpvthn_na33=-6.5e-16
parameters du0n_na33=-0.002
parameters dlu0n_na33=0
parameters dwu0n_na33=0
parameters dpu0n_na33=-1e-16
parameters dcitn_na33=0
parameters dlcitn_na33=0
parameters dwcitn_na33=0
parameters dpcitn_na33=0
parameters dnfactorn_na33=0
parameters dlnfactorn_na33=0
parameters dwnfactorn_na33=0
parameters dpnfactorn_na33=0
parameters dvsatn_na33=0
parameters dlvsatn_na33=0
parameters dwvsatn_na33=0
parameters dpvsatn_na33=0
parameters deta0n_na33=0
parameters dleta0n_na33=0
parameters dweta0n_na33=0
parameters dpeta0n_na33=0
parameters cfn_na33=8.37e-11 + 2.4e-11 * ccoflag_na33
parameters b1fn_na33=-6e+40
parameters b2fn_na33=-1.5e+24
parameters b3fn_na33=-1.35e+8   
parameters a1fn_na33=3e+41   
parameters a2fn_na33=0   
parameters a3fn_na33=1.35e+9   
parameters c1fn_na33=2e+41     
parameters c2fn_na33=7.5e+24     
parameters c3fn_na33=3e+8       
parameters noian_na33=a1fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b1fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c1fn_na33
parameters noibn_na33=a2fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b2fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c2fn_na33
parameters noicn_na33=a3fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b3fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c3fn_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na33
endsection ss_na33
 
// **************************     LIBRARY OF FNFP CORNER CASE     ***************************

section ff_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na33
parameters parn1_na33=0
parameters parn2_na33=0
parameters parp1_na33=0
parameters parp2_na33=0
parameters toxn_na33=5.3e-09
parameters dxln_na33=-1e-08
parameters dxwn_na33=1.2e-08
parameters cjn_na33=0.000134998
parameters cjswn_na33=1.572e-10
parameters cjswgn_na33=1.09519e-10
parameters cgon_na33=5.86209e-11
parameters cgln_na33=8.10885e-10
parameters ddlcn_na33=1.30153e-07
parameters dvthn_na33=-0.0515
parameters dlvthn_na33=-3.3e-08
parameters dwvthn_na33=1.05e-09
parameters dpvthn_na33=6.5e-16
parameters du0n_na33=0.0017
parameters dlu0n_na33=0
parameters dwu0n_na33=0
parameters dpu0n_na33=1e-16
parameters dcitn_na33=0.003
parameters dlcitn_na33=0
parameters dwcitn_na33=0
parameters dpcitn_na33=0
parameters dnfactorn_na33=0
parameters dlnfactorn_na33=0
parameters dwnfactorn_na33=0
parameters dpnfactorn_na33=0
parameters dvsatn_na33=0
parameters dlvsatn_na33=0
parameters dwvsatn_na33=0
parameters dpvsatn_na33=0
parameters deta0n_na33=0
parameters dleta0n_na33=0
parameters dweta0n_na33=0
parameters dpeta0n_na33=0
parameters cfn_na33=9.63e-11 + 2.4e-11 * ccoflag_na33
parameters b1fn_na33=-6e+40
parameters b2fn_na33=-1.5e+24
parameters b3fn_na33=-1.35e+8   
parameters a1fn_na33=3e+41   
parameters a2fn_na33=0   
parameters a3fn_na33=1.35e+9   
parameters c1fn_na33=2e+41     
parameters c2fn_na33=7.5e+24     
parameters c3fn_na33=3e+8         
parameters noian_na33=a1fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b1fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c1fn_na33
parameters noibn_na33=a2fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b2fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c2fn_na33
parameters noicn_na33=a3fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b3fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c3fn_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na33
endsection ff_na33
 
// **************************     LIBRARY OF SNFP CORNER CASE     ***************************

section sf_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na33
parameters parn1_na33=0
parameters parn2_na33=0
parameters parp1_na33=0
parameters parp2_na33=0
parameters toxn_na33=5.6e-09
parameters dxln_na33=0
parameters dxwn_na33=0
parameters cjn_na33=0.00015532
parameters cjswn_na33=1.808e-10
parameters cjswgn_na33=1.26006e-10
parameters cgon_na33=5.47859e-11
parameters cgln_na33=7.57836e-10
parameters ddlcn_na33=1.30153e-07
parameters dvthn_na33=0.045
parameters dlvthn_na33=3.5e-08
parameters dwvthn_na33=1.3e-09
parameters dpvthn_na33=-6.5e-16
parameters du0n_na33=-0.002
parameters dlu0n_na33=0
parameters dwu0n_na33=0
parameters dpu0n_na33=-1e-16
parameters dcitn_na33=0
parameters dlcitn_na33=0
parameters dwcitn_na33=0
parameters dpcitn_na33=0
parameters dnfactorn_na33=0
parameters dlnfactorn_na33=0
parameters dwnfactorn_na33=0
parameters dpnfactorn_na33=0
parameters dvsatn_na33=0
parameters dlvsatn_na33=0
parameters dwvsatn_na33=0
parameters dpvsatn_na33=0
parameters deta0n_na33=0
parameters dleta0n_na33=0
parameters dweta0n_na33=0
parameters dpeta0n_na33=0
parameters cfn_na33=9e-11 + 2.4e-11 * ccoflag_na33
parameters b1fn_na33=-6e+40
parameters b2fn_na33=-1.5e+24
parameters b3fn_na33=-1.35e+8   
parameters a1fn_na33=3e+41   
parameters a2fn_na33=0   
parameters a3fn_na33=1.35e+9   
parameters c1fn_na33=2e+41     
parameters c2fn_na33=7.5e+24     
parameters c3fn_na33=3e+8        
parameters noian_na33=a1fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b1fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c1fn_na33
parameters noibn_na33=a2fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b2fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c2fn_na33
parameters noicn_na33=a3fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b3fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c3fn_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na33
endsection sf_na33
 
// **************************     LIBRARY OF FNSP CORNER CASE     ***************************

section fs_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=post_simu_na33
parameters parn1_na33=0
parameters parn2_na33=0
parameters parp1_na33=0
parameters parp2_na33=0
parameters toxn_na33=5.6e-09
parameters dxln_na33=0
parameters dxwn_na33=0
parameters cjn_na33=0.000134998
parameters cjswn_na33=1.572e-10
parameters cjswgn_na33=1.09519e-10
parameters cgon_na33=5.47859e-11
parameters cgln_na33=7.57836e-10
parameters ddlcn_na33=1.30153e-07
parameters dvthn_na33=-0.0515
parameters dlvthn_na33=-3.3e-08
parameters dwvthn_na33=1.05e-09
parameters dpvthn_na33=6.5e-16
parameters du0n_na33=0.0017
parameters dlu0n_na33=0
parameters dwu0n_na33=0
parameters dpu0n_na33=1e-16
parameters dcitn_na33=0.003
parameters dlcitn_na33=0
parameters dwcitn_na33=0
parameters dpcitn_na33=0
parameters dnfactorn_na33=0
parameters dlnfactorn_na33=0
parameters dwnfactorn_na33=0
parameters dpnfactorn_na33=0
parameters dvsatn_na33=0
parameters dlvsatn_na33=0
parameters dwvsatn_na33=0
parameters dpvsatn_na33=0
parameters deta0n_na33=0
parameters dleta0n_na33=0
parameters dweta0n_na33=0
parameters dpeta0n_na33=0
parameters cfn_na33=9e-11 + 2.4e-11 * ccoflag_na33
parameters b1fn_na33=-6e+40
parameters b2fn_na33=-1.5e+24
parameters b3fn_na33=-1.35e+8   
parameters a1fn_na33=3e+41   
parameters a2fn_na33=0   
parameters a3fn_na33=1.35e+9   
parameters c1fn_na33=2e+41     
parameters c2fn_na33=7.5e+24     
parameters c3fn_na33=3e+8         
parameters noian_na33=a1fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b1fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c1fn_na33
parameters noibn_na33=a2fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b2fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c2fn_na33
parameters noicn_na33=a3fn_na33 * (abs(noiseflagn_na33) + noiseflagn_na33) + b3fn_na33 
+ * (abs(noiseflagn_na33) - noiseflagn_na33) + c3fn_na33
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_na33
endsection fs_na33
 
// **************************************************************
//                                                              *
//                      Standard-vt DEVICE MODELS               *
//                                                              *
// **************************************************************

section mos
// *********************************************************************************************
//                                                                            
//                   *
//                                1.0V STD-VT NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
 
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt nch_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=7.15e-008 xw= + 1.6e-08 
+ + dxwn ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg / factor * (w 
+ / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) ps=4 * dmcg 
+ / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf + xw / factor) 
+ nrs=dmcg / factor / (w / nf + xw / factor) sa=0.405e-6 / factor sb=0.405e-6 / 
+ factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parn1 temp2=parn2 fac1=0.443742 * temp1 * sigma + 0.896155 
+ * temp2 * sigma fac2=0.443742 * temp1 * sigma - 0.896155 * temp2 * sigma lef=l 
+ * factor - 1.46e-08 wef=w / nf * factor + 1.6e-08 geo_fac=1 / sqrt(multi * nf 
+ * lef * wef * 1e12) vthmisn=0.00235886 * geo_fac * fac1 * mismatchflag dlmisn=0.00171632 
+ * geo_fac * lef * fac2 * mismatchflag dwmisn= - 0.00171632 * geo_fac * wef * fac2 
+ * mismatchflag toxmisn=0.00171632 * geo_fac * toxn * fac2 * mismatchflag tnoiax=1.603e05 
+ / (l * 1e6) + 2.013e07 rnoiax=0.011 / (l * 1e6) + 0.4433 
nch_mac ( n1 n2 n3 n4 ) nch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nch bsim4  { 
     1: type=n 
+ lmin=9.999997e-006-(dxln+dlmisn)                    lmax=2.00001e-05
+ wmin=1e-005-(dxwn+dwmisn) wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31803+(dvthn+vthmisn)                        k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0076717973+dk2n     k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00057279971
+ voff=-0.13911744+dvoffn   nfactor=0.6+dnfactorn     eta0=0.12927+deta0n
+ etab=-0.057726            u0=0.021593681+du0n       ua=-1.7296441e-009
+ ub=2.0224332e-18          pub=0                     wub=0
+ lub=0                     ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               uc=4.269655e-11
+ puc=0                     wuc=0                     luc=0
+ vsat=101530+dvsatn        a0=3.373321+da0n          kvsat=1
+ ags=0.6553773+dagsn       wags=0                    a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.034718159         dwg=0                     dwb=0
+ pclm=0.053744831+dpclmn   pdiblc1=0                 pdiblc2=0.00098156419
+ pdiblcb=-0.03716          drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.44984             pditsd=1
+ pditsl=264000             rsh=16                    rsw=45+drdswn
+ rdw=45+drdswn             prwg=0                    prwb=0
+ wr=1                      alpha0=3.3929e-010        alpha1=0.0034
+ beta0=5.808               agidl=1.5797e-008         bgidl=1.4527e+009
+ cgidl=1.4892              egidl=0.81976             aigbacc=0.013432
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010744
+ bigc=0.000824385          cigc=-0.087762            aigsd=0.0093701
+ bigsd=0.0012397           cigsd=0.081703            nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=7.6133               noff=2.4067
+ voffcv=-0.12779           kt1=-0.23137464+dkt1n     kt1l=0
+ kt2=-0.037187286+dkt2n    ute=-1                    ua1=2.945079e-009+dua1n
+ ub1=-1.225332e-018+dub1n  uc1=2.957975e-10          puc1=0
+ wuc1=0                    luc1=0                    prt=0
+ at=200000+datn            jss=1.35e-07              jsd=1.35e-07
+ jsws=2.5e-13              jswd=2.5e-13              jswgs=2.5e-13
+ jswgd=2.5e-13             njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.03                  bvd=9.03
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn                   cjd=cjn
+ mjs=0.32                  mjd=0.32                  pbsws=1.12
+ pbswd=1.12                cjsws=cjswn               cjswd=cjswn
+ mjsws=0.05                mjswd=0.05                pbswgs=1.15
+ pbswgd=1.15               cjswgs=cjswgn             cjswgd=cjswgn
+ mjswgs=0.98               mjswgd=0.98               tpb=0.0016
+ tcj=0.0008                tpbsw=0.003               tcjsw=0.0004
+ tpbswg=0.0019             tcjswg=0.0016             xtis=3
+ xtid=3                    jtsswgs=7.86078e-009      jtsswgd=7.86078e-009
+ njtsswg=5.64              xtsswgs=-0.103            xtsswgd=-0.103
+ tnjtsswg=-0.485           vtsswgs=17.7              vtsswgd=17.7
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lvth0=0+dlvthn            wvth0=0+dwvthn
+ pvth0=0+dpvthn            lk2=0+dlk2n               wk2=0+dwk2n
+ pk2=0+dpk2n               lcit=0+dlcitn             wcit=0+dwcitn
+ pcit=0+dpcitn             lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn
+ pnfactor=0+dpnfactorn     leta0=0+dleta0n           weta0=0+dweta0n
+ peta0=0+dpeta0n           lu0=0+dlu0n               wu0=0+dwu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           wvsat=0+dwvsatn
+ pvsat=0+dpvsatn           lags=0+dlagsn             pags=0+dpagsn
+ ppclm=0+dppclmn           lkt1=0+dlkt1n             pat=0+dpatn
+ lat=0+dlatn               lvoff=0+dlvoffn           wvoff=0+dwvoffn
+ pvoff=0+dpvoffn           la0=0+dla0n               wa0=0+dwa0n
+ pa0=0+dpa0n               wkt1=0+dwkt1n             pkt1=0+dpkt1n
+ lkt2=0+dlkt2n             wkt2=0+dwkt2n             pkt2=0+dpkt2n
+ lua1=0+dlua1n             wua1=0+dwua1n             pua1=0+dpua1n
+ lub1=0+dlub1n             wub1=0+dwub1n             pub1=0+dpub1n
+ wat=0+dwatn               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.0036
+ pkvth0we=0.15e-17         wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0017             pku0we=-1.4e-17           wku0we=-2.0e-10
+ lku0we=1.88e-10           k2we=0.00045              pk2we=-0.26e-17
+ wk2we=0.4e-10             lk2we=0.1e-12             fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn                rnoib=0                   noic=noicn
+ em=3e+8                   ef=0.9                    lintnoi=-1e-8
+ minr=1e-3
 
 
     2: type=n 
+ lmin=9.999973e-007-(dxln+dlmisn)                    lmax=9.999997e-006-(dxln+dlmisn)
+ wmin=1e-005-(dxwn+dwmisn) wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31813491+(dvthn+vthmisn)                     k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.008109687+dk2n      lk2=4.3544712e-009+dlk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00055237426         lcit=2.031151e-010+dlcitn voff=-0.13961679+dvoffn
+ lvoff=4.9656433e-009+dlvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.12927+deta0n       etab=-0.057726            u0=0.021593648+du0n
+ lu0=3.3280672e-013+dlu0n  ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               ua=-1.7528582e-009
+ lua=2.3084567e-016        ub=2.0073098e-18          pub=0
+ wub=0                     lub=1.5039036e-25         uc=3.6428937e-11
+ puc=0                     wuc=0                     luc=6.232659e-17
+ vsat=101530+dvsatn        a0=3.4548994+da0n         la0=-8.1123352e-07+dla0n
+ kvsat=1                   ags=0.5348291+dagsn       wags=0
+ lags=1.1987574e-06+dlagsn a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.027869224
+ lketa=-6.8107322e-008     dwg=0                     dwb=0
+ pclm=0.053744813+dpclmn   lpclm=1.7631453e-013      pdiblc1=0
+ pdiblc2=0.00059937807     lpdiblc2=3.8005429e-009   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.2299745+dkt1n      lkt1=-1.392331e-008+dlkt1n
+ kt1l=0                    kt2=-0.037094269+dkt2n    lkt2=-9.2497547e-010+dlkt2n
+ ute=-1                    ua1=3.0054368e-009+dua1n  lua1=-6.0021167e-016+dlua1n
+ ub1=-1.1511459e-018+dub1n lub1=-7.3772296e-025+dlub1n
+ uc1=3.2196412e-10         puc1=0                    wuc1=0
+ luc1=-2.6020665e-16       prt=0                     at=200000+datn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=-1.0432812e-09+dlvthn                         wvth0=0+dwvthn
+ pvth0=0+dpvthn            wk2=0+dwk2n               pk2=0+dpk2n
+ wcit=0+dwcitn             pcit=0+dpcitn             lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     leta0=0+dleta0n
+ weta0=0+dweta0n           peta0=0+dpeta0n           wu0=0+dwu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           wvsat=0+dwvsatn
+ pvsat=0+dpvsatn           pags=0+dpagsn             ppclm=0+dppclmn
+ pat=0+dpatn               lat=0+dlatn               wvoff=0+dwvoffn
+ pvoff=0+dpvoffn           wa0=0+dwa0n               pa0=0+dpa0n
+ wkt1=0+dwkt1n             pkt1=0+dpkt1n             wkt2=0+dwkt2n
+ pkt2=0+dpkt2n             wua1=0+dwua1n             pua1=0+dpua1n
+ wub1=0+dwub1n             pub1=0+dpub1n             wat=0+dwatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     3: type=n 
+ lmin=2.399969e-007-(dxln+dlmisn)                    lmax=9.999973e-007-(dxln+dlmisn)
+ wmin=1e-005-(dxwn+dwmisn) wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=3.259685e-09+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0057626158+dk2n     lk2=2.1383197e-009+dlk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00039326253         lcit=3.5335157e-010+dlcitn
+ voff=-0.1323198+dvoffn    lvoff=-1.9243258e-009+dlvoffn
+ nfactor=0.6+dnfactorn     eta0=0.12927+deta0n       etab=-0.057726
+ u0=0.021766153+du0n       lu0=-1.6254995e-010+dlu0n ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ ua=-1.47514e-009          lua=-3.1381339e-017       ub=2.1862099e-018
+ lub=-1.8530711e-026       uc=1.0038715e-10          luc=1.9359613e-018
+ vsat=101530+dvsatn        a0=3.2209203+da0n         la0=-5.9030578e-007+dla0n
+ kvsat=1                   ags=0.90434548+dagsn      lags=8.4985262e-007+dlagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.1                 dwg=0
+ dwb=0                     pclm=0.045979013+dpclmn   lpclm=7.3327998e-009
+ pdiblc1=0                 pdiblc2=0.0021186272      lpdiblc2=2.3660374e-009
+ pdiblcb=-0.03716          drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.44984             pditsd=1
+ pditsl=264000             rsh=16                    rsw=45+drdswn
+ rdw=45+drdswn             prwg=0                    prwb=0
+ wr=1                      alpha0=3.3929e-010        alpha1=0.0034
+ beta0=5.808               agidl=1.5797e-008         bgidl=1.4527e+009
+ cgidl=1.4892              egidl=0.81976             aigbacc=0.013432
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010744
+ bigc=0.000824385          cigc=-0.087762            aigsd=0.0093701
+ bigsd=0.0012397           cigsd=0.081703            nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=7.6133               noff=2.4067
+ voffcv=-0.12779           kt1=-0.23202777+dkt1n     lkt1=-1.1984574e-008+dlkt1n
+ kt1l=0                    kt2=-0.036650182+dkt2n    lkt2=-1.3442915e-009+dlkt2n
+ ute=-1                    ua1=2.1903258e-009+dua1n  lua1=1.6943242e-016+dlua1n
+ ub1=-1.5597811e-018+dub1n lub1=-3.5188146e-025+dlub1n
+ uc1=5.8453883e-11         luc1=-1.139502e-017       prt=0
+ at=226630.71+datn         lat=-0.025145252+dlatn    jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn
+ wvth0=0+dwvthn            pvth0=0+dpvthn            wk2=0+dwk2n
+ pk2=0+dpk2n               wcit=0+dwcitn             pcit=0+dpcitn
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ leta0=0+dleta0n           weta0=0+dweta0n           peta0=0+dpeta0n
+ wu0=0+dwu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ wvsat=0+dwvsatn           pvsat=0+dpvsatn           pags=0+dpagsn
+ ppclm=0+dppclmn           pat=0+dpatn               wvoff=0+dwvoffn
+ pvoff=0+dpvoffn           wa0=0+dwa0n               pa0=0+dpa0n
+ wkt1=0+dwkt1n             pkt1=0+dpkt1n             wkt2=0+dwkt2n
+ pkt2=0+dpkt2n             wua1=0+dwua1n             pua1=0+dpua1n
+ wub1=0+dwub1n             pub1=0+dpub1n             wat=0+dwatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     4: type=n 
+ lmin=1e-007-(dxln+dlmisn) lmax=2.399969e-007-(dxln+dlmisn)
+ wmin=1e-005-(dxwn+dwmisn) wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ k2=-0.0043418399+dk2n     kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lk2=1.8410081e-009+dlk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-7.4533297e-007       lcit=4.3580166e-010+dlcitn
+ voff=-0.12929504+dvoffn   lvoff=-2.5572859e-009+dlvoffn
+ nfactor=0.6+dnfactorn     eta0=0.12926747+deta0n    leta0=5.3032939e-013+dleta0n
+ etab=-0.057725876         letab=-2.5954944e-014     u0=0.022175644+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-2.4824008e-010+dlu0n ua=-1.4957211e-009
+ lua=-2.7074535e-017       ub=2.061055e-018          lub=7.6591956e-027
+ uc=7.960772e-11           luc=6.2842642e-018        vsat=101530+dvsatn
+ a0=0.3568378+da0n         la0=9.032121e-009+dla0n   kvsat=1
+ ags=6.2505817+dagsn       lags=-2.6890077e-007+dlagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.1                 dwg=0
+ dwb=0                     pclm=-0.11297214+dpclmn   lpclm=4.0594919e-008
+ pdiblc1=0                 pdiblc2=0.018665366       lpdiblc2=-1.096533e-009
+ pdiblcb=-0.03716          drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.44984             pditsd=1
+ pditsl=264000             rsh=16                    rsw=45+drdswn
+ rdw=45+drdswn             prwg=0                    prwb=0
+ wr=1                      alpha0=3.3929e-010        alpha1=0.0034

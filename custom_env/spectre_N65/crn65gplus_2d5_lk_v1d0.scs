+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.33744056           lkt1=1.0097023e-013       wkt1=-5.5983606e-009
+ pkt1=3.2131618e-028       kt1l=0                    kt2=-0.066289057
+ lkt2=-1.1297447e-015      wkt2=2.1355506e-008       pkt2=1.1305355e-020
+ ute=-1.6734967            wute=2.3513114e-007       ua1=1.0521577e-009
+ wua1=4.7675639e-016       ub1=-1.1817386e-018       lub1=-1.0097023e-030
+ wub1=-5.0416596e-025      pub1=-9.6454826e-046      uc1=1.1933187e-010
+ luc1=1.1297447e-023       wuc1=2.6099557e-017       puc1=-1.1305355e-028
+ prt=0                     at=158518.8               lat=1.0097023e-007
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    lvth0=0+dlvthn_25         wvth0=0+dwvthn_25
+ pvth0=0+dpvthn_25         lu0=0+dlu0n_25            pu0=0+dpu0n_25
+ lk2=0+dlk2n_25            pk2=0+dpk2n_25            minr=1e-3
 
 
     7: type=n 
+ lmin=1.2e-006-dxln_25     lmax=1e-005-dxln_25       wmin=1e-006-dxwn_25
+ wmax=1e-005-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.55634659+dvthn_25  lvth0=-1.344571e-008+dlvthn_25
+ k1=0.3969                 k2=0.078696834+dk2n_25    lk2=-7.9075717e-009+dlk2n_25
+ wk2=1.0465117e-008+dwk2n_25                         pk2=-1.5054785e-014+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8299998e-009
+ wkvth0we=-3.0000047e-010  pkvth0we=-1.0999931e-016  k2we=0.0040000001
+ lk2we=-1.0553389e-016     wk2we=3.9999997e-010      pk2we=-1.9999983e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=3.8754405e-005+dcitn_25
+ lcit=-1.2637175e-011+dlcitn_25                      wcit=1.0431858e-009+dwcitn_25
+ pcit=1.2646021e-016+dpcitn_25                       voff=-0.10595702
+ lvoff=1.8053107e-009      wvoff=-4.3005588e-010     pvoff=-1.8065744e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-2.0000001e-010
+ wku0we=-8.9999993e-010    pku0we=-5.0000108e-017    u0=0.031175052+du0n_25
+ lu0=4.7953379e-010+dlu0n_25                         wu0=-1.0205557e-009+dwu0n_25
+ pu0=-2.1076702e-015+dpu0n_25                        ua=-1.3189511e-009
+ wua=8.9573769e-017        ub=3.0224328e-018         lub=4.3440102e-026
+ wub=-1.5136567e-025       pub=-1.6560265e-031       uc=1.2886449e-010
+ luc=-6.0177023e-019       wuc=-3.8671948e-017       puc=6.0219147e-024
+ vsat=98400                a0=1.7938922              la0=-6.7078109e-007
+ wa0=-6.5672586e-008       pa0=-1.5054787e-014       ags=0.45791868
+ lags=-1.2035403e-008      wags=-7.9242247e-008      pags=1.2043828e-013
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.059940891         lketa=1.5044256e-009
+ wketa=1.9422494e-008      pketa=-1.5054787e-014     dwg=0
+ dwb=0                     pclm=0.50603487           lpclm=1.6548681e-008
+ wpclm=1.3974909e-007      ppclm=-1.6560265e-013     pdiblc1=0
+ pdiblc2=0.001019349       lpdiblc2=-6.0177023e-011  wpdiblc2=-8.440801e-010
+ ppdiblc2=6.0219147e-016   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25
+ cgdo=cgon_25              cgbo=0                    cgdl=cgln_25
+ cgsl=cgln_25              clc=1e-007                cle=0.6
+ cf=cfn_25                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.33613915           lkt1=-1.2994398e-008
+ wkt1=-5.14604e-009        pkt1=-4.516421e-015       kt1l=0
+ kt2=-0.066406624          lkt2=1.1739033e-009       wkt2=2.2531997e-008
+ pkt2=-1.174725e-014       ute=-1.7028392            lute=2.9298501e-007
+ wute=2.5925499e-007       pute=-2.4087659e-013      ua1=1.0508213e-009
+ lua1=1.3344255e-017       wua1=4.9013004e-016       pua1=-1.3353596e-022
+ ub1=-1.2253999e-018       lub1=4.3595714e-025       wub1=-4.7150831e-025
+ pub1=-3.2608665e-031      uc1=1.1827816e-010        luc1=1.052135e-017
+ wuc1=3.6644078e-017       puc1=-1.0528715e-022      prt=0
+ at=178717.68              lat=-0.20168567           fnoimod=1
+ tnoimod=0                 noia=noian_25             noib=noibn_25
+ noic=noicn_25             em=1.1200e+08             ef=1.00
+ jss=1.32e-7               jsd=1.32e-7               jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25                cjd=cjn_25                mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25            cjswd=cjswn_25            mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25          cjswgd=cjswgn_25          mjswgs=0.56
+ mjswgd=0.56               tpb=1.55e-3               tcj=8.5e-4
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=2.5e-3
+ tcjswg=1.68e-3            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ kvth0=-3.5e-08            lkvth0=2.5e-6             wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-8               lku0=7e-7                 wku0=20.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-9             tku0=0
+ wvth0=0+dwvthn_25         pvth0=0+dpvthn_25         minr=1e-3
 
 
     8: type=n 
+ lmin=7e-007-dxln_25       lmax=1.2e-006-dxln_25     wmin=1e-006-dxwn_25
+ wmax=1e-005-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.53614767+dvthn_25  lvth0=1.0490012e-008+dlvthn_25
+ wvth0=3.3746917e-008+dwvthn_25                      pvth0=-3.9990097e-014+dpvthn_25
+ k1=0.3969                 k2=0.071013996+dk2n_25    lk2=1.1965911e-009+dlk2n_25
+ wk2=5.1236222e-009+dwk2n_25                         pk2=-8.7251139e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8300005e-009
+ wkvth0we=-2.9999985e-010  pkvth0we=-1.1000003e-016  k2we=0.0039999998
+ lk2we=1.4784218e-016      wk2we=4.000001e-010       pk2we=-2.0000138e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-2.78615e-005+dcitn_25
+ lcit=6.6302672e-011+dlcitn_25                       wcit=1.2299755e-009+dwcitn_25
+ pcit=-9.4885594e-017+dpcitn_25                      voff=-0.11357329
+ lvoff=1.083058e-008       wvoff=-6.4717017e-009     pvoff=-1.0906394e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000001       lku0we=-1.9999994e-010
+ wku0we=-9.0000004e-010    pku0we=-4.9999982e-017    u0=0.031717681+du0n_25
+ lu0=-1.6348142e-010+dlu0n_25                        wu0=-4.179736e-009+dwu0n_25
+ pu0=1.6359585e-015+dpu0n_25                         ua=-1.3189511e-009
+ wua=8.9573769e-017        ub=2.9845555e-018         lub=8.8324699e-026
+ wub=-3.6781229e-025       pub=9.0886584e-032        uc=1.1617036e-010
+ luc=1.4440769e-017        wuc=-2.1318549e-017       puc=-1.4541863e-023
+ vsat=98400                a0=1.2016774              la0=3.0993464e-008
+ wa0=3.2045016e-007        pa0=-4.7261024e-013       ags=0.51166359
+ lags=-7.5723121e-008      wags=6.841194e-008        pags=-5.4531933e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.058671333         wketa=6.7180327e-009
+ dwg=0                     dwb=0                     pclm=0.51693424
+ lpclm=3.6329222e-009      wpclm=3.0679042e-008      ppclm=-3.6354652e-014
+ pdiblc1=0                 pdiblc2=0.0011055667      lpdiblc2=-1.6234502e-010
+ wpdiblc2=-3.3590168e-010  ppdiblc2=3.6354634e-023   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25              cgdo=cgon_25              cgbo=0
+ cgdl=cgln_25              cgsl=cgln_25              clc=1e-007
+ cle=0.6                   cf=cfn_25                 ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.33628859
+ lkt1=-1.2817315e-008      wkt1=-2.1228941e-008      pkt1=1.4541817e-014
+ kt1l=0                    kt2=-0.059202923          lkt2=-7.3624825e-009
+ wkt2=-2.0105814e-009      pkt2=1.7335705e-014       ute=-1.2875843
+ lute=-1.9909199e-007      wute=-2.5433464e-007      pute=3.6772712e-013
+ ua1=1.3133996e-009        lua1=-2.9781105e-016      wua1=5.0970722e-017
+ pua1=3.8686784e-022       ub1=-2.6331125e-019       lub1=-7.0411789e-025
+ wub1=-9.775158e-025       pub1=2.7353223e-031       uc1=1.6313473e-010
+ luc1=-4.2633686e-017      wuc1=3.0309966e-017       puc1=-9.778123e-023
+ prt=0                     at=10051.679              lat=-0.0018164611
+ wat=-0.015339508          pat=1.8177317e-008        fnoimod=1
+ tnoimod=0                 noia=noian_25             noib=noibn_25
+ noic=noicn_25             em=1.1200e+08             ef=1.00
+ jss=1.32e-7               jsd=1.32e-7               jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25                cjd=cjn_25                mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25            cjswd=cjswn_25            mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25          cjswgd=cjswgn_25          mjswgs=0.56
+ mjswgd=0.56               tpb=1.55e-3               tcj=8.5e-4
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=2.5e-3
+ tcjswg=1.68e-3            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ kvth0=-3.5e-08            lkvth0=2.5e-6             wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-8               lku0=7e-7                 wku0=20.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-9             tku0=0
+ minr=1e-3
 
 
     9: type=n 
+ lmin=3.8e-007-dxln_25     lmax=7e-007-dxln_25       wmin=1e-006-dxwn_25
+ wmax=1e-005-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.54080508+dvthn_25  lvth0=7.2996882e-009+dlvthn_25
+ wvth0=-9.3072744e-009+dwvthn_25                     pvth0=-1.0497976e-014+dpvthn_25
+ k1=0.3969                 k2=0.079107675+dk2n_25    lk2=-4.3475788e-009+dlk2n_25
+ wk2=-2.2045294e-008+dwk2n_25                        pk2=9.8855938e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.83e-009
+ wkvth0we=-2.999993e-010   pkvth0we=-1.1000041e-016  k2we=0.0040000001
+ lk2we=-4.0759284e-017     wk2we=3.9999984e-010      pk2we=-1.9999956e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00030758564+dcitn_25
+ lcit=2.5791371e-010+dlcitn_25                       wcit=1.1039722e-009+dwcitn_25
+ pcit=-8.5733644e-018+dpcitn_25                      voff=-0.096741231
+ lvoff=-6.9937722e-010     wvoff=-3.2610455e-008     pvoff=6.9986522e-015
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-2.0000001e-010
+ wku0we=-8.9999998e-010    pku0we=-5.0000021e-017    u0=0.024873764+du0n_25
+ lu0=4.5246017e-009+dlu0n_25                         wu0=1.5290522e-009+dwu0n_25
+ pu0=-2.2745614e-015+dpu0n_25                        ua=-1.395046e-009
+ lua=5.2125004e-017        wua=1.6620133e-016        pua=-5.2489879e-023
+ ub=2.6000557e-018         lub=3.5170704e-025        wub=-5.248463e-027
+ pub=-1.5746964e-031       uc=1.0300908e-010         luc=2.3456252e-017
+ wuc=-8.0651463e-018       puc=-2.3620444e-023       vsat=98400
+ a0=1.3964808              la0=-1.0244687e-007       wa0=-3.8226302e-007
+ pa0=8.7482869e-015        ags=0.47186932            lags=-4.8464047e-008
+ wags=3.0808479e-007       pags=-2.1870783e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.056756985         lketa=-1.3113283e-009     wketa=-1.2438859e-008
+ pketa=1.3122471e-014      dwg=0                     dwb=0
+ pclm=0.61731648           lpclm=-6.5128908e-008     wpclm=-6.0707222e-008
+ ppclm=2.6244939e-014      pdiblc1=0                 pdiblc2=0.0012490413
+ lpdiblc2=-2.6062508e-010  wpdiblc2=-7.190394e-010   ppdiblc2=2.6244938e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.37847456           lkt1=1.6080071e-008       wkt1=4.0868008e-008
+ pkt1=-2.7994593e-014      kt1l=0                    kt2=-0.067191633
+ lkt2=-1.890216e-009       wkt2=5.5794486e-009       pkt2=1.2136535e-014
+ ute=-1.8068876            lute=1.5663077e-007       wute=6.3025468e-007
+ pute=-2.3821657e-013      ua1=7.4572584e-010        lua1=9.1045476e-017
+ wua1=9.330177e-016        pua1=-2.1733434e-022      ub1=-6.7427997e-019
+ lub1=-4.2260431e-025      wub1=-1.2377067e-024      pub1=4.5176298e-031
+ uc1=1.8276753e-010        luc1=-5.6082156e-017      wuc1=-1.9488123e-016
+ puc1=5.6474737e-023       prt=0                     at=-19241.287
+ lat=0.018249221           wat=0.0495105             pat=-2.6244939e-008
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     10: type=n 
+ lmin=2.8e-07              lmax=3.8e-007-dxln_25     wmin=1e-006-dxwn_25
+ wmax=1e-005-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.75758999+dvthn_25  lvth0=-7.1826804e-008+dlvthn_25
+ wvth0=-1.7752404e-007+dwvthn_25                     pvth0=5.0901145e-014+dpvthn_25
+ k1=0.3969                 k2=0.055612499+dk2n_25    lk2=4.2281602e-009+dlk2n_25
+ wk2=-1.958867e-008+dwk2n_25                         pk2=8.9889258e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8300002e-009
+ wkvth0we=-3.0000175e-010  pkvth0we=-1.0999952e-016  k2we=0.0040000001
+ lk2we=-3.5498075e-017     wk2we=3.9999974e-010      pk2we=-1.9999922e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00096605782+dcitn_25
+ lcit=4.9825605e-010+dlcitn_25                       wcit=3.2583578e-009+dwcitn_25
+ pcit=-7.9492409e-016+dpcitn_25                      voff=-0.28241539
+ lvoff=6.7071691e-008      wvoff=2.2169508e-008      pvoff=-1.2996034e-014
+ nfactor=0.55              eta0=-0.029791196         leta0=1.3891214e-007
+ weta0=-1.4835656e-007     peta0=5.4150143e-014      etab=-0.15951067
+ letab=1.9881793e-008      wetab=1.471697e-008       petab=-5.3716941e-015
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0019999998       lku0we=-2.0000006e-010
+ wku0we=-9.0000043e-010    pku0we=-4.9999859e-017    u0=0.035918993+du0n_25
+ lu0=4.930933e-010+dlu0n_25                          wu0=-9.7467457e-009+dwu0n_25
+ pu0=1.8411048e-015+dpu0n_25                         ua=-1.7531437e-009
+ lua=1.8283067e-016        wua=5.2680573e-016        pua=-1.8411048e-022
+ ub=3.4759835e-018         lub=3.1993406e-026        wub=-1.4158254e-024
+ pub=3.5739094e-031        uc=3.0985397e-010         luc=-5.2042135e-017
+ wuc=-1.7366118e-016       puc=3.6822109e-023        vsat=98400
+ a0=1.4604899              la0=-1.2581019e-007       wa0=-6.2533709e-007
+ pa0=9.7470321e-014        ags=1.7880671             lags=-5.2887623e-007
+ wags=-7.361845e-007       pags=1.6245046e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.1761862           lketa=4.2280335e-008      wketa=6.8910227e-008
+ pketa=-1.6569946e-014     dwg=0                     dwb=0
+ pclm=1.121951             lpclm=-2.4932051e-007     wpclm=7.0539343e-008
+ ppclm=-2.1660057e-014     pdiblc1=0                 pdiblc2=0.00053499982
+ lpdiblc2=4.7280255e-017   wpdiblc2=-4.0868033e-017  ppdiblc2=1.0830028e-023
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.27489647           lkt1=-2.172593e-008       wkt1=-1.0110639e-007
+ pkt1=2.3826063e-014       kt1l=0                    kt2=-0.176371
+ lkt2=3.7960252e-008       wkt2=1.8289336e-007       pkt2=-5.2583042e-014
+ ute=-1.2773213            lute=-3.6660924e-008      wute=-4.9713442e-007
+ pute=1.7328046e-013       ua1=4.3820359e-011        lua1=3.4724098e-016
+ wua1=1.390319e-015        pua1=-3.842493e-022       ub1=-1.2604713e-018
+ lub1=-2.0864449e-025      wub1=4.7444467e-025       pub1=-1.7317226e-031
+ uc1=1.5592656e-010        luc1=-4.6285202e-017      wuc1=-1.6785234e-016
+ puc1=4.6609195e-023       prt=0                     at=86777.292
+ lat=-0.020447561          wat=-0.13217729           pat=4.0071106e-008
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     11: type=n 
+ lmin=1e-005-dxln_25       lmax=0.000901             wmin=6e-007-dxwn_25
+ wmax=1e-006-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.5474125+dvthn_25   wvth0=7.6406125e-009+dwvthn_25
+ k1=0.3969                 k2=0.083765+dk2n_25       wk2=3.056245e-009+dwk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8299932e-009
+ wkvth0we=-2.9999951e-010  pkvth0we=-1.0999682e-016  k2we=0.004
+ lk2we=1.3656223e-015      wk2we=4.0000004e-010      pk2we=-2.0001245e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0009039+dcitn_25
+ wcit=1.833747e-010+dwcitn_25                        voff=-0.0973775
+ wvoff=-1.0696858e-008     nfactor=0.55              eta0=0.35079
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.002
+ lku0we=-1.9999869e-010    wku0we=-9.0000004e-010    pku0we=-5.0000798e-017
+ u0=0.03+du0n_25           ua=-1.23e-009             ub=2.814475e-018
+ wub=4.5843675e-026        uc=1.1983249e-010         luc=6.6160743e-023
+ wuc=-2.9034323e-017       puc=-4.6288462e-029       vsat=98400
+ a0=1.66                   ags=0.405175              wags=-1.5281225e-008
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.042               dwg=0
+ dwb=0                     pclm=0.84245              lpclm=1.0097023e-013
+ wpclm=-2.1393715e-007     ppclm=6.9174826e-027      pdiblc1=0
+ pdiblc2=0.00038674995     lpdiblc2=1.1177404e-015   wpdiblc2=-1.5281222e-010
+ ppdiblc2=-6.171795e-022   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25
+ cgdo=cgon_25              cgbo=0                    cgdl=cgln_25
+ cgsl=cgln_25              clc=1e-007                cle=0.6
+ cf=cfn_25                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.339965             lkt1=2.5419255e-013
+ wkt1=-3.0562448e-009      pkt1=-1.5429488e-019      kt1l=0
+ kt2=-0.046397673          lkt2=2.5419255e-014       wkt2=1.3248822e-009
+ pkt2=-1.5429488e-020      ute=-1.273075             wute=-1.6809348e-007
+ ua1=1.4987404e-009        lua1=-1.5322232e-021      wua1=2.7047614e-017
+ pua1=1.5429488e-027       ub1=-1.1011973e-018       lub1=-1.0097023e-030
+ wub1=-5.8527107e-025      pub1=3.0447557e-045       uc1=3.058015e-010
+ luc1=-2.8483701e-022      wuc1=-1.6167536e-016      puc1=1.8515385e-028
+ prt=0                     at=219218.8               lat=1.0097023e-007
+ wat=-0.0611249            pat=-3.0448487e-022       fnoimod=1
+ tnoimod=0                 noia=noian_25             noib=noibn_25
+ noic=noicn_25             em=1.1200e+08             ef=1.00
+ jss=1.32e-7               jsd=1.32e-7               jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25                cjd=cjn_25                mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25            cjswd=cjswn_25            mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25          cjswgd=cjswgn_25          mjswgs=0.56
+ mjswgd=0.56               tpb=1.55e-3               tcj=8.5e-4
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=2.5e-3
+ tcjswg=1.68e-3            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ kvth0=-3.5e-08            lkvth0=2.5e-6             wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-8               lku0=7e-7                 wku0=20.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-9             tku0=0
+ lvth0=0+dlvthn_25         pvth0=0+dpvthn_25         lu0=0+dlu0n_25
+ wu0=0+dwu0n_25            pu0=0+dpu0n_25            lcit=0+dlcitn_25
+ pcit=0+dpcitn_25          lk2=0+dlk2n_25            pk2=0+dpk2n_25
+ minr=1e-3
 
 
     12: type=n 
+ lmin=1.2e-006-dxln_25     lmax=1e-005-dxln_25       wmin=6e-007-dxwn_25
+ wmax=1e-006-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.54651129+dvthn_25  lvth0=8.9985416e-009+dlvthn_25
+ wvth0=9.904144e-009+dwvthn_25                       pvth0=-2.2601362e-014+dpvthn_25
+ k1=0.3969                 k2=0.086401591+dk2n_25    lk2=-2.6326361e-008+dlk2n_25
+ wk2=2.7064267e-009+dwk2n_25                         pk2=3.4929356e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.014999999       lkvth0we=5.8300013e-009
+ wkvth0we=-2.9999911e-010  pkvth0we=-1.1000083e-016  k2we=0.0040000001
+ lk2we=-3.4757162e-016     wk2we=3.9999989e-010      pk2we=-1.9999739e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00088237138+dcitn_25
+ lcit=2.1496329e-010+dlcitn_25                       wcit=1.9366348e-010+dwcitn_25
+ pcit=-1.0273346e-016+dpcitn_25                      voff=-0.09412683
+ lvoff=-3.2457945e-008     wvoff=-1.2343062e-008     pvoff=1.6437354e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0019999998       lku0we=-2.0000036e-010
+ wku0we=-9.0000014e-010    pku0we=-4.9999759e-017    u0=0.030406805+du0n_25
+ lu0=-4.0619491e-009+dlu0n_25                        wu0=-2.469307e-010+dwu0n_25
+ pu0=2.4656031e-015+dpu0n_25                         ua=-1.23e-009
+ ub=2.8490723e-018         lub=-3.4545391e-025       wub=2.3208361e-026
+ pub=2.2601362e-031        uc=1.1964125e-010         luc=1.909627e-018
+ wuc=-2.9384146e-017       puc=3.4929377e-024        vsat=98400
+ a0=1.6898506              la0=-2.9805788e-007       wa0=3.9097351e-008
+ pa0=-3.9038705e-013       ags=0.38111984            lags=2.4019075e-007
+ wags=-1.905816e-009       pags=-1.3355346e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.040653409         lketa=-1.344571e-008      dwg=0
+ dwb=0                     pclm=0.900175             lpclm=-5.7638398e-007
+ wpclm=-2.5715002e-007     ppclm=4.3148054e-013      pdiblc1=0
+ pdiblc2=0.00031245191     lpdiblc2=7.4186706e-010   wpdiblc2=-1.3223472e-010
+ ppdiblc2=-2.0546692e-016  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25
+ cgdo=cgon_25              cgbo=0                    cgdl=cgln_25
+ cgsl=cgln_25              clc=1e-007                cle=0.6
+ cf=cfn_25                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.33695155           lkt1=-3.0089012e-008
+ wkt1=-4.3279534e-009      pkt1=1.2697856e-014       kt1l=0
+ kt2=-0.04375242           lkt2=-2.6412824e-008      wkt2=-2.8078622e-010
+ pkt2=1.6032584e-014       ute=-1.2478096            lute=-2.5227514e-007
+ wute=-1.9895981e-007      pute=3.0820039e-013       ua1=1.5070676e-009
+ lua1=-8.3148608e-017      wua1=3.0689996e-017       pua1=-3.6367645e-023
+ ub1=-1.0205339e-018       lub1=-8.0542439e-025      wub1=-6.7780833e-025
+ pub1=9.2398455e-031       uc1=3.2584575e-010        luc1=-2.0014217e-016
+ wuc1=-1.7237649e-016      puc1=1.0685102e-022       prt=0
+ at=253721.84              lat=-0.34451272           wat=-0.075529191
+ pat=1.4382685e-007        fnoimod=1                 tnoimod=0
+ noia=noian_25             noib=noibn_25             noic=noicn_25
+ em=1.1200e+08             ef=1.00                   jss=1.32e-7
+ jsd=1.32e-7               jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25
+ cjd=cjn_25                mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25
+ cjswd=cjswn_25            mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25
+ cjswgd=cjswgn_25          mjswgs=0.56               mjswgd=0.56
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=2.5e-3             tcjswg=1.68e-3
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 kvth0=-3.5e-08
+ lkvth0=2.5e-6             wkvth0=6.8e-006           pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 lodeta0=1                 ku0=-6.6e-8
+ lku0=7e-7                 wku0=20.8e-07             pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=0
+ steta0=8.5e-9             tku0=0                    minr=1e-3
 
 
     13: type=n 
+ lmin=7e-007-dxln_25       lmax=1.2e-006-dxln_25     wmin=6e-007-dxwn_25
+ wmax=1e-006-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.5974758+dvthn_25   lvth0=-5.1394393e-008+dlvthn_25
+ wvth0=-2.8010506e-008+dwvthn_25                     pvth0=2.2327499e-014+dpvthn_25
+ k1=0.3969                 k2=0.066745101+dk2n_25    lk2=-3.0334204e-009+dlk2n_25
+ wk2=9.4223997e-009+dwk2n_25                         pk2=-4.4654924e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015             lkvth0we=5.8300004e-009
+ wkvth0we=-2.9999979e-010  pkvth0we=-1.1000002e-016  k2we=0.0039999999
+ lk2we=-3.0033828e-017     wk2we=4.0000007e-010      pk2we=-1.9999959e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0010835969+dcitn_25
+ lcit=-2.3488886e-011+dlcitn_25                      wcit=1.1073693e-010+dwcitn_25
+ pcit=-4.4654949e-018+dpcitn_25                      voff=-0.13607033
+ lvoff=1.7245098e-008      wvoff=1.6182817e-008      pvoff=-1.7365813e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000003       lku0we=-1.9999978e-010
+ wku0we=-8.9999982e-010    pku0we=-5.0000146e-017    u0=0.024498615+du0n_25
+ lu0=2.9392562e-009+dlu0n_25                         wu0=3.0898637e-009+dwu0n_25
+ pu0=-1.4884983e-015+dpu0n_25                        ua=-1.23e-009
+ ub=2.157373e-018          lub=4.7420975e-025        wub=4.6516049e-025
+ pub=-2.9769966e-031       uc=1.3164763e-010         luc=-1.2317935e-017
+ wuc=-3.6904158e-017       puc=1.2404152e-023        vsat=98400
+ a0=1.8705942              la0=-5.1223906e-007       wa0=-3.5314903e-007
+ pa0=7.4424914e-014        ags=0.87012528            lags=-3.3928069e-007
+ wags=-2.9255898e-007      pags=2.1087054e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.066552821         lketa=1.7245093e-008      wketa=1.4654691e-008
+ pketa=-1.7365808e-014     dwg=0                     dwb=0
+ pclm=0.108539             lpclm=3.6170467e-007      wpclm=4.4193305e-007
+ ppclm=-3.969329e-013      pdiblc1=0                 pdiblc2=0.0014912949
+ lpdiblc2=-6.5506194e-010  wpdiblc2=-7.2432999e-010  ppdiblc2=4.9616597e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.38034488           lkt1=2.1332076e-008       wkt1=2.3135738e-008
+ pkt1=-1.9846619e-014      kt1l=0                    kt2=-0.070749227
+ lkt2=5.5783933e-009       wkt2=9.6165477e-009       pkt2=4.3042434e-015
+ ute=-1.8966891            lute=5.1664713e-007       wute=3.5903391e-007
+ pute=-3.5302218e-013      ua1=1.2902124e-009        lua1=1.7382482e-016
+ wua1=7.4320238e-017       pua1=-8.8069482e-023      ub1=-1.6818137e-018
+ lub1=-2.1807891e-026      wub1=4.5091614e-025       pub1=-4.1355394e-031
+ uc1=4.2398969e-010        luc1=-3.1644274e-016      wuc1=-2.3237099e-016
+ puc1=1.7794449e-022       prt=0                     at=-113075.45
+ lat=0.09014206            wat=0.10864951            pat=-7.4424915e-008
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     14: type=n 
+ lmin=3.8e-007-dxln_25     lmax=7e-007-dxln_25       wmin=6e-007-dxwn_25
+ wmax=1e-006-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.51835548+dvthn_25  lvth0=2.8030265e-009+dlvthn_25
+ wvth0=1.3299474e-008+dwvthn_25                      pvth0=-5.9698374e-015+dpvthn_25
+ k1=0.3969                 k2=0.053813106+dk2n_25    lk2=5.8249965e-009+dlk2n_25
+ wk2=3.4263372e-009+dwk2n_25                         pk2=-3.5818953e-016+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8299996e-009
+ wkvth0we=-2.9999982e-010  pkvth0we=-1.1e-016        k2we=0.0039999997
+ lk2we=1.1133926e-016      wk2we=4.0000029e-010      pk2we=-2.0000109e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00017598868+dcitn_25
+ lcit=5.9822271e-010+dlcitn_25                       wcit=6.1701289e-010+dwcitn_25
+ pcit=-3.5126453e-016+dpcitn_25                      voff=-0.12867449
+ lvoff=1.2178952e-008      wvoff=-4.5366137e-010     pvoff=-5.9698254e-015
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0019999998       lku0we=-2.0000011e-010
+ wku0we=-9.0000015e-010    pku0we=-4.9999915e-017    u0=0.022366069+du0n_25
+ lu0=4.4000505e-009+dlu0n_25                         wu0=4.0543018e-009+dwu0n_25
+ pu0=-2.1491384e-015+dpu0n_25                        ua=-1.23e-009
+ ub=2.270241e-018          lub=3.9689515e-025        wub=3.2687495e-025
+ pub=-2.0297407e-031       uc=1.1366525e-010         luc=-1.99434e-024
+ wuc=-1.8795912e-017       puc=3.5818953e-030        vsat=98400
+ a0=1.0519672              la0=4.8520453e-008        wa0=-3.5337756e-008
+ pa0=-1.4327581e-013       ags=0.38183983            lags=-4.805158e-009
+ wags=3.9874449e-007       pags=-2.6267234e-013      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.032523411         lketa=-6.0650533e-009     wketa=-3.6842068e-008
+ pketa=1.7909472e-014      dwg=0                     dwb=0
+ pclm=0.79746021           lpclm=-1.1020636e-007     wpclm=-2.4211196e-007
+ ppclm=7.1637929e-014      pdiblc1=0                 pdiblc2=0.00053500049
+ lpdiblc2=-2.3226932e-016  wpdiblc2=-3.3356049e-016  ppdiblc2=1.5521546e-022
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.30817277           lkt1=-2.8105818e-008      wkt1=-2.9925892e-008
+ pkt1=1.6500598e-014       kt1l=0                    kt2=-0.10445469
+ lkt2=2.8666636e-008       wkt2=4.3103349e-008       pkt2=-1.8634216e-014
+ ute=-0.67163199           lute=-3.2251701e-007      wute=-5.1294775e-007
+ pute=2.4428526e-013       ua1=1.8796598e-009        lua1=-2.2994663e-016
+ wua1=-2.0885376e-016      pua1=1.059047e-022        ub1=-1.780366e-018
+ lub1=4.5700469e-026       wub1=-1.2387803e-025      pub1=-1.981994e-032
+ uc1=-1.4350135e-010       luc1=7.2288626e-017       wuc1=1.3367154e-016
+ puc1=-7.279464e-023       prt=0                     at=47234.028
+ lat=-0.019669931          wat=-0.017430143          pat=1.1939648e-008
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     15: type=n 
+ lmin=2.8e-07              lmax=3.8e-007-dxln_25     wmin=6e-007-dxwn_25
+ wmax=1e-006-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.70497614+dvthn_25  lvth0=-6.5313517e-008+dlvthn_25
+ wvth0=-1.245419e-007+dwvthn_25                      pvth0=4.4342265e-014+dpvthn_25
+ k1=0.3969                 k2=0.053034593+dk2n_25    lk2=6.1091534e-009+dlk2n_25
+ wk2=-1.6992718e-008+dwk2n_25                        pk2=7.0947657e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.014999994       lkvth0we=5.8300021e-009
+ wkvth0we=-2.9999597e-010  pkvth0we=-1.1000141e-016  k2we=0.0039999999
+ lk2we=4.2800782e-017      wk2we=3.9999999e-010      pk2we=-2.0000001e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0031675552+dcitn_25
+ lcit=-4.9369906e-010+dlcitn_25                      wcit=-9.0419049e-010+dwcitn_25
+ pcit=2.039747e-016+dpcitn_25                        voff=-0.33257987
+ lvoff=8.6604416e-008      wvoff=7.2685139e-008      pvoff=-3.2665487e-014
+ nfactor=0.55              eta0=-0.37818526          leta0=2.6607597e-007
+ weta0=2.0247627e-007      peta0=-7.3903839e-014     etab=-0.14489599
+ letab=1.4547438e-008      wetab=-4.049524e-015      petab=1.4780769e-021
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000006       lku0we=-1.9999984e-010
+ wku0we=-8.9999971e-010    pku0we=-5.0000076e-017    u0=0.035701614+du0n_25
+ lu0=-4.6742356e-010+dlu0n_25                        wu0=-9.5278453e-009+dwu0n_25
+ pu0=2.8083453e-015+dpu0n_25                         ua=-1.23e-009
+ ub=2.78019e-018           lub=2.1076378e-025        wub=-7.1516133e-025
+ pub=1.7736918e-031        uc=2.2040717e-010         luc=-3.8960805e-017
+ wuc=-8.3588256e-017       puc=2.3649209e-023        vsat=86335.875
+ lvsat=0.0044034056        wvsat=0.012148574         pvsat=-4.4342295e-009
+ a0=1.1719076              la0=4.7421916e-009        wa0=-3.3473471e-007
+ pa0=-3.3995922e-014       ags=2.3005912             lags=-7.051494e-007
+ wags=-1.2522963e-006      pags=3.3995754e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.15890233          lketa=4.006325e-008       wketa=5.1505366e-008
+ pketa=-1.4337342e-014     dwg=0                     dwb=0
+ pclm=1.4788075            lpclm=-3.5889811e-007     wpclm=-2.8881514e-007
+ ppclm=8.8684589e-014      pdiblc1=0                 pdiblc2=0.00053499945
+ lpdiblc2=1.4610311e-016   wpdiblc2=3.3465882e-016   ppdiblc2=-8.8684588e-023
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.39047504           lkt1=1.9345097e-009       wkt1=1.5281225e-008
+ pkt1=4.8510309e-028       kt1l=0                    kt2=0.018139607
+ lkt2=-1.6080283e-008      wkt2=-1.2978822e-008      pkt2=1.8357769e-015
+ ute=-2.7799786            lute=4.4702949e-007       wute=1.0160414e-006
+ pute=-3.1379579e-013      ua1=1.2013867e-009        lua1=1.7623055e-017
+ wua1=2.2464969e-016       pua1=-5.2324056e-023      ub1=7.0848031e-020
+ lub1=-6.2999266e-025      wub1=-8.6619388e-025      pub1=2.5112534e-031
+ uc1=9.781575e-011         luc1=-1.5792117e-017      wuc1=-1.0933476e-016
+ puc1=1.5902658e-023       prt=0                     at=-140083.69
+ lat=0.048701035           wat=0.096271715           pat=-2.956153e-008
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     16: type=n 
+ lmin=1e-005-dxln_25       lmax=0.000901             wmin=4e-07
+ wmax=6e-007-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.566105+dvthn_25    lvth0=2.0547441e-013+dlvthn_25
+ wvth0=-3.7057349e-009+dwvthn_25                     pvth0=-1.2472297e-019+dpvthn_25
+ k1=0.3969                 k2=0.082695+dk2n_25       wk2=3.705735e-009+dwk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8300078e-009
+ wkvth0we=-3.0000031e-010  pkvth0we=-1.1000566e-016  k2we=0.0040000001
+ lk2we=-1.7922216e-015     wk2we=3.9999999e-010      pk2we=-1.9999328e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00109611+dcitn_25
+ wcit=6.670323e-011+dwcitn_25                        voff=-0.112965
+ wvoff=-1.235245e-009      nfactor=0.55              eta0=0.35079
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.0020000002
+ lku0we=-1.9999969e-010    wku0we=-8.9999991e-010    pku0we=-5.0000191e-017
+ u0=0.031628+du0n_25       wu0=-9.88196e-010+dwu0n_25
+ ua=-1.23e-009             ub=2.89e-018              uc=8.0140003e-011
+ luc=-3.0644465e-023       wuc=-4.9409813e-018       puc=1.2472297e-029
+ vsat=98400                a0=1.66                   ags=0.35965
+ wags=1.235245e-008        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.03386
+ wketa=-4.94098e-009       dwg=0                     dwb=0
+ pclm=0.46965              lpclm=3.0644464e-013      wpclm=1.235245e-008
+ ppclm=-1.2472297e-019     pdiblc1=0                 pdiblc2=0.000135
+ lpdiblc2=3.0644464e-016   wpdiblc2=1.3858336e-019   ppdiblc2=-1.2472297e-022
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.355175             wkt1=6.176225e-009        kt1l=0
+ kt2=-0.03715762           lkt2=-2.0547442e-014      wkt2=-4.2838297e-009
+ pkt2=1.2472297e-020       ute=-1.69245              wute=8.646715e-008
+ ua1=1.7598237e-009        lua1=3.0644464e-021       wua1=-1.3142994e-016
+ pua1=-1.2472297e-027      ub1=-2.8108205e-018       lub1=-5.1191905e-030
+ wub1=4.5247024e-025       pub1=2.4944594e-036       uc1=-6.6376104e-011
+ luc1=8.1836369e-023       wuc1=6.4236446e-017       puc1=-3.741689e-029
+ prt=0                     at=118518.8               lat=3.0644464e-007
+ wat=1.3858336e-010        pat=-1.2472297e-013       fnoimod=1
+ tnoimod=0                 noia=noian_25             noib=noibn_25
+ noic=noicn_25             em=1.1200e+08             ef=1.00
+ jss=1.32e-7               jsd=1.32e-7               jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25                cjd=cjn_25                mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25            cjswd=cjswn_25            mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25          cjswgd=cjswgn_25          mjswgs=0.56
+ mjswgd=0.56               tpb=1.55e-3               tcj=8.5e-4
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=2.5e-3
+ tcjswg=1.68e-3            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ kvth0=-3.5e-08            lkvth0=2.5e-6             wkvth0=6.8e-006
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 lodeta0=1
+ ku0=-6.6e-8               lku0=7e-7                 wku0=20.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=0                   steta0=8.5e-9             tku0=0
+ lu0=0+dlu0n_25            pu0=0+dpu0n_25            lcit=0+dlcitn_25
+ pcit=0+dpcitn_25          lk2=0+dlk2n_25            pk2=0+dpk2n_25
+ minr=1e-3
 
 
     17: type=n 
+ lmin=1.2e-006-dxln_25     lmax=1e-005-dxln_25       wmin=4e-07
+ wmax=6e-007-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.57660574+dvthn_25  lvth0=-1.0484965e-007+dlvthn_25
+ wvth0=-8.3631825e-009+dwvthn_25                     pvth0=4.650449e-014+dpvthn_25
+ k1=0.3969                 k2=0.086481681+dk2n_25    lk2=-3.7810009e-008+dlk2n_25
+ wk2=2.6578121e-009+dwk2n_25                         pk2=1.046351e-014+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000002       lkvth0we=5.8299995e-009
+ wkvth0we=-3.000009e-010   pkvth0we=-1.0999973e-016  k2we=0.0039999999
+ lk2we=2.2387108e-016      wk2we=4.0000006e-010      pk2we=-2.0000086e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00095341983+dcitn_25
+ lcit=1.4247614e-009+dlcitn_25                       wcit=1.5053707e-010+dwcitn_25
+ pcit=-8.370809e-016+dpcitn_25                       voff=-0.12475777
+ lvoff=1.1775081e-007      wvoff=6.2499186e-009      pvoff=-7.4739359e-014
+ nfactor=0.55              eta0=0.35079              etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.0020000002       lku0we=-1.9999974e-010
+ wku0we=-8.9999991e-010    pku0we=-5.0000133e-017    u0=0.031847225+du0n_25
+ lu0=-2.1889616e-009+dlu0n_25                        wu0=-1.1212656e-009+dwu0n_25
+ pu0=1.3286997e-015+dpu0n_25                         ua=-1.23e-009
+ ub=2.8653843e-018         lub=2.4578758e-025        wub=1.3306958e-026
+ pub=-1.3286997e-031       uc=8.0550778e-011         luc=-4.1016139e-018
+ wuc=-5.656229e-018        puc=7.1417609e-024        vsat=98400
+ a0=1.7570017              la0=-9.6856159e-007       wa0=-1.6633647e-009
+ pa0=1.6608697e-014        ags=0.37818246            lags=-1.8504657e-007
+ wags=-1.2282266e-010      pags=1.245656e-013        a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.032239378         lketa=-1.6181912e-008     wketa=-5.107317e-009
+ pketa=1.6608746e-015      dwg=0                     dwb=0
+ pclm=0.4507035            lpclm=1.8918114e-007      wpclm=1.5679177e-008
+ ppclm=-3.3217493e-014     pdiblc1=0                 pdiblc2=0.00012200543
+ lpdiblc2=1.2975113e-010   wpdiblc2=-1.6633708e-011  ppdiblc2=1.6608745e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.34730171           lkt1=-7.8614782e-008      wkt1=1.9545927e-009
+ pkt1=4.2152998e-014       kt1l=0                    kt2=-0.033355987
+ lkt2=-3.7959331e-008      wkt2=-6.5914212e-009      pkt2=2.3041314e-014
+ ute=-1.7344771            lute=4.1964062e-007       wute=9.6447368e-008
+ pute=-9.9652478e-014      ua1=1.8421937e-009        lua1=-8.2246132e-016
+ wua1=-1.7273154e-016      pua1=4.1239517e-022       ub1=-3.0926253e-018
+ lub1=2.8138156e-024       wub1=5.7995113e-025       pub1=-1.2728942e-030
+ uc1=-8.2142869e-011       luc1=1.5743123e-016       wuc1=7.52726e-017
+ puc1=-1.1019604e-022      prt=0                     at=121070.62
+ lat=-0.025479638          wat=0.0049900964          pat=-4.9826236e-008
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     18: type=n 
+ lmin=7e-007-dxln_25       lmax=1.2e-006-dxln_25     wmin=4e-07
+ wmax=6e-007-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.35826947+dvthn_25  lvth0=1.5387882e-007+dlvthn_25
+ wvth0=1.1718773e-007+dwvthn_25                      pvth0=-1.0227334e-013+dpvthn_25
+ k1=0.3969                 k2=0.065294059+dk2n_25    lk2=-1.2702678e-008+dlk2n_25
+ wk2=1.0303182e-008+dwk2n_25                         pk2=1.4037469e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000001       lkvth0we=5.8300003e-009
+ wkvth0we=-3.0000073e-010  pkvth0we=-1.0999993e-016  k2we=0.004
+ lk2we=1.06336e-016        wk2we=4.0000003e-010      pk2we=-2.0000042e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0034979717+dcitn_25
+ lcit=-1.5905326e-009+dlcitn_25                      wcit=-1.3547886e-009+dwcitn_25
+ pcit=9.4673005e-016+dpcitn_25                       voff=0.18493237
+ lvoff=-2.4923201e-007     wvoff=-1.7866582e-007     pvoff=1.4438579e-013
+ nfactor=0.55              eta0=0.62958506           leta0=-3.3037214e-007
+ weta0=-1.692286e-007      peta0=2.0053589e-013      etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-2.0000001e-010
+ wku0we=-9.0000002e-010    pku0we=-5.0000004e-017    u0=0.032655745+du0n_25
+ lu0=-3.1470578e-009+dlu0n_25                        wu0=-1.8615142e-009+dwu0n_25
+ pu0=2.2058943e-015+dpu0n_25                         ua=-1.23e-009
+ ub=4.0065232e-018         lub=-1.106462e-024        wub=-6.572737e-025
+ pub=6.617681e-031         uc=8.4179265e-011         luc=-8.4013718e-018
+ wuc=-8.0908598e-018       puc=1.0026799e-023        vsat=131855.4
+ lvsat=-0.039644649        wvsat=-0.020307428        pvsat=2.4064302e-008
+ a0=0.59934208             la0=4.0326501e-007        wa0=4.1850099e-007
+ pa0=-4.8128606e-013       ags=-1.6388117            lags=2.2050915e-006
+ wags=1.2303658e-006       pags=-1.3335634e-012      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.066849131          lketa=-1.336018e-007      wketa=-6.6320294e-008
+ pketa=7.4198252e-014      dwg=0                     dwb=0
+ pclm=0.60603467           lpclm=5.1137029e-009      wpclm=1.3995318e-007
+ ppclm=-1.8048218e-013     pdiblc1=0                 pdiblc2=0.00065209019
+ lpdiblc2=-4.9839931e-010  wpdiblc2=-2.1493271e-010  ppdiblc2=4.0107176e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.47818488           lkt1=7.6481769e-008       wkt1=8.2524619e-008
+ pkt1=-5.3322482e-014      kt1l=0                    kt2=-0.11234074
+ lkt2=5.5637599e-008       wkt2=3.4862594e-008       pkt2=-2.6081695e-014
+ ute=-1.158273             lute=-2.6316125e-007      wute=-8.9184689e-008
+ pute=1.2032151e-013       ua1=6.7892768e-010        lua1=5.560089e-016
+ wua1=4.4537006e-016       pua1=-3.2005522e-022      ub1=1.0827097e-018
+ lub1=-2.1339563e-024      wub1=-1.2271496e-024      pub1=8.6852016e-031
+ uc1=3.0368605e-011        luc1=2.4105132e-017       wuc1=6.5570147e-018
+ puc1=-2.876807e-023       prt=0                     at=182727.85
+ lat=-0.098543455          wat=-0.070903093          pat=4.0107193e-008
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     19: type=n 
+ lmin=3.8e-007-dxln_25     lmax=7e-007-dxln_25       wmin=4e-07
+ wmax=6e-007-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.58156996+dvthn_25  lvth0=9.1798913e-010+dlvthn_25
+ wvth0=-2.5071719e-008+dwvthn_25                     pvth0=-4.8256197e-015+dpvthn_25
+ k1=0.3969                 k2=0.028198311+dk2n_25    lk2=1.270791e-008+dlk2n_25
+ wk2=1.8974517e-008+dwk2n_25                         pk2=-4.5361178e-015+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.015000005       lkvth0we=5.8299978e-009
+ wkvth0we=-3.0000216e-010  pkvth0we=-1.0999895e-016  k2we=0.0040000003
+ lk2we=-1.6603225e-016     wk2we=3.9999988e-010      pk2we=-1.9999941e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00085736396+dcitn_25
+ lcit=2.182837e-010+dlcitn_25                        wcit=2.034181e-010+dwcitn_25
+ pcit=-1.2064155e-016+dpcitn_25                      voff=-0.18929535
+ lvoff=7.1139751e-009      wvoff=3.6343196e-008      pvoff=-2.8953844e-015
+ nfactor=0.55              eta0=-0.084827321         leta0=1.5900034e-007
+ weta0=2.6441971e-007      peta0=-9.6513205e-014     etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.002              lku0we=-1.9999998e-010
+ wku0we=-9.0000003e-010    pku0we=-4.9999997e-017    u0=0.02402141+du0n_25
+ lu0=2.7674619e-009+dlu0n_25                         wu0=3.0495097e-009+dwu0n_25
+ pu0=-1.158157e-015+dpu0n_25                         ua=-1.23e-009
+ ub=1.8821893e-018         lub=3.4870674e-025        wub=5.6242237e-025
+ pub=-1.737237e-031        uc=7.1914476e-011         luc=8.6766484e-024
+ wuc=6.5468064e-018        puc=-2.895395e-030        vsat=46125.94
+ lvsat=0.019080031         wvsat=0.031730355         pvsat=-1.1581579e-008
+ a0=2.0188814              la0=-5.6911938e-007       wa0=-6.2225468e-007
+ pa0=2.3163157e-013        ags=3.5189063             lags=-1.3279453e-006
+ wags=-1.5054548e-006      pags=5.4047374e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.23204389          lketa=7.1139921e-008      wketa=8.426686e-008
+ pketa=-2.8953948e-014     dwg=0                     dwb=0
+ pclm=0.57888182           lpclm=2.3713404e-008      wpclm=-1.0943488e-007
+ ppclm=-9.6513649e-015     pdiblc1=0                 pdiblc2=-0.00077185179
+ lpdiblc2=4.7700094e-010   wpdiblc2=7.93259e-010     ppdiblc2=-2.8953956e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25              cgdo=cgon_25
+ cgbo=0                    cgdl=cgln_25              cgsl=cgln_25
+ clc=1e-007                cle=0.6                   cf=cfn_25
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.38565946           lkt1=1.3101857e-008       wkt1=1.7108529e-008
+ pkt1=-8.5124612e-015      kt1l=0                    kt2=-0.022113824
+ lkt2=-6.1678363e-009      wkt2=-6.8775575e-009      pkt2=2.5103094e-015
+ ute=-1.8965918            lute=2.4258715e-007       wute=2.3060287e-007
+ pute=-9.8732969e-014      ua1=1.7364071e-009        lua1=-1.6836449e-016
+ wua1=-1.2189938e-016      pua1=6.8524348e-023       ub1=-2.090367e-018
+ lub1=3.9601225e-026       wub1=6.4292572e-026       pub1=-1.6117699e-032
+ uc1=2.7662019e-010        luc1=-1.4457721e-016      wuc1=-1.2134224e-016
+ puc1=5.884292e-023        prt=0                     at=38868.789
+ lat=2.8756781e-009        wat=-0.012352443          pat=-2.2198028e-015
+ fnoimod=1                 tnoimod=0                 noia=noian_25
+ noib=noibn_25             noic=noicn_25             em=1.1200e+08
+ ef=1.00                   jss=1.32e-7               jsd=1.32e-7
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25                cjd=cjn_25
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25            cjswd=cjswn_25
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25          cjswgd=cjswgn_25
+ mjswgs=0.56               mjswgd=0.56               tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=2.5e-3             tcjswg=1.68e-3            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 kvth0=-3.5e-08            lkvth0=2.5e-6
+ wkvth0=6.8e-006           pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ lodeta0=1                 ku0=-6.6e-8               lku0=7e-7
+ wku0=20.8e-07             pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=0                   steta0=8.5e-9
+ tku0=0                    minr=1e-3
 
 
     20: type=n 
+ lmin=2.8e-07              lmax=3.8e-007-dxln_25     wmin=4e-07
+ wmax=6e-007-dxwn_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxn_25              toxm=5.6e-009
+ dtox=2.835e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxln_25
+ xw=7e-09+dxwn_25          dlc=0+dlcn_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.72466753+dvthn_25  lvth0=-5.1312622e-008+dlvthn_25
+ wvth0=-1.3649457e-007+dwvthn_25                     pvth0=3.5843722e-014+dpvthn_25
+ k1=0.3969                 k2=0.013175963+dk2n_25    lk2=1.8191067e-008+dlk2n_25
+ wk2=7.2014706e-009+dwk2n_25                         pk2=-2.3895576e-016+dpk2n_25
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            web=-250                  wec=-3500
+ scref=1e-006              kvth0we=0.014999996       lkvth0we=5.8300011e-009
+ wkvth0we=-2.999971e-010   pkvth0we=-1.100008e-016   k2we=0.0039999994
+ lk2we=1.7313776e-016      wk2we=4.0000026e-010      pk2we=-2.000008e-017
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00011798921+dcitn_25
+ lcit=4.8815549e-010+dlcitn_25                       wcit=9.4689604e-010+dwcitn_25
+ pcit=-3.9201101e-016+dpcitn_25                      voff=-0.4154905
+ lvoff=8.9675207e-008      wvoff=1.2301189e-007      pvoff=-3.4529458e-014
+ nfactor=0.55              eta0=-0.044616245         leta0=1.4432329e-007
+ weta0=-1.2290688e-013     peta0=3.5843721e-020      etab=-0.144896
+ letab=1.454744e-008       ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.0020000004
+ lku0we=-1.9999984e-010    wku0we=-8.999998e-010     pku0we=-5.000008e-017
+ u0=0.022365597+du0n_25    lu0=3.3718335e-009+dlu0n_25
+ wu0=-1.432883e-009+dwu0n_25                         pu0=4.7791629e-016+dpu0n_25
+ ua=-1.23e-009             ub=1.1899132e-018         lub=6.0138749e-025
+ wub=2.5013666e-025        pub=-5.9739417e-032       uc=-3.0547774e-011
+ luc=3.739873e-017         wuc=6.8741397e-017        puc=-2.2701029e-023
+ vsat=122528.25            lvsat=-0.0088068113       wvsat=-0.0098201965
+ pvsat=3.5843722e-009      a0=1.8566111              la0=-5.0989075e-007
+ wa0=-7.5034976e-007       pa0=2.7838628e-013        ags=-0.045364599
+ lags=-2.6986451e-008      wags=1.716989e-007        pags=-7.1687372e-014
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.092975445         lketa=2.037994e-008
+ wketa=1.148775e-008       pketa=-2.3895729e-015     dwg=0
+ dwb=0                     pclm=1.9818348            lpclm=-4.8836445e-007
+ wpclm=-5.9415274e-007     ppclm=1.6727065e-013      pdiblc1=0
+ pdiblc2=-4.2745208e-006   lpdiblc2=1.9683524e-010   wpdiblc2=3.2733963e-010
+ ppdiblc2=-1.1947899e-016  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25
+ cgdo=cgon_25              cgbo=0                    cgdl=cgln_25
+ cgsl=cgln_25              clc=1e-007                cle=0.6
+ cf=cfn_25                 ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.23086895           lkt1=-4.3396677e-008
+ wkt1=-8.1599667e-008      pkt1=2.751603e-014        kt1l=0
+ kt2=0.032463065           lkt2=-2.6088401e-008      wkt2=-2.1673161e-008
+ pkt2=7.9107046e-015       ute=-0.47629205           lute=-2.7582227e-007
+ wute=-3.822963e-007       pute=1.2497523e-013       ua1=1.8453655e-009
+ lua1=-2.0813431e-016      wua1=-1.6624545e-016      pua1=8.4710663e-023
+ ub1=-1.835116e-019        lub1=-6.56401e-025        wub1=-7.1179758e-025
+ pub1=2.6715521e-031       uc1=-1.866754e-010        luc1=2.4525685e-017
+ wuc1=6.335137e-017        puc1=-8.5702482e-024      prt=0
+ at=71225.305              lat=-0.011810125          wat=-0.031992844
+ pat=7.1687444e-009        fnoimod=1                 tnoimod=0
+ noia=noian_25             noib=noibn_25             noic=noicn_25
+ em=1.1200e+08             ef=1.00                   jss=1.32e-7
+ jsd=1.32e-7               jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25
+ cjd=cjn_25                mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25
+ cjswd=cjswn_25            mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25
+ cjswgd=cjswgn_25          mjswgs=0.56               mjswgd=0.56
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=2.5e-3             tcjswg=1.68e-3
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 kvth0=-3.5e-08
+ lkvth0=2.5e-6             wkvth0=6.8e-006           pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 lodeta0=1                 ku0=-6.6e-8
+ lku0=7e-7                 wku0=20.8e-07             pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=0
+ steta0=8.5e-9             tku0=0                    minr=1e-3
 
// *********************************************************************************************
//                                                                            
//                   *
//                                    2.5V PMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
     } 
model pch_25 bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_25       lmax=0.000901             wmin=1e-005-dxwp_25
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.6329+dvthp_25     k1=0.7812                 k2=-0.082342292+dk2_25
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0059703572     lkvth0we=0
+ wkvth0we=0                pkvth0we=0                k2we=0.012423912
+ lk2we=0                   wk2we=0                   pk2we=0
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5e-006+dcitp_25
+ voff=-0.15000001          nfactor=0.63002+dnfactorp_25
+ eta0=0.4                  etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015129931        lku0we=0                  wku0we=0
+ pku0we=0                  u0=0.01425+du0p_25        ua=1.997e-009
+ ub=1.95678e-019           uc=-1.025e-012            vsat=110000+dvsatp_25
+ a0=1.1                    la0=-1.134003e-014+dla0p_25
+ wa0=-1.1340306e-014+dwa0p_25                        pa0=1.0217444e-017+dpa0p_25
+ ags=0.28435               a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.02109
+ dwg=0                     dwb=0                     pclm=0.27
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   bgidl=2.041e-9
+ pbgidl=0                  wbgidl=0                  lbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.30317              kt1l=0
+ kt2=-0.03                 ute=-1                    ua1=2.76e-009
+ ub1=-3.99e-018            uc1=-1.2e-010             prt=0
+ at=200000.01              lat=-1.1340027e-009       wat=-1.1340306e-009
+ pat=1.0217445e-012        jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lvth0=0+dlvthp_25         wvth0=0+dwvthp_25         pvth0=0+dpvthp_25
+ lu0=0+dlu0p_25            wu0=0+dwu0p_25            pu0=0+dpu0p_25
+ lcit=0+dlcitp_25          wcit=0+dwcitp_25          pcit=0+dpcitp_25
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     2: type=p 
+ lmin=1.2e-006-dxlp_25     lmax=1e-005-dxlp_25       wmin=1e-005-dxwp_25
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.63447551+dvthp_25 lvth0=1.5731481e-008+dlvthp_25
+ k1=0.7812                 k2=-0.082398628+dk2_25    lk2=5.6251473e-010
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0057219847     lkvth0we=-2.4799999e-009
+ wkvth0we=-1.3626682e-016  pkvth0we=1.360624e-021    k2we=0.012490007
+ lk2we=-6.5995848e-010     wk2we=0                   pk2we=0
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5e-006+dcitp_25
+ voff=-0.15518439          lvoff=5.1765998e-008      nfactor=0.63002+dnfactorp_25
+ eta0=0.4                  etab=-0.01                ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015119916        lku0we=-9.9999781e-011    wku0we=0
+ pku0we=0                  u0=0.014244614+du0p_25    lu0=5.3782841e-011+dlu0p_25
+ ua=2.0512676e-009         lua=-5.4186212e-016       ub=1.3040133e-019
+ lub=6.5178753e-025        uc=-9.2802756e-012        luc=8.2428927e-017
+ vsat=110000+dvsatp_25     a0=1.1269318              la0=-2.6891416e-007+dla0p_25
+ wa0=1.0664458e-012+dwa0p_25                         pa0=-5.4424957e-019+dpa0p_25
+ ags=0.26194946            lags=2.2366939e-007       a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.016910182         lketa=-4.1735486e-008     wketa=-1.362668e-015
+ pketa=1.3606239e-020      dwg=0                     dwb=0
+ pclm=0.2533696            lpclm=1.6605452e-007      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   lagidl=0                  bgidl=2.041e-9
+ pbgidl=0                  wbgidl=0                  lbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.2995571            lkt1=-3.6074841e-008
+ kt1l=0                    kt2=-0.03                 ute=-1
+ ua1=2.76e-009             ub1=-3.9051648e-018       lub1=-8.4707974e-025
+ uc1=-1.2e-010             prt=0                     at=202019.9
+ lat=-0.020168565          wat=1.0119391e-007        pat=1.0720722e-022
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25                cjd=cjp_25                mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25            cjswd=cjswp_25            mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25          cjswgd=cjswgp_25          mjswgs=0.5
+ mjswgd=0.5                tpb=1.55e-3               tcj=8.5e-4
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=1.34e-3
+ tcjswg=1.55e-3            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-007
+ sbref=4.6e-007            wlod=0                    kvth0=1.1e-009
+ lkvth0=-1.5e-007          wkvth0=3e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 lodeta0=1                 ku0=3.9e-009
+ lku0=1.5e-008             wku0=1.1e-006             pku0=2e-015
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=5e-009             tku0=0                    wvth0=0+dwvthp_25
+ pvth0=0+dpvthp_25         wu0=0+dwu0p_25            pu0=0+dpu0p_25
+ lcit=0+dlcitp_25          wcit=0+dwcitp_25          pcit=0+dpcitp_25
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     3: type=p 
+ lmin=7e-007-dxlp_25       lmax=1.2e-006-dxlp_25     wmin=1e-005-dxwp_25
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.627776+dvthp_25   lvth0=7.79256e-009+dlvthp_25
+ k1=0.7812                 k2=-0.085934212+dk2_25    lk2=4.7521823e-009
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0057219845     lkvth0we=-2.4800001e-009
+ wkvth0we=2.3982957e-015   pkvth0we=-1.6428325e-021  k2we=0.012490006
+ lk2we=-6.5995678e-010     wk2we=0                   pk2we=0
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00021324101+dcitp_25
+ lcit=2.586156e-010+dlcitp_25                        wcit=1.3863565e-016+dwcitp_25
+ pcit=-1.6428325e-022+dpcitp_25                      voff=-0.1314746
+ lvoff=2.3669904e-008      wvoff=-5.5454262e-014     pvoff=6.5713298e-020
+ nfactor=0.63002+dnfactorp_25                        eta0=0.4
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015119916
+ lku0we=-9.999965e-011     wku0we=0                  pku0we=0
+ u0=0.012509+du0p_25       lu0=2.110485e-009+dlu0p_25
+ ua=1.41864e-009           lua=2.078016e-016         ub=4.5322534e-019
+ lub=2.6924108e-025        uc=-9.2064e-012           luc=8.2341384e-017
+ vsat=110000+dvsatp_25     a0=0.89087586             la0=1.0812146e-008+dla0p_25
+ wa0=1.577613e-012+dwa0p_25                          pa0=-1.1499827e-018+dpa0p_25
+ ags=0.193688              lags=3.0455922e-007       a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.026086301         lketa=-3.0861785e-008     wketa=1.0119391e-014
+ pketa=-9.1808008e-028     dwg=0                     dwb=0
+ pclm=0.28869499           lpclm=1.2419394e-007      wpclm=1.3863566e-013
+ ppclm=-1.6428324e-019     pdiblc1=0                 pdiblc2=1e-005
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ lagidl=0                  bgidl=2.041e-9            pbgidl=0
+ wbgidl=0                  lbgidl=0                  cgidl=0.5
+ egidl=0.8                 aigbacc=0.43              bigbacc=0.054
+ cigbacc=0.075             nigbacc=1                 aigbinv=0.35
+ bigbinv=0.03              cigbinv=0.006             eigbinv=1.1
+ nigbinv=3                 aigc=0.43                 bigc=0.054
+ cigc=0.075                aigsd=0.43                bigsd=0.054
+ cigsd=0.075               nigc=1                    poxedge=1
+ pigcd=1                   ntox=1                    xrcrg1=12
+ xrcrg2=1                  vfbsdoff=0                lvfbsdoff=0
+ wvfbsdoff=0               pvfbsdoff=0               cgso=cgop_25
+ cgdo=cgop_25              cgbo=0                    cgdl=cglp_25
+ cgsl=cglp_25              clc=1e-007                cle=0.6
+ cf=cfp_25                 ckappas=0.6               ckappad=0.6
+ acde=1.03                 moin=6.502                noff=3.7071
+ voffcv=0.00514            tvoff=0                   ltvoff=0
+ wtvoff=0                  ptvoff=0                  tvfbsdoff=0
+ ltvfbsdoff=0              wtvfbsdoff=0              ptvfbsdoff=0
+ kt1=-0.33                 kt1l=0                    kt2=-0.03
+ ute=-1                    ua1=2.76e-009             ub1=-4.62e-018
+ uc1=-1.2e-010             prt=0                     at=285010.04
+ lat=-0.11851188           wat=1.0119391e-007        pat=2.0979449e-021
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25                cjd=cjp_25                mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25            cjswd=cjswp_25            mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25          cjswgd=cjswgp_25          mjswgs=0.5
+ mjswgd=0.5                tpb=1.55e-3               tcj=8.5e-4
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=1.34e-3
+ tcjswg=1.55e-3            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-007
+ sbref=4.6e-007            wlod=0                    kvth0=1.1e-009
+ lkvth0=-1.5e-007          wkvth0=3e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 lodeta0=1                 ku0=3.9e-009
+ lku0=1.5e-008             wku0=1.1e-006             pku0=2e-015
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=5e-009             tku0=0                    wvth0=0+dwvthp_25
+ pvth0=0+dpvthp_25         wu0=0+dwu0p_25            pu0=0+dpu0p_25
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     4: type=p 
+ lmin=3.8e-007-dxlp_25     lmax=7e-007-dxlp_25       wmin=1e-005-dxwp_25
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.63932656+dvthp_25 lvth0=1.5704695e-008+dlvthp_25
+ k1=0.7812                 k2=-0.071986651+dk2_25    lk2=-4.8018973e-009
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0057219849     lkvth0we=-2.4799999e-009
+ wkvth0we=0                pkvth0we=0                k2we=0.012490008
+ lk2we=-6.5995818e-010     wk2we=0                   pk2we=0
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00016157653+dcitp_25
+ lcit=2.2322543e-010+dlcitp_25                       wcit=-3.3204251e-016+dwcitp_25
+ pcit=1.5813129e-022+dpcitp_25                       voff=-0.15750999
+ lvoff=4.1504145e-008      wvoff=2.8935132e-014      pvoff=7.9065642e-021
+ nfactor=0.63002+dnfactorp_25                        eta0=0.4
+ etab=-0.01                ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015119915
+ lku0we=-1.0000062e-010    wku0we=0                  pku0we=0
+ u0=0.017107031+du0p_25    lu0=-1.0391664e-009+dlu0p_25
+ ua=2.6060985e-009         lua=-6.0560746e-016       wua=-4.616972e-022
+ pua=3.1626258e-028        ub=-2.0279885e-020        lub=5.9359216e-025
+ uc=1.0153281e-010         luc=6.4850234e-018        vsat=110000+dvsatp_25
+ a0=1.0739441              la0=-1.1458957e-007+dla0p_25
+ wa0=-1.0119391e-013+dwa0p_25                        pa0=2.8737684e-027+dpa0p_25
+ ags=0.079165625           lags=3.8300705e-007       a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.068459533         lketa=-1.8361203e-009     wketa=2.1661822e-014
+ pketa=-7.9065649e-021     dwg=0                     dwb=0
+ pclm=0.31873299           lpclm=1.0361791e-007      wpclm=-3.3204251e-013
+ ppclm=1.5813129e-019      pdiblc1=0                 pdiblc2=9.9999989e-006
+ lpdiblc2=7.8132812e-019   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   lagidl=0                  bgidl=2.041e-9
+ pbgidl=0                  wbgidl=0                  lbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.29578124           lkt1=-2.3439852e-008
+ kt1l=0                    kt2=-0.01175              lkt2=-1.250125e-008
+ ute=-1                    ua1=2.76e-009             ub1=-4.4619094e-018
+ lub1=-1.0829208e-025      uc1=-2.158125e-010        luc1=6.5631563e-017
+ wuc1=6.9254578e-023       puc1=-4.7439386e-029      prt=0
+ at=194124.98              lat=-0.056255621          wat=1.3582119e-007
+ pat=-2.3719693e-014       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ wvth0=0+dwvthp_25         pvth0=0+dpvthp_25         wu0=0+dwu0p_25
+ pu0=0+dpu0p_25            lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25
+ pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25
+ pvsat=0+dpvsatp_25        leta0=0+dleta0p_25        peta0=0+dpeta0p_25
+ fnoimod=1                 noia=noiap_25             noib=noibp_25
+ noic=noicp_25             em=3e+7            ef=1.15
+ tnoimod=0                 minr=1e-3
 
 
     5: type=p 
+ lmin=2.8e-07              lmax=3.8e-007-dxlp_25     wmin=1e-005-dxwp_25
+ wmax=0.000901             version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.524803+dvthp_25   lvth0=-2.6096405e-008+dlvthp_25
+ k1=0.7812                 k2=-0.030506249+dk2_25    lk2=-1.9942244e-008
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0057219845     lkvth0we=-2.48e-009
+ wkvth0we=0                pkvth0we=0                k2we=0.012490007
+ lk2we=-6.5995806e-010     wk2we=2.6816383e-015      pk2we=-9.7879792e-022
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.001616+dcitp_25
+ lcit=-4.2558999e-010+dlcitp_25                      wcit=1.7182219e-015+dwcitp_25
+ pcit=-5.9021523e-022+dpcitp_25                      voff=0.015983988
+ lvoff=-2.1821157e-008     wvoff=2.3831165e-013      pvoff=-6.8515864e-020
+ nfactor=0.63002+dnfactorp_25                        eta0=-0.27045
+ leta0=2.4471425e-007+dleta0p_25                     etab=-0.023250001
+ letab=4.8362503e-009      wetab=-1.3408192e-014     petab=4.8939903e-021
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015119916        lku0we=-1.0000011e-010
+ wku0we=0                  pku0we=0                  u0=0.010974+du0p_25
+ lu0=1.19939e-009+dlu0p_25 ua=8.0565485e-010         lua=5.1554464e-017
+ wua=1.477431e-021         pua=-3.9151922e-028       ub=7.271e-020
+ lub=5.5965085e-025        uc=3.0294501e-010         luc=-6.703043e-017
+ wuc=-1.3408193e-022       puc=4.8939902e-029        vsat=110000+dvsatp_25
+ a0=1.7670003              la0=-3.6755509e-007+dla0p_25
+ wa0=-2.2465047e-012+dwa0p_25                        pa0=7.8303844e-019+dpa0p_25
+ ags=-2.1614755            lags=1.2008411e-006       wags=-2.6816384e-012
+ pags=9.7879807e-019       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.21523851
+ lketa=5.1738204e-008      wketa=-2.6816385e-014     pketa=9.7879812e-021
+ dwg=0                     dwb=0                     pclm=0.18290444
+ lpclm=1.5319533e-007      wpclm=3.6935775e-013      ppclm=-9.7879812e-020
+ pdiblc1=0                 pdiblc2=1.0000004e-005    lpdiblc2=-9.6725e-019
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0072              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=200                pdits=0.039               pditsd=1.73
+ pditsl=1000000            rsh=15.5                  rdsw=0
+ rsw=21.04                 rdw=21.04                 prwg=0
+ prwb=0                    wr=1                      alpha0=3.53e-007
+ alpha1=0.296              beta0=26.3                agidl=0
+ lagidl=0                  wagidl=0                  pagidl=0
+ bgidl=2.041e-9            lbgidl=0                  wbgidl=0
+ pbgidl=0                  cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25              cgdo=cgop_25
+ cgbo=0                    cgdl=cglp_25              cgsl=cglp_25
+ clc=1e-007                cle=0.6                   cf=cfp_25
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.41830004
+ lkt1=2.127951e-008        wkt1=2.6816386e-013       pkt1=-9.7879807e-020
+ kt1l=0                    kt2=-0.0778               lkt2=1.1607e-008
+ ute=-1                    ua1=2.2565e-009           lua1=1.837775e-016
+ ub1=-3.27089e-018         lub1=-5.4301415e-025      uc1=-1.2080001e-010
+ luc1=3.0952003e-017       wuc1=-1.411655e-022       puc1=2.9363942e-029
+ prt=0                     at=82399.982              lat=-0.015475995
+ wat=2.3173405e-007        pat=-5.8727884e-014       jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25
+ cjd=cjp_25                mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25
+ cjswd=cjswp_25            mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25
+ cjswgd=cjswgp_25          mjswgs=0.5                mjswgd=0.5
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=1.34e-3            tcjswg=1.55e-3
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=0                    kvth0=1.1e-009            lkvth0=-1.5e-007
+ wkvth0=3e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-009              lku0=1.5e-008
+ wku0=1.1e-006             pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-009
+ tku0=0                    wvth0=0+dwvthp_25         pvth0=0+dpvthp_25
+ wu0=0+dwu0p_25            pu0=0+dpu0p_25            lnfactor=0+dlnfactorp_25
+ wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25
+ wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25        peta0=0+dpeta0p_25
+ fnoimod=1                 noia=noiap_25             noib=noibp_25
+ noic=noicp_25             em=3e+7            ef=1.15
+ tnoimod=0                 minr=1e-3
 
 
     6: type=p 
+ lmin=1e-005-dxlp_25       lmax=0.000901             wmin=1e-006-dxwp_25
+ wmax=1e-005-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.63143426+dvthp_25 wvth0=-1.4667705e-008+dwvthp_25
+ k1=0.7812                 k2=-0.082798282+dk2_25    wk2=4.5630905e-009
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0059483726     lkvth0we=0
+ wkvth0we=-2.2000001e-010  pkvth0we=0                k2we=0.01243991
+ lk2we=0                   wk2we=-1.600896e-010      pk2we=0
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5e-006+dcitp_25
+ voff=-0.15000001          nfactor=0.63002+dnfactorp_25
+ eta0=0.39239156           weta0=7.6137704e-008      etab=-0.0077622222
+ wetab=-2.2393442e-008     ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015010015
+ lku0we=0                  wku0we=-1.1999996e-009    pku0we=0
+ u0=0.014247762+du0p_25    wu0=2.2393442e-011+dwu0p_25
+ ua=2.0577557e-009         wua=-6.0798196e-016       ub=1.6449524e-019
+ wub=3.120459e-025         uc=1.5486833e-013         wuc=-1.1806942e-017
+ vsat=110000+dvsatp_25     a0=1.1                    la0=1.0096897e-012+dla0p_25
+ ags=0.28466888            wags=-3.1910655e-009      a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.022152944         wketa=1.0636885e-008      dwg=0
+ dwb=0                     pclm=0.27279722           wpclm=-2.7991803e-008
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   wagidl=0
+ bgidl=2.041e-9            pbgidl=0                  lbgidl=0
+ wbgidl=0                  cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25              cgdo=cgop_25
+ cgbo=0                    cgdl=cglp_25              cgsl=cglp_25
+ clc=1e-007                cle=0.6                   cf=cfp_25
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.30317
+ kt1l=0                    kt2=-0.028353891          wkt2=-1.6472616e-008
+ ute=-1                    ua1=2.76e-009             ub1=-4.0448256e-018
+ wub1=5.4863933e-025       uc1=-1.2984622e-010       luc1=3.3891916e-024
+ wuc1=9.8531156e-017       puc1=-3.3915642e-029      prt=0
+ at=200000.01              lat=1.0096897e-007        jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25
+ cjd=cjp_25                mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25
+ cjswd=cjswp_25            mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25
+ cjswgd=cjswgp_25          mjswgs=0.5                mjswgd=0.5
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=1.34e-3            tcjswg=1.55e-3
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=0                    kvth0=1.1e-009            lkvth0=-1.5e-007
+ wkvth0=3e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-009              lku0=1.5e-008
+ wku0=1.1e-006             pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-009
+ tku0=0                    lvth0=0+dlvthp_25         pvth0=0+dpvthp_25
+ lu0=0+dlu0p_25            pu0=0+dpu0p_25            wa0=0+dwa0p_25
+ pa0=0+dpa0p_25            lcit=0+dlcitp_25          wcit=0+dwcitp_25
+ pcit=0+dpcitp_25          lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25
+ pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25
+ pvsat=0+dpvsatp_25        leta0=0+dleta0p_25        peta0=0+dpeta0p_25
+ fnoimod=1                 noia=noiap_25             noib=noibp_25
+ noic=noicp_25             em=3e+7            ef=1.15
+ tnoimod=0                 minr=1e-3
 
 
     7: type=p 
+ lmin=1.2e-006-dxlp_25     lmax=1e-005-dxlp_25       wmin=1e-006-dxwp_25
+ wmax=1e-005-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.63295251+dvthp_25 lvth0=1.5159799e-008+dlvthp_25
+ wvth0=-1.5240646e-008+dwvthp_25                     pvth0=5.720819e-015+dpvthp_25
+ k1=0.7812                 k2=-0.082869907+dk2_25    lk2=7.1517316e-010
+ wk2=4.7160852e-009        pk2=-1.5276529e-015       k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0057000001     lkvth0we=-2.4799998e-009  wkvth0we=-2.2000001e-010
+ pkvth0we=-4.4231533e-030  k2we=0.0125               lk2we=-6.0000051e-010
+ wk2we=-9.9999514e-011     pk2we=-5.9999949e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=5e-006+dcitp_25       voff=-0.15516179
+ lvoff=5.1540334e-008      wvoff=-2.2616104e-010     pvoff=2.258218e-015
+ nfactor=0.63002+dnfactorp_25                        eta0=0.39239156
+ weta0=7.6137704e-008      etab=-0.0077622222        wetab=-2.2393442e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015              lku0we=-9.999963e-011
+ wku0we=-1.1999995e-009    pku0we=-1.5054787e-021    u0=0.014241773+du0p_25
+ lu0=5.9800543e-011+dlu0p_25                         wu0=2.8424403e-011+dwu0p_25
+ pu0=-6.0219147e-017+dpu0p_25                        ua=2.1129273e-009
+ lua=-5.5088868e-016       wua=-6.170284e-016        pua=9.0328721e-023
+ ub=9.83936e-020           lub=6.6002486e-025        wub=3.2030138e-025
+ pub=-8.2430979e-032       uc=-8.158942e-012         luc=8.3013396e-017
+ wuc=-1.1221185e-017       puc=-5.8487847e-024       vsat=110000+dvsatp_25
+ a0=1.1272333              la0=-2.7192307e-007+dla0p_25
+ wa0=-3.0154806e-009+dwa0p_25                        pa0=3.0109574e-014+dpa0p_25
+ ags=0.2624499             lags=2.2185656e-007       wags=-5.0078926e-009
+ pags=1.8141018e-014       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.017971017
+ lketa=-4.1756547e-008     wketa=1.0615777e-008      pketa=2.1076702e-016
+ dwg=0                     dwb=0                     pclm=0.25689003
+ lpclm=1.5883328e-007      wpclm=-3.5228956e-008     ppclm=7.2262976e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.2995571            lkt1=-3.6074841e-008
+ kt1l=0                    kt2=-0.028435252          lkt2=8.1238981e-010
+ wkt2=-1.5658436e-008      pkt2=-8.1295849e-015      ute=-1
+ ua1=2.76e-009             ub1=-3.9599903e-018       lub1=-8.4707974e-025
+ wub1=5.4863933e-025       pub1=-2.1825274e-046      uc1=-1.302681e-010
+ luc1=4.2123918e-018       wuc1=1.0275283e-016       puc1=-4.2153404e-023
+ prt=0                     at=201884.31              lat=-0.018814582
+ wat=0.0013569663          pat=-1.3549308e-008       jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25
+ cjd=cjp_25                mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25
+ cjswd=cjswp_25            mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25
+ cjswgd=cjswgp_25          mjswgs=0.5                mjswgd=0.5
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=1.34e-3            tcjswg=1.55e-3
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=0                    kvth0=1.1e-009            lkvth0=-1.5e-007
+ wkvth0=3e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-009              lku0=1.5e-008
+ wku0=1.1e-006             pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-009
+ tku0=0                    lcit=0+dlcitp_25          wcit=0+dwcitp_25
+ pcit=0+dpcitp_25          lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25
+ pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25
+ pvsat=0+dpvsatp_25        leta0=0+dleta0p_25        peta0=0+dpeta0p_25
+ fnoimod=1                 noia=noiap_25             noib=noibp_25
+ noic=noicp_25             em=3e+7            ef=1.15
+ tnoimod=0                 minr=1e-3
 
 
     8: type=p 
+ lmin=7e-007-dxlp_25       lmax=1.2e-006-dxlp_25     wmin=1e-006-dxwp_25
+ wmax=1e-005-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.62725748+dvthp_25 lvth0=8.4111864e-009+dlvthp_25
+ wvth0=-5.1888204e-009+dwvthp_25                     pvth0=-6.1905943e-015+dpvthp_25
+ k1=0.7812                 k2=-0.086622656+dk2_25    lk2=5.1621814e-009
+ wk2=6.8892561e-009        pk2=-4.1028604e-015       k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0056999997     lkvth0we=-2.4800002e-009  wkvth0we=-2.2000001e-010
+ pkvth0we=-2.5076555e-030  k2we=0.012499998          lk2we=-5.9999852e-010
+ wk2we=-9.9997121e-011     pk2we=-6.0000233e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00023765974+dcitp_25
+ lcit=2.875518e-010+dlcitp_25                        wcit=2.4435837e-010+dwcitp_25
+ pcit=-2.8956467e-016+dpcitp_25                      voff=-0.13223413
+ lvoff=2.4371064e-008      wvoff=7.6005582e-009      pvoff=-7.0164443e-015
+ nfactor=0.63002+dnfactorp_25                        eta0=0.39239156
+ weta0=7.6137704e-008      etab=-0.0077622222        wetab=-2.2393442e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015              lku0we=-9.999965e-011
+ wku0we=-1.2000008e-009    pku0we=-1.8628298e-029    u0=0.012521968+du0p_25
+ lu0=2.0977698e-009+dlu0p_25                         wu0=-1.2977e-010+dwu0p_25
+ pu0=1.2724122e-016+dpu0p_25                         ua=1.478354e-009
+ lua=2.010807e-016         wua=-5.9755781e-016       pua=6.7256073e-023
+ ub=4.2353689e-019         lub=2.7473006e-025        wub=2.9709231e-025
+ pub=-5.4928234e-032       uc=-8.7644947e-012        luc=8.3730976e-017
+ wuc=-4.4221465e-018       puc=-1.3905646e-023       vsat=110000+dvsatp_25
+ a0=0.86289409             la0=4.1318845e-008+dla0p_25
+ wa0=2.8001512e-007+dwa0p_25                         pa0=-3.0528169e-013+dpa0p_25
+ ags=0.19187643            lags=3.0548612e-007       wags=1.8128428e-008
+ pags=-9.2755213e-015      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.027155712
+ lketa=-3.0872683e-008     wketa=1.0701602e-008      pketa=1.090639e-016
+ dwg=0                     dwb=0                     pclm=0.28259594
+ lpclm=1.2837178e-007      wpclm=6.1033327e-008      ppclm=-4.1807829e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.33                 kt1l=0
+ kt2=-0.027119371          lkt2=-7.4692842e-010      wkt2=-2.8826451e-008
+ pkt2=7.4745127e-015       ute=-1                    ua1=2.76e-009
+ ub1=-4.6640954e-018       lub1=-1.2715221e-026      wub1=4.4126278e-025
+ pub1=1.2724122e-031       uc1=-1.2855279e-010       luc1=2.179754e-018
+ wuc1=8.5587757e-017       puc1=-2.1812798e-023      prt=0
+ at=284330.88              lat=-0.11651378           wat=0.0067964082
+ pat=-1.9995047e-008       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     9: type=p 
+ lmin=3.8e-007-dxlp_25     lmax=7e-007-dxlp_25       wmin=1e-006-dxwp_25
+ wmax=1e-005-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.63687343+dvthp_25 lvth0=1.499811e-008+dlvthp_25
+ wvth0=-2.4548517e-008+dwvthp_25                     pvth0=7.0707978e-015+dpvthp_25
+ k1=0.7812                 k2=-0.070814345+dk2_25    lk2=-5.666512e-009
+ wk2=-1.1731268e-008       pk2=8.6521989e-015        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0057000002     lkvth0we=-2.4799999e-009  wkvth0we=-2.2000013e-010
+ pkvth0we=8.7483124e-023   k2we=0.012500001          lk2we=-6.000002e-010
+ wk2we=-1.000013e-010      pk2we=-5.9999947e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-8.0693753e-005+dcitp_25
+ lcit=1.8003009e-010+dlcitp_25                       wcit=-8.0939428e-010+dwcitp_25
+ pcit=4.322559e-016+dpcitp_25                        voff=-0.15687838
+ lvoff=4.1252371e-008      wvoff=-6.3205491e-009     pvoff=2.5195142e-015
+ nfactor=0.63002+dnfactorp_25                        eta0=0.39239156
+ weta0=7.6137704e-008      etab=-0.0077622222        wetab=-2.2393442e-008
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.014999998        lku0we=-1.0000071e-010
+ wku0we=-1.200002e-009     pku0we=8.748313e-022      u0=0.017107818+du0p_25
+ lu0=-1.0435375e-009+dlu0p_25                        wu0=-7.8726945e-012+dwu0p_25
+ pu0=4.3741566e-017+dpu0p_25                         ua=2.6580301e-009
+ lua=-6.0699744e-016       wua=-5.1968007e-016       pua=1.3909818e-023
+ ub=-4.2391949e-020        lub=5.9389132e-025        wub=2.2127542e-025
+ pub=-2.993664e-033        uc=1.0231614e-010         luc=7.6407415e-018
+ wuc=-7.8387521e-018       puc=-1.1565271e-023       vsat=110000+dvsatp_25
+ a0=1.126991               la0=-1.3958757e-007+dla0p_25
+ wa0=-5.308413e-007+dwa0p_25                         pa0=2.5015496e-013+dpa0p_25
+ ags=0.055509929           lags=3.9889717e-007       wags=2.3672255e-007
+ pags=-1.590125e-013       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.069239834
+ lketa=-2.0450595e-009     wketa=7.8084883e-009      pketa=2.0908468e-015
+ dwg=0                     dwb=0                     pclm=0.30705568
+ lpclm=1.1161686e-007      wpclm=1.1685458e-007      ppclm=-8.0045385e-014
+ pdiblc1=0                 pdiblc2=1.0002551e-005    lpdiblc2=-1.7476574e-015
+ wpdiblc2=-2.554252e-014   ppdiblc2=1.7496626e-020   pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.29394346           lkt1=-2.4698728e-008
+ wkt1=-1.8390627e-008      pkt1=1.259758e-014        kt1l=0
+ kt2=-0.0085048726         lkt2=-1.349786e-008       wkt2=-3.247399e-008
+ pkt2=9.973077e-015        ute=-1                    ua1=2.76e-009
+ ub1=-4.5426131e-018       lub1=-9.5930616e-026      wub1=8.07602e-025
+ pub1=-1.2370115e-031      uc1=-2.2935105e-010       luc1=7.1226561e-017
+ wuc1=1.3548031e-016       puc1=-5.59892e-023        prt=0
+ at=195341.79              lat=-0.055556248          wat=-0.012176432
+ pat=-6.9986514e-009       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     10: type=p 
+ lmin=2.8e-07              lmax=3.8e-007-dxlp_25     wmin=1e-006-dxwp_25
+ wmax=1e-005-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.51953178+dvthp_25 lvth0=-2.7831591e-008+dlvthp_25
+ wvth0=-5.2749074e-008+dwvthp_25                     pvth0=1.7364001e-014+dpvthp_25
+ k1=0.7812                 k2=-0.031348028+dk2_25    lk2=-2.0071718e-008
+ wk2=8.4236796e-009        pk2=1.2956429e-015        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0056999999     lkvth0we=-2.48e-009       wkvth0we=-2.1999989e-010
+ pkvth0we=2.0346488e-030   k2we=0.012500001          lk2we=-6.0000011e-010
+ wk2we=-9.9999433e-011     pk2we=-6.0000015e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.001524486+dcitp_25  lcit=-4.058605e-010+dlcitp_25
+ wcit=9.1578235e-010+dwcitp_25                       pcit=-1.9743357e-016+dpcitp_25
+ voff=0.02240151           lvoff=-2.4184787e-008     wvoff=-6.4219908e-008
+ pvoff=2.365278e-014       nfactor=0.63002+dnfactorp_25
+ eta0=-0.30800551          leta0=2.5564493e-007+dleta0p_25
+ weta0=3.7581797e-007      peta0=-1.093833e-013+dpeta0p_25
+ etab=-0.019529697         letab=4.2951282e-009      wetab=-3.7229095e-008
+ petab=5.4150134e-015      ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015
+ lku0we=-1.0000011e-010    wku0we=-1.1999996e-009    pku0we=-2.6450434e-029
+ u0=0.010944428+du0p_25    lu0=1.2060999e-009+dlu0p_25
+ wu0=2.9592934e-010+dwu0p_25                         pu0=-6.7146177e-017+dpu0p_25
+ ua=8.9444711e-010         lua=3.671035e-017         wua=-8.8854265e-016
+ pua=1.4854466e-022        ub=-2.300535e-020         lub=5.8681521e-025
+ wub=9.5782351e-025        pub=-2.7183372e-031       uc=3.1736132e-010
+ luc=-7.0850751e-017       wuc=-1.4426415e-016       puc=3.8230001e-023
+ vsat=110000+dvsatp_25     a0=1.8055234              la0=-3.8725187e-007+dla0p_25
+ wa0=-3.8550311e-007+dwa0p_25                        pa0=1.9710652e-013+dpa0p_25
+ ags=-2.3468777            lags=1.2757686e-006       wags=1.8553164e-006
+ pags=-7.4979925e-013      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.21869347
+ lketa=5.2505517e-008      wketa=3.4573798e-008      pketa=-7.6784913e-015
+ dwg=0                     dwb=0                     pclm=0.23800281
+ lpclm=1.3682116e-007      wpclm=-5.5136903e-007     ppclm=1.6385623e-013
+ pdiblc1=0                 pdiblc2=9.9948008e-006    lpdiblc2=1.081278e-015
+ wpdiblc2=5.2064753e-014   ppdiblc2=-1.0830029e-020  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.42197489           lkt1=2.2032744e-008
+ wkt1=3.6774552e-008       pkt1=-7.5377107e-015      kt1l=0
+ kt2=-0.071770308          lkt2=9.5940238e-009       wkt2=-6.033913e-008
+ pkt2=2.0143853e-014       ute=-1                    ua1=2.3158011e-009
+ lua1=1.6213259e-016       wua1=-5.9342622e-016      pua1=2.1660057e-022
+ ub1=-3.4418439e-018       lub1=-4.9771136e-025      wub1=1.7107358e-024
+ pub1=-4.5334499e-031      uc1=-1.1426571e-010       luc1=2.9220413e-017
+ wuc1=-6.5388855e-017      puc1=1.7328047e-023       prt=0
+ at=87311.927              lat=-0.016125348          wat=-0.049153605
+ pat=6.4980169e-009        jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ fnoimod=1                 noia=noiap_25             noib=noibp_25
+ noic=noicp_25             em=3e+7            ef=1.15
+ tnoimod=0                 minr=1e-3
 
 
     11: type=p 
+ lmin=1e-005-dxlp_25       lmax=0.000901             wmin=6e-007-dxwp_25
+ wmax=1e-006-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.63370825+dvthp_25 wvth0=-1.2377792e-008+dwvthp_25
+ k1=0.7812                 k2=-0.083807352+dk2_25    wk2=5.5792242e-009
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0059483726     lkvth0we=0
+ wkvth0we=-2.1999998e-010  pkvth0we=0                k2we=0.012439911
+ lk2we=0                   wk2we=-1.600907e-010      pk2we=0
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=2.7283025e-006+dcitp_25
+ wcit=2.2875994e-012+dwcitp_25                       voff=-0.15000003
+ wvoff=1.5281225e-014      nfactor=0.63002+dnfactorp_25
+ eta0=0.556015             weta0=-8.8631105e-008     etab=-0.0224125
+ wetab=-7.6406125e-009     ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015010014
+ lku0we=0                  wku0we=-1.200001e-009     pku0we=0
+ u0=0.01448245+du0p_25     wu0=-2.1393715e-010+dwu0p_25
+ ua=1.912285e-009          wua=-4.61493e-016         ub=2.5675036e-019
+ wub=2.1914499e-025        uc=-1.5360715e-011        luc=3.0644085e-024
+ wuc=3.8172497e-018        puc=-3.0858591e-030       vsat=110000+dvsatp_25
+ a0=1.1                    la0=2.5418938e-012+dla0p_25
+ wa0=1.7124918e-015+dwa0p_25                         pa0=-1.5429295e-018+dpa0p_25
+ ags=0.26890475            wags=1.2683417e-008       a1=0
+ a2=0.5                    b0=0                      b1=0
+ keta=-0.01606359          lketa=-4.5966123e-015     wketa=4.5049048e-009
+ pketa=4.6287887e-021      dwg=0                     dwb=0
+ pclm=0.2313425            wpclm=1.3753103e-008      pdiblc1=0
+ pdiblc2=1e-005            pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0072              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=200                pdits=0.039
+ pditsd=1.73               pditsl=1000000            rsh=15.5
+ rdsw=0                    rsw=21.04                 rdw=21.04
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.53e-007          alpha1=0.296              beta0=26.3
+ agidl=0                   wagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.31329133           wkt1=1.019218e-008
+ kt1l=0                    kt2=-0.04275746           wkt2=-1.9682218e-009
+ ute=-1                    ua1=2.76e-009             ub1=-3.7018275e-018
+ wub1=2.0324029e-025       uc1=-3.1999976e-011       luc1=-7.6256815e-023
+ wuc1=-1.53326e-023        puc1=4.6287886e-029       prt=0
+ at=200000.03              lat=2.5418938e-007        wat=-1.5109976e-008
+ pat=-1.5429295e-013       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lvth0=0+dlvthp_25         pvth0=0+dpvthp_25         lu0=0+dlu0p_25
+ pu0=0+dpu0p_25            lcit=0+dlcitp_25          pcit=0+dpcitp_25
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     12: type=p 
+ lmin=1.2e-006-dxlp_25     lmax=1e-005-dxlp_25       wmin=6e-007-dxwp_25
+ wmax=1e-006-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.63550938+dvthp_25 lvth0=1.798431e-008+dlvthp_25
+ wvth0=-1.2665878e-008+dwvthp_25                     pvth0=2.8765369e-015+dpvthp_25
+ k1=0.7812                 k2=-0.083913235+dk2_25    lk2=1.0572418e-009
+ wk2=5.766717e-009         pk2=-1.872116e-015        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0057000001     lkvth0we=-2.4799996e-009  wkvth0we=-2.1999996e-010
+ pkvth0we=-2.0546692e-022  k2we=0.012500001          lk2we=-5.9999961e-010
+ wk2we=-1.0000052e-010     pk2we=-6.000004e-016      xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=2.4223978e-006+dcitp_25
+ lcit=3.0544586e-012+dlcitp_25                       wcit=2.5956454e-012+dwcitp_25
+ pcit=-3.0758398e-018+dpcitp_25                      voff=-0.1554477
+ lvoff=5.4394991e-008      wvoff=6.1750015e-011      pvoff=-6.1642132e-016
+ nfactor=0.63002+dnfactorp_25                        eta0=0.556015
+ weta0=-8.8631105e-008     etab=-0.0224125           wetab=-7.6406125e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.014999998        lku0we=-1.0000317e-010
+ wku0we=-1.2000012e-009    pku0we=2.0546693e-021     u0=0.014502885+du0p_25
+ lu0=-2.0403865e-010+dlu0p_25                        wu0=-2.3451471e-010+dwu0p_25
+ pu0=2.0546692e-016+dpu0p_25                         ua=1.9712038e-009
+ lua=-5.8830406e-016       wua=-4.7431283e-016       pua=1.2800602e-022
+ ub=1.9071776e-019         lub=6.593355e-025         wub=2.2733095e-025
+ pub=-8.1736797e-032       uc=-2.3913898e-011        luc=8.540354e-017
+ wuc=4.6440556e-018        puc=-8.2556602e-024       vsat=110000+dvsatp_25
+ a0=1.1242389              la0=-2.4202272e-007+dla0p_25
+ wa0=-1.4458123e-013+dwa0p_25                        pa0=-8.2186769e-020+dpa0p_25
+ ags=0.24285855            lags=2.600713e-007        wags=1.4720595e-008
+ pags=-2.0341225e-014      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.011585481
+ lketa=-4.4713924e-008     wketa=4.1855416e-009      pketa=3.1888464e-015
+ dwg=0                     dwb=0                     pclm=0.20303766
+ lpclm=2.8262379e-007      wpclm=1.900038e-008       ppclm=-5.2394065e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.30942294           lkt1=-3.8625854e-008
+ wkt1=9.9349068e-009       pkt1=2.5688708e-015       kt1l=0
+ kt2=-0.042561598          lkt2=-1.9556786e-009      wkt2=-1.4332053e-009
+ pkt2=-5.34214e-015        ute=-1                    ua1=2.76e-009
+ ub1=-3.6012577e-018       lub1=-1.0041895e-024      wub1=1.8739557e-025
+ pub1=1.5820953e-031       uc1=-2.8229529e-011       luc1=-3.7647992e-017
+ wuc1=-1.0902633e-023      puc1=2.0546693e-030       prt=0
+ at=201597.11              lat=-0.015946612          wat=0.0016461741
+ pat=-1.6437354e-008       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     13: type=p 
+ lmin=7e-007-dxlp_25       lmax=1.2e-006-dxlp_25     wmin=6e-007-dxwp_25
+ wmax=1e-006-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.6213996+dvthp_25  lvth0=1.2642224e-009+dlvthp_25
+ wvth0=-1.1087702e-008+dwvthp_25                     pvth0=1.0063985e-015+dpvthp_25
+ k1=0.7812                 k2=-0.081830405+dk2_25    lk2=-1.4109117e-009
+ wk2=2.0634593e-009        pk2=2.5162443e-015        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0056999996     lkvth0we=-2.4800002e-009  wkvth0we=-2.2000013e-010
+ pkvth0we=6.405834e-029    k2we=0.012500003          lk2we=-6.0000205e-010
+ wk2we=-1.000019e-010      pk2we=-5.9999877e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=5.0000152e-006+dcitp_25
+ lcit=-1.7982956e-017+dlcitp_25                      wcit=-9.2115225e-018+dwcitp_25
+ pcit=1.0915654e-023+dpcitp_25                       voff=-0.12227692
+ lvoff=1.5087624e-008      wvoff=-2.4263529e-009     pvoff=2.3319806e-015
+ nfactor=0.63002+dnfactorp_25                        eta0=0.556015
+ weta0=-8.8631105e-008     etab=-0.0224125           wetab=-7.6406125e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015000001        lku0we=-9.999965e-011
+ wku0we=-1.1999995e-009    pku0we=2.135278e-029      u0=0.012931964+du0p_25
+ lu0=1.6575019e-009+dlu0p_25                         wu0=-5.426363e-010+dwu0p_25
+ pu0=5.7059101e-016+dpu0p_25                         ua=1.3312301e-009
+ lua=1.7006481e-016        wua=-4.4940401e-016       pua=9.8489069e-023
+ ub=5.038742e-019          lub=2.8824513e-025        wub=2.1619264e-025
+ pub=-6.8537904e-032       uc=8.0693711e-012         luc=4.7503366e-017
+ wuc=-2.1373849e-017       puc=2.2575557e-023        vsat=110000+dvsatp_25
+ a0=1.500182               la0=-6.8751527e-007+dla0p_25
+ wa0=-3.6173377e-007+dwa0p_25                        pa0=4.2865426e-013+dpa0p_25
+ ags=0.1842465             lags=3.2952658e-007       wags=2.5811768e-008
+ pags=-3.3484265e-014      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.02921996
+ lketa=-2.3817067e-008     wketa=1.27803e-008        pketa=-6.9959419e-015
+ dwg=0                     dwb=0                     pclm=0.40254684
+ lpclm=4.6205416e-008      wpclm=-5.975723e-008      ppclm=4.0933703e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.35848408           lkt1=1.9511596e-008
+ wkt1=2.8683471e-008       pkt1=-1.9648177e-014      kt1l=0
+ kt2=-0.041762345          lkt2=-2.9027935e-009      wkt2=-1.4080977e-008
+ pkt2=9.6454689e-015       ute=-1                    ua1=3.0354226e-009
+ lua1=-3.2637579e-016      wua1=-2.7735057e-016      pua1=3.2866042e-022
+ ub1=-4.9811598e-018       lub1=6.3099443e-025       wub1=7.6054657e-025
+ pub1=-5.209744e-031       uc1=-8.5139451e-011       luc1=2.9790267e-017
+ wuc1=4.1870526e-017       puc1=-4.9616585e-023      prt=0
+ at=294904.24              lat=-0.12651556           wat=-0.0038509579
+ pat=-9.9232524e-009       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     14: type=p 
+ lmin=3.8e-007-dxlp_25     lmax=7e-007-dxlp_25       wmin=6e-007-dxwp_25
+ wmax=1e-006-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.68556018+dvthp_25 lvth0=4.5214218e-008+dlvthp_25
+ wvth0=2.4479044e-008+dwvthp_25                      pvth0=-2.3356823e-014+dpvthp_25
+ k1=0.7812                 k2=-0.092633649+dk2_25    lk2=5.9893103e-009
+ wk2=1.0240771e-008        pk2=-3.0852141e-015       k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0057000009     lkvth0we=-2.4799993e-009  wkvth0we=-2.1999943e-010
+ pkvth0we=-4.7758603e-022  k2we=0.012499999          lk2we=-5.9999938e-010
+ wk2we=-9.999968e-011      pk2we=-6.0000029e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0010061472+dcitp_25
+ lcit=6.9263584e-010+dlcitp_25                       wcit=1.2253737e-010+dwcitp_25
+ pcit=-8.3938091e-017+dpcitp_25                      voff=-0.19417459
+ lvoff=6.4337525e-008      wvoff=3.1236738e-008      pvoff=-2.0727236e-014
+ nfactor=0.63002+dnfactorp_25                        eta0=0.556015
+ weta0=-8.8631105e-008     etab=-0.0224125           wetab=-7.6406125e-009
+ ud=0                      lud=0                     wud=0
+ pud=0                     ku0we=-0.015000001        lku0we=-9.9999843e-011
+ wku0we=-1.1999995e-009    pku0we=-3.9567034e-029    u0=0.020204236+du0p_25
+ lu0=-3.3240042e-009+dlu0p_25                        wu0=-3.1259656e-009+dwu0p_25
+ pu0=2.3401716e-015+dpu0p_25                         ua=3.4743081e-009
+ lua=-1.2979437e-015       wua=-1.341672e-015        pua=7.0969266e-022
+ ub=-4.5604259e-019        lub=9.4578812e-025        wub=6.3782162e-025
+ pub=-3.5735375e-031       uc=1.1906653e-010         luc=-2.8529689e-017
+ wuc=-2.4706398e-017       puc=2.4858353e-023        vsat=110000+dvsatp_25
+ a0=-0.185937              la0=4.6747622e-007+dla0p_25
+ wa0=7.9127723e-007+dwa0p_25                         pa0=-3.6115827e-013+dpa0p_25
+ ags=0.47416519            lags=1.3093228e-007       wags=-1.8486329e-007
+ pags=1.1082815e-013       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.036825302
+ lketa=-1.8607407e-008     wketa=-2.4832946e-008     pketa=1.8769131e-014
+ dwg=0                     dwb=0                     pclm=0.72441347
+ lpclm=-1.7427322e-007     wpclm=-3.0342472e-007     ppclm=2.0784593e-013
+ pdiblc1=0                 pdiblc2=9.9598756e-006    lpdiblc2=2.7485184e-014
+ wpdiblc2=1.743189e-014    ppdiblc2=-1.1940845e-020  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.31220625           lkt1=-1.2188719e-008
+ kt1l=0                    kt2=-0.036252789          lkt2=-6.6768395e-009
+ wkt2=-4.5318383e-009      pkt2=3.1043092e-015       ute=-1
+ ua1=2.6585229e-009        lua1=-6.8199476e-017      wua1=1.0218746e-016
+ pua1=6.8676872e-023       ub1=-3.740625e-018        lub1=-2.1877188e-025
+ uc1=4.8045868e-011        luc1=-6.1441678e-017      wuc1=-1.4385838e-016
+ puc1=7.7607717e-023       prt=0                     at=222230.75
+ lat=-0.076734219          wat=-0.039253612          pat=1.4327566e-008
+ jss=1.38e-07              jsd=1.38e-07              jsws=4.11e-13
+ jswd=4.11e-13             jswgs=4.11e-13            jswgd=4.11e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=10                    bvd=10                    xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_25                cjd=cjp_25                mjs=0.32
+ mjd=0.32                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswp_25            cjswd=cjswp_25            mjsws=0.085
+ mjswd=0.085               pbswgs=0.9                pbswgd=0.9
+ cjswgs=cjswgp_25          cjswgd=cjswgp_25          mjswgs=0.5
+ mjswgd=0.5                tpb=1.55e-3               tcj=8.5e-4
+ tpbsw=1e-3                tcjsw=3e-4                tpbswg=1.34e-3
+ tcjswg=1.55e-3            xtis=3                    xtid=3
+ jtsswgs=2.148e-008        jtsswgd=2.148e-008        njtsswg=39.97
+ xtsswgs=0.02              xtsswgd=0.02              tnjtsswg=1
+ vtsswgs=1                 vtsswgd=1                 dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ rshg=15.882               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   saref=4.6e-007
+ sbref=4.6e-007            wlod=0                    kvth0=1.1e-009
+ lkvth0=-1.5e-007          wkvth0=3e-007             pkvth0=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=0.5                 lodeta0=1                 ku0=3.9e-009
+ lku0=1.5e-008             wku0=1.1e-006             pku0=2e-015
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=5e-009             tku0=0                    lnfactor=0+dlnfactorp_25
+ wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25
+ wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25        leta0=0+dleta0p_25
+ peta0=0+dpeta0p_25        fnoimod=1                 noia=noiap_25
+ noib=noibp_25             noic=noicp_25             em=3e+7
+ ef=1.15         tnoimod=0                 minr=1e-3
 
 
     15: type=p 
+ lmin=2.8e-07              lmax=3.8e-007-dxlp_25     wmin=6e-007-dxwp_25
+ wmax=1e-006-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.47747622+dvthp_25 lvth0=-3.0736427e-008+dlvthp_25
+ wvth0=-9.5099023e-008+dwvthp_25                     pvth0=2.0289172e-014+dpvthp_25
+ k1=0.7812                 k2=0.0079225279+dk2_25    lk2=-3.0713694e-008
+ wk2=-3.112177e-008        pk2=1.2012113e-014        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0056999991     lkvth0we=-2.48e-009       wkvth0we=-2.2000074e-010
+ pkvth0we=-3.0318943e-029  k2we=0.012500004          lk2we=-6.0000127e-010
+ wk2we=-1.0000325e-010     pk2we=-5.9999899e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0029740983+dcitp_25 lcit=-7.6015379e-010+dlcitp_25
+ wcit=-5.4397731e-010+dwcitp_25                      pcit=1.5933976e-016+dpcitp_25
+ voff=0.036632392          lvoff=-1.9907023e-008     wvoff=-7.8550406e-008
+ pvoff=1.9345071e-014      nfactor=0.63002+dnfactorp_25
+ eta0=0.26581349           leta0=1.0592355e-007+dleta0p_25
+ weta0=-2.0201775e-007     peta0=4.1386127e-014+dpeta0p_25
+ etab=-0.089126238         letab=2.4350514e-008      wetab=3.2854622e-008
+ petab=-1.478076e-014      ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.015
+ lku0we=-1.0000011e-010    wku0we=-1.1999995e-009    pku0we=-9.095683e-029
+ u0=-0.0017480098+du0p_25  lu0=4.6885654e-009+dlu0p_25
+ wu0=1.3077214e-008+dwu0p_25                         pu0=-3.573989e-015+dpu0p_25
+ ua=-2.4049192e-009        lua=8.4797429e-016        wua=2.4339192e-015
+ pua=-6.6839813e-022       ub=6.9356968e-019         lub=5.2617965e-025
+ wub=2.3623246e-025        pub=-2.1077371e-031       uc=-3.9503292e-011
+ luc=2.9348297e-017        wuc=2.1509852e-016        puc=-6.267044e-023
+ vsat=110000+dvsatp_25     a0=0.93467947             la0=5.8451208e-008+dla0p_25
+ wa0=4.9143672e-007+dwa0p_25                         pa0=-2.5171649e-013+dpa0p_25
+ ags=-0.53283877           lags=4.9848872e-007       wags=2.857924e-008
+ pags=3.2921626e-014       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.24052271
+ lketa=5.5742146e-008      wketa=5.6555843e-008      pketa=-1.0937777e-014
+ dwg=0                     dwb=0                     pclm=-0.85447445
+ lpclm=4.0202087e-007      wpclm=5.4875558e-007      ppclm=-1.0319988e-013
+ pdiblc1=0                 pdiblc2=1.0101898e-005    lpdiblc2=-2.4352954e-014
+ wpdiblc2=-5.5782049e-014  ppdiblc2=1.4782243e-020   pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.37644805           lkt1=1.1259539e-008
+ wkt1=-9.0709757e-009      pkt1=3.3109061e-015       kt1l=0
+ kt2=-0.17021934           lkt2=4.2220952e-008       wkt2=3.8799047e-008
+ pkt2=-1.2711464e-014      ute=-1                    ua1=4.7143645e-010
+ lua1=7.3008707e-016       wua1=1.263849e-015        pua1=-3.5532959e-022
+ ub1=-1.743e-018           lub1=-9.47905e-025        uc1=-4.3247073e-010
+ luc1=1.1394688e-016       wuc1=2.550436e-016        puc1=-6.7991507e-023
+ prt=0                     at=38500.03               lat=-0.0096725075
+ wat=-2.5053569e-008       pat=6.3557288e-015        jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25
+ cjd=cjp_25                mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25
+ cjswd=cjswp_25            mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25
+ cjswgd=cjswgp_25          mjswgs=0.5                mjswgd=0.5
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=1.34e-3            tcjswg=1.55e-3
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=0                    kvth0=1.1e-009            lkvth0=-1.5e-007
+ wkvth0=3e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-009              lku0=1.5e-008
+ wku0=1.1e-006             pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-009
+ tku0=0                    lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25
+ pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25
+ pvsat=0+dpvsatp_25        fnoimod=1                 noia=noiap_25
+ noib=noibp_25             noic=noicp_25             em=3e+7
+ ef=1.15         tnoimod=0                 minr=1e-3
 
 
     16: type=p 
+ lmin=1e-005-dxlp_25       lmax=0.000901             wmin=4e-07
+ wmax=6e-007-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.6319185+dvthp_25  wvth0=-1.3464171e-008+dwvthp_25
+ k1=0.7812                 k2=-0.085679553+dk2_25    wk2=6.7156503e-009
+ k3=-3.442                 k3b=3                     w0=0
+ dvt0=6.767                dvt1=0.2284               dvt2=0.000377
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.288                minv=0                    voffl=-2.31e-009
+ dvtp0=0                   dvtp1=4.55                lpe0=0
+ lpeb=4.44089e-021         web=-250                  wec=-3500
+ scref=1e-006              kvth0we=-0.0059483726     lkvth0we=0
+ wkvth0we=-2.1999998e-010  pkvth0we=0                k2we=0.01243991
+ lk2we=0                   wk2we=-1.6009022e-010     pk2we=0
+ xj=9.5e-008               ngate=1.842e+020          ndep=7.81e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00086225063+dcitp_25
+ lcit=2.0547185e-016+dlcitp_25                       wcit=5.2732981e-010+dwcitp_25
+ pcit=-1.2472142e-022+dpcitp_25                      voff=-0.15
+ nfactor=0.63002+dnfactorp_25                        eta0=0.4507
+ weta0=-2.47049e-008       etab=-0.035               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015010016        lku0we=0                  wku0we=-1.1999998e-009
+ pku0we=0                  u0=0.0141707+du0p_25      wu0=-2.47049e-011+dwu0p_25
+ ua=1.6786581e-009         lua=2.0547184e-022        wua=-3.1968144e-016
+ pua=-1.2472142e-028       ub=4.3173214e-019         wub=1.1293105e-025
+ uc=-2.4755746e-011        luc=1.6473088e-023        wuc=9.5200337e-018
+ puc=-1.1224927e-029       vsat=110000+dvsatp_25     a0=1.195645
+ wa0=-5.8056515e-008+dwa0p_25                        ags=0.2898
+ a1=0                      a2=0.5                    b0=0
+ b1=0                      keta=-0.013511756         lketa=1.1247943e-014
+ wketa=2.9559417e-009      pketa=-4.9888567e-021     dwg=0
+ dwb=0                     pclm=0.22958              wpclm=1.482294e-008
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   wagidl=0
+ bgidl=2.041e-9            lbgidl=0                  wbgidl=0
+ pbgidl=0                  cgidl=0.5                 egidl=0.8
+ aigbacc=0.43              bigbacc=0.054             cigbacc=0.075
+ nigbacc=1                 aigbinv=0.35              bigbinv=0.03
+ cigbinv=0.006             eigbinv=1.1               nigbinv=3
+ aigc=0.43                 bigc=0.054                cigc=0.075
+ aigsd=0.43                bigsd=0.054               cigsd=0.075
+ nigc=1                    poxedge=1                 pigcd=1
+ ntox=1                    xrcrg1=12                 xrcrg2=1
+ vfbsdoff=0                lvfbsdoff=0               wvfbsdoff=0
+ pvfbsdoff=0               cgso=cgop_25              cgdo=cgop_25
+ cgbo=0                    cgdl=cglp_25              cgsl=cglp_25
+ clc=1e-007                cle=0.6                   cf=cfp_25
+ ckappas=0.6               ckappad=0.6               acde=1.03
+ moin=6.502                noff=3.7071               voffcv=0.00514
+ tvoff=0                   ltvoff=0                  wtvoff=0
+ ptvoff=0                  tvfbsdoff=0               ltvfbsdoff=0
+ wtvfbsdoff=0              ptvfbsdoff=0              kt1=-0.32319445
+ wkt1=1.6203376e-008       kt1l=0                    kt2=-0.046
+ ute=-1                    ua1=2.7599998e-009        lua1=-2.0547186e-021
+ wua1=1.2214022e-022       pua1=1.2472142e-027       ub1=-3.5588598e-018
+ wub1=1.164589e-025        uc1=-3.2000001e-011       luc1=2.0547185e-023
+ wuc1=1.3842785e-026       puc1=-1.2472142e-029      prt=0
+ at=200000                 jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lvth0=0+dlvthp_25         pvth0=0+dpvthp_25         lu0=0+dlu0p_25
+ pu0=0+dpu0p_25            la0=0+dla0p_25            pa0=0+dpa0p_25
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     17: type=p 
+ lmin=1.2e-006-dxlp_25     lmax=1e-005-dxlp_25       wmin=4e-07
+ wmax=6e-007-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.6338106+dvthp_25  lvth0=1.8892567e-008+dlvthp_25
+ wvth0=-1.3697042e-008+dwvthp_25                     pvth0=2.3252245e-015+dpvthp_25
+ k1=0.7812                 k2=-0.085460584+dk2_25    lk2=-2.1864048e-009
+ wk2=6.705958e-009         pk2=9.6777504e-017        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0057000001     lkvth0we=-2.4799999e-009  wkvth0we=-2.1999998e-010
+ pkvth0we=1.0766796e-029   k2we=0.0125               lk2we=-6.0000147e-010
+ wk2we=-1.0000016e-010     pk2we=-5.9999927e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00097903379+dcitp_25
+ lcit=1.1660801e-009+dlcitp_25                       wcit=5.9833955e-010+dwcitp_25
+ pcit=-7.0903239e-016+dpcitp_25                      voff=-0.15493492
+ lvoff=4.9275167e-008      wvoff=-2.4950545e-010     pvoff=2.491312e-015
+ nfactor=0.63002+dnfactorp_25                        eta0=0.4507
+ weta0=-2.47049e-008       etab=-0.035               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015000001        lku0we=-9.9999781e-011    wku0we=-1.1999998e-009
+ pku0we=-3.588932e-030     u0=0.014154494+du0p_25    lu0=1.6181912e-010+dlu0p_25
+ wu0=-2.304153e-011+dwu0p_25                         pu0=-1.6608746e-017+dpu0p_25
+ ua=1.7235269e-009         lua=-4.4801485e-016       wua=-3.2397294e-016
+ pua=4.2850466e-023        ub=3.7276656e-019         lub=5.8877133e-025
+ wub=1.1682733e-025        pub=-3.8904344e-032       uc=-3.5278208e-011
+ luc=1.050668e-016         wuc=1.1542192e-017        puc=-2.0191257e-023
+ vsat=110000+dvsatp_25     a0=1.2327631              la0=-3.706244e-007+dla0p_25
+ wa0=-6.5874356e-008+dwa0p_25                        pa0=7.8061141e-014+dpa0p_25
+ ags=0.26620564            lags=2.3558968e-007       wags=5.48912e-010
+ pags=-5.4808863e-015      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.0089796555
+ lketa=-4.5253011e-008     wketa=2.6038058e-009      pketa=3.5160718e-015
+ dwg=0                     dwb=0                     pclm=0.20942652
+ lpclm=2.0123253e-007      wpclm=1.5122347e-008      ppclm=-2.9895743e-015
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.32334453           lkt1=1.4984624e-009
+ wkt1=1.8385308e-008       pkt1=-2.1786589e-014      kt1l=0
+ kt2=-0.044922727          lkt2=-1.0756568e-008      ute=-1
+ ua1=2.7902526e-009        lua1=-3.020767e-016       wua1=-1.8363354e-017
+ pua1=1.8336056e-022       ub1=-3.510229e-018        lub1=-4.8557865e-025
+ wub1=1.3214115e-025       pub1=-1.5658726e-031      uc1=-2.8229544e-011
+ luc1=-3.7647989e-017      wuc1=-1.235245e-024       puc1=6.6849067e-038
+ prt=0                     at=202116.84              lat=-0.021136657
+ wat=0.0013306958          pat=-1.3286997e-008       jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25
+ cjd=cjp_25                mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25
+ cjswd=cjswp_25            mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25
+ cjswgd=cjswgp_25          mjswgs=0.5                mjswgd=0.5
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=1.34e-3            tcjswg=1.55e-3
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=0                    kvth0=1.1e-009            lkvth0=-1.5e-007
+ wkvth0=3e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-009              lku0=1.5e-008
+ wku0=1.1e-006             pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-009
+ tku0=0                    lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25
+ pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25
+ pvsat=0+dpvsatp_25        leta0=0+dleta0p_25        peta0=0+dpeta0p_25
+ fnoimod=1                 noia=noiap_25             noib=noibp_25
+ noic=noicp_25             em=3e+7            ef=1.15
+ tnoimod=0                 minr=1e-3
 
 
     18: type=p 
+ lmin=7e-007-dxlp_25       lmax=1.2e-006-dxlp_25     wmin=4e-07
+ wmax=6e-007-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.61535313+dvthp_25 lvth0=-2.9795237e-009+dlvthp_25
+ wvth0=-1.475791e-008+dwvthp_25                      pvth0=3.5823524e-015+dpvthp_25
+ k1=0.7812                 k2=-0.094121919+dk2_25    lk2=8.0772764e-009
+ wk2=9.5244081e-009        pk2=-3.2430858e-015       k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0056999998     lkvth0we=-2.4800002e-009  wkvth0we=-2.1999998e-010
+ pkvth0we=3.4880629e-029   k2we=0.0125               lk2we=-6.0000093e-010
+ wk2we=-1e-010             pk2we=-5.9999945e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=5.0000709e-006+dcitp_25
+ lcit=-4.8564695e-017+dlcitp_25                      wcit=-4.3034701e-017+dwcitp_25
+ pcit=2.947877e-023+dpcitp_25                        voff=-0.13320196
+ lvoff=2.3521612e-008      wvoff=4.2051463e-009      pvoff=-2.7874503e-015
+ nfactor=0.63002+dnfactorp_25                        eta0=0.4507
+ weta0=-2.47049e-008       etab=-0.035               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015000001        lku0we=-9.999965e-011     wku0we=-1.1999998e-009
+ pku0we=1.3952252e-029     u0=0.01223845+du0p_25     lu0=2.4323307e-009+dlu0p_25
+ wu0=-1.2167333e-010+dwu0p_25                        pu0=1.0026993e-016+dpu0p_25
+ ua=1.2933492e-009         lua=6.1745716e-017        wua=-4.2641032e-016
+ pua=1.6423876e-022        ub=5.153517e-019          lub=4.1980794e-025
+ wub=2.092258e-025         pub=-1.4839653e-031       uc=-3.4006329e-011
+ luc=1.0355962e-016        wuc=4.1661003e-018        puc=-1.1450589e-023
+ vsat=110000+dvsatp_25     a0=0.67363358             la0=2.9194411e-007+dla0p_25
+ wa0=1.3998111e-007+dwa0p_25                         pa0=-1.6587758e-013+dpa0p_25
+ ags=0.31315619            lags=1.7995328e-007       wags=-5.2436417e-008
+ pags=5.7306729e-014       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.014415603
+ lketa=-3.8811413e-008     wketa=3.794055e-009       pketa=2.1056264e-015
+ dwg=0                     dwb=0                     pclm=0.19914691
+ lpclm=2.1341387e-007      wpclm=6.3706526e-008      ppclm=-6.0561827e-014
+ pdiblc1=0                 pdiblc2=1e-005            pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.3112296            lkt1=-1.2857724e-008
+ kt1l=0                    kt2=-0.06496              lkt2=1.29876e-008
+ ute=-1                    ua1=2.3041004e-009        lua1=2.740137e-016
+ wua1=1.6656201e-016       pua1=-3.5775997e-023      ub1=-3.7282e-018
+ lub1=-2.27283e-025        uc1=-1.6159991e-011       luc1=-5.195041e-017
+ wuc1=-6.3121019e-024      puc1=6.0160754e-030       prt=0
+ at=304839.97              lat=-0.14286356           wat=-0.0098819465
+ pat=-1.6042869e-014       jss=1.38e-07              jsd=1.38e-07
+ jsws=4.11e-13             jswd=4.11e-13             jswgs=4.11e-13
+ jswgd=4.11e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=10                    bvd=10
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_25                cjd=cjp_25
+ mjs=0.32                  mjd=0.32                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswp_25            cjswd=cjswp_25
+ mjsws=0.085               mjswd=0.085               pbswgs=0.9
+ pbswgd=0.9                cjswgs=cjswgp_25          cjswgd=cjswgp_25
+ mjswgs=0.5                mjswgd=0.5                tpb=1.55e-3
+ tcj=8.5e-4                tpbsw=1e-3                tcjsw=3e-4
+ tpbswg=1.34e-3            tcjswg=1.55e-3            xtis=3
+ xtid=3                    jtsswgs=2.148e-008        jtsswgd=2.148e-008
+ njtsswg=39.97             xtsswgs=0.02              xtsswgd=0.02
+ tnjtsswg=1                vtsswgs=1                 vtsswgd=1
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             rshg=15.882               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-007            sbref=4.6e-007            wlod=0
+ kvth0=1.1e-009            lkvth0=-1.5e-007          wkvth0=3e-007
+ pkvth0=0                  llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=0.5                 lodeta0=1
+ ku0=3.9e-009              lku0=1.5e-008             wku0=1.1e-006
+ pku0=2e-015               llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=5e-009             tku0=0
+ lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25  pnfactor=0+dpnfactorp_25
+ lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25        pvsat=0+dpvsatp_25
+ leta0=0+dleta0p_25        peta0=0+dpeta0p_25        fnoimod=1
+ noia=noiap_25             noib=noibp_25             noic=noicp_25
+ em=3e+7            ef=1.15         tnoimod=0
+ minr=1e-3
 
 
     19: type=p 
+ lmin=3.8e-007-dxlp_25     lmax=7e-007-dxlp_25       wmin=4e-07
+ wmax=6e-007-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.67470707+dvthp_25 lvth0=3.7677924e-008+dlvthp_25
+ wvth0=1.7891206e-008+dwvthp_25                      pvth0=-1.8782292e-014+dpvthp_25
+ k1=0.7812                 k2=-0.087227646+dk2_25    lk2=3.3546997e-009
+ wk2=6.9593273e-009        pk2=-1.4860055e-015       k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0056999993     lkvth0we=-2.4800006e-009  wkvth0we=-2.200004e-010
+ pkvth0we=2.8953951e-022   k2we=0.012499997          lk2we=-5.9999881e-010
+ wk2we=-9.9998273e-011     pk2we=-6.0000064e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.0016812127+dcitp_25
+ lcit=1.1550557e-009+dlcitp_25                       wcit=5.3230209e-010+dwcitp_25
+ pcit=-3.6462693e-016+dpcitp_25                      voff=-0.21282806
+ lvoff=7.8065492e-008      wvoff=4.2559397e-008      pvoff=-2.9060112e-014
+ nfactor=0.63002+dnfactorp_25                        eta0=0.4507
+ weta0=-2.47049e-008       etab=-0.035               ud=0
+ lud=0                     wud=0                     pud=0
+ ku0we=-0.015000003        lku0we=-9.9998253e-011    wku0we=-1.1999984e-009
+ pku0we=-9.6513164e-022    u0=0.020282731+du0p_25    lu0=-3.0780015e-009+dlu0p_25
+ wu0=-3.173612e-009+dwu0p_25                         pu0=2.1908479e-015+dpu0p_25
+ ua=2.7318184e-009         lua=-9.236057e-016        wua=-8.9098077e-016
+ pua=4.8246952e-022        ub=3.0054969e-019         lub=5.6694731e-025
+ wub=1.7857011e-025        pub=-1.2739738e-031       uc=1.054461e-010
+ luc=8.0347105e-018        wuc=-1.6438792e-017       puc=2.6637624e-024
+ vsat=110000+dvsatp_25     a0=0.74611459             la0=2.4229461e-007+dla0p_25
+ wa0=2.2552191e-007+dwa0p_25                         pa0=-2.2447303e-013+dpa0p_25
+ ags=0.5758242             lags=2.5696319e-011       wags=-2.4657031e-007
+ pags=1.9028845e-013       a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.074102503
+ lketa=2.0741136e-009      wketa=-2.2056844e-009     pketa=6.2154479e-015
+ dwg=0                     dwb=0                     pclm=0.36110191
+ lpclm=1.0247469e-007      wpclm=-8.2894604e-008     ppclm=3.9859947e-014
+ pdiblc1=0                 pdiblc2=9.965382e-006     lpdiblc2=2.3713309e-014
+ wpdiblc2=1.4089513e-014   ppdiblc2=-9.6513166e-021  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.26729155           lkt1=-4.2955288e-008
+ wkt1=-2.7263222e-008      pkt1=1.8675307e-014       kt1l=0
+ kt2=-0.043718752          lkt2=-1.5626547e-009      wkt2=1.4089517e-015
+ pkt2=-9.6513149e-022      ute=-1                    ua1=2.8878986e-009
+ lua1=-1.2588806e-016      wua1=-3.7043594e-017      pua1=1.0369384e-022
+ ub1=-3.740625e-018        lub1=-2.1877188e-025      uc1=-1.8895311e-010
+ luc1=6.6412876e-017       wuc1=-1.8972584e-024      puc1=2.991908e-030
+ prt=0                     at=173842.56              lat=-0.053130337
+ wat=-0.0098819834         pat=9.2652639e-015        jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25
+ cjd=cjp_25                mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25
+ cjswd=cjswp_25            mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25
+ cjswgd=cjswgp_25          mjswgs=0.5                mjswgd=0.5
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=1.34e-3            tcjswg=1.55e-3
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=0                    kvth0=1.1e-009            lkvth0=-1.5e-007
+ wkvth0=3e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-009              lku0=1.5e-008
+ wku0=1.1e-006             pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-009
+ tku0=0                    lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25
+ pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25
+ pvsat=0+dpvsatp_25        leta0=0+dleta0p_25        peta0=0+dpeta0p_25
+ fnoimod=1                 noia=noiap_25             noib=noibp_25
+ noic=noicp_25             em=3e+7            ef=1.15
+ tnoimod=0                 minr=1e-3
 
 
     20: type=p 
+ lmin=2.8e-07              lmax=3.8e-007-dxlp_25     wmin=4e-07
+ wmax=6e-007-dxwp_25       version=4.5               rgeomod=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_25      permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 wpemod=1
+ tnom=25                   toxe=toxp_25              toxm=5.9e-009
+ dtox=3.946e-010           epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.5e-08+dxlp_25
+ xw=7e-09+dxwp_25          dlc=0+dlcp_25             dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.46455035+dvthp_25 lvth0=-3.9029278e-008+dlvthp_25
+ wvth0=-1.0294503e-007+dwvthp_25                     pvth0=2.5322932e-014+dpvthp_25
+ k1=0.7812                 k2=-0.0070360283+dk2_25   lk2=-2.5915241e-008
+ wk2=-2.2041926e-008       pk2=9.0994521e-015        k3=-3.442
+ k3b=3                     w0=0                      dvt0=6.767
+ dvt1=0.2284               dvt2=0.000377             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.288
+ minv=0                    voffl=-2.31e-009          dvtp0=0
+ dvtp1=4.55                lpe0=0                    lpeb=4.44089e-021
+ web=-250                  wec=-3500                 scref=1e-006
+ kvth0we=-0.0057000009     lkvth0we=-2.48e-009       wkvth0we=-2.1999961e-010
+ pkvth0we=-1.9810887e-029  k2we=0.012499997          lk2we=-5.999988e-010
+ wk2we=-9.9998691e-011     pk2we=-6.0000049e-016     xj=9.5e-008
+ ngate=1.842e+020          ndep=7.81e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0043448549+dcitp_25 lcit=-1.044459e-009+dlcitp_25
+ wcit=-1.3760265e-009+dwcitp_25                      pcit=3.3191301e-016+dpcitp_25
+ voff=0.16560633           lvoff=-6.0063062e-008     wvoff=-1.5683759e-007
+ pvoff=4.3719787e-014      nfactor=0.63002+dnfactorp_25
+ eta0=0.10851907           leta0=1.2489604e-007+dleta0p_25
+ weta0=-1.0654005e-007     peta0=2.9869828e-014+dpeta0p_25
+ etab=-0.035000024         letab=8.8068113e-015      wetab=9.820197e-015
+ petab=-3.5843721e-021     ud=0                      lud=0
+ wud=0                     pud=0                     ku0we=-0.014999992
+ lku0we=-1.0000208e-010    wku0we=-1.2000043e-009    pku0we=1.1947909e-021
+ u0=0.01513585+du0p_25     lu0=-1.19939e-009+dlu0p_25
+ wu0=2.8287111e-009+dwu0p_25                         pu0=1.9810887e-029+dpu0p_25
+ ua=1.0338773e-009         lua=-3.0385719e-016       wua=3.4656975e-016
+ pua=3.0763579e-023        ub=1.6547885e-018         lub=7.2650148e-026
+ wub=-3.4722737e-025       pub=6.4518699e-032        uc=3.6982531e-010
+ luc=-8.8463702e-017       wuc=-3.3363945e-017       puc=8.841443e-024
+ vsat=110000+dvsatp_25     a0=5.4279813              la0=-1.4665867e-006+dla0p_25
+ wa0=-2.2359975e-006+dwa0p_25                        pa0=6.7398154e-013+dpa0p_25
+ ags=-3.3675323            lags=1.4393508e-006       wags=1.7492382e-006
+ pags=-5.3818165e-013      a1=0                      a2=0.5
+ b0=0                      b1=0                      keta=-0.22030473
+ lketa=5.5437928e-008      wketa=4.4283532e-008      pketa=-1.0753116e-014
+ dwg=0                     dwb=0                     pclm=-0.85801665
+ lpclm=5.4745297e-007      wpclm=5.509057e-007       ppclm=-1.9147716e-013
+ pdiblc1=0                 pdiblc2=1.0084278e-005    lpdiblc2=-1.9683538e-014
+ wpdiblc2=-4.5086443e-014  ppdiblc2=1.1947907e-020   pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0072
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=200
+ pdits=0.039               pditsd=1.73               pditsl=1000000
+ rsh=15.5                  rdsw=0                    rsw=21.04
+ rdw=21.04                 prwg=0                    prwb=0
+ wr=1                      alpha0=3.53e-007          alpha1=0.296
+ beta0=26.3                agidl=0                   lagidl=0
+ wagidl=0                  pagidl=0                  bgidl=2.041e-9
+ lbgidl=0                  wbgidl=0                  pbgidl=0
+ cgidl=0.5                 egidl=0.8                 aigbacc=0.43
+ bigbacc=0.054             cigbacc=0.075             nigbacc=1
+ aigbinv=0.35              bigbinv=0.03              cigbinv=0.006
+ eigbinv=1.1               nigbinv=3                 aigc=0.43
+ bigc=0.054                cigc=0.075                aigsd=0.43
+ bigsd=0.054               cigsd=0.075               nigc=1
+ poxedge=1                 pigcd=1                   ntox=1
+ xrcrg1=12                 xrcrg2=1                  vfbsdoff=0
+ lvfbsdoff=0               wvfbsdoff=0               pvfbsdoff=0
+ cgso=cgop_25              cgdo=cgop_25              cgbo=0
+ cgdl=cglp_25              cgsl=cglp_25              clc=1e-007
+ cle=0.6                   cf=cfp_25                 ckappas=0.6
+ ckappad=0.6               acde=1.03                 moin=6.502
+ noff=3.7071               voffcv=0.00514            tvoff=0
+ ltvoff=0                  wtvoff=0                  ptvoff=0
+ tvfbsdoff=0               ltvfbsdoff=0              wtvfbsdoff=0
+ ptvfbsdoff=0              kt1=-0.49025136           lkt1=3.8425042e-008
+ wkt1=6.000763e-008        pkt1=-1.3178554e-014      kt1l=0
+ kt2=-0.11708547           lkt2=2.5216196e-008       wkt2=6.5467842e-009
+ pkt2=-2.3895767e-015      ute=-1                    ua1=1.8790789e-009
+ lua1=2.4233114e-016       wua1=4.0941005e-016       pua1=-5.926174e-023
+ ub1=-1.743e-018           lub1=-9.47905e-025        uc1=-1.23001e-011
+ luc1=1.9345279e-018       wuc1=2.8558864e-023       puc1=-8.1245769e-030
+ prt=0                     at=97921.972              lat=-0.025419322
+ wat=-0.036069144          pat=9.5583228e-009        jss=1.38e-07
+ jsd=1.38e-07              jsws=4.11e-13             jswd=4.11e-13
+ jswgs=4.11e-13            jswgd=4.11e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=10
+ bvd=10                    xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_25
+ cjd=cjp_25                mjs=0.32                  mjd=0.32
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswp_25
+ cjswd=cjswp_25            mjsws=0.085               mjswd=0.085
+ pbswgs=0.9                pbswgd=0.9                cjswgs=cjswgp_25
+ cjswgd=cjswgp_25          mjswgs=0.5                mjswgd=0.5
+ tpb=1.55e-3               tcj=8.5e-4                tpbsw=1e-3
+ tcjsw=3e-4                tpbswg=1.34e-3            tcjswg=1.55e-3
+ xtis=3                    xtid=3                    jtsswgs=2.148e-008
+ jtsswgd=2.148e-008        njtsswg=39.97             xtsswgs=0.02
+ xtsswgd=0.02              tnjtsswg=1                vtsswgs=1
+ vtsswgd=1                 dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             rshg=15.882
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   saref=4.6e-007            sbref=4.6e-007
+ wlod=0                    kvth0=1.1e-009            lkvth0=-1.5e-007
+ wkvth0=3e-007             pkvth0=0                  llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=0.5
+ lodeta0=1                 ku0=3.9e-009              lku0=1.5e-008
+ wku0=1.1e-006             pku0=2e-015               llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=5e-009
+ tku0=0                    lnfactor=0+dlnfactorp_25  wnfactor=0+dwnfactorp_25
+ pnfactor=0+dpnfactorp_25  lvsat=0+dlvsatp_25        wvsat=0+dwvsatp_25
+ pvsat=0+dpvsatp_25        fnoimod=1                 noia=noiap_25
+ noib=noibp_25             noic=noicp_25             em=3e+7
+ ef=1.15         tnoimod=0                 minr=1e-3
 
     } 
endsection mos_25
 
// **************************************************************
//                                                              *
//                      1.8V IO DEVICE MODELS                   *
//                                                              *
// **************************************************************

section mos_25ud18
// *********************************************************************************************
//                                                                            
//                   *
//                                    1.8V NMOS DEVICE MODELS                 
//                     *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt nch_25ud18_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=9.25e-008 xw= + 7e-09 
+ + dxwn_25ud18 ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg / factor 
+ * (w / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) ps=4 
+ * dmcg / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf + xw 
+ / factor) nrs=dmcg / factor / (w / nf + xw / factor) sa=4.6e-7 / factor sb=4.6e-7 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parn1_25ud18 temp2=parn2_25ud18 fac1=0.308877 * temp1 * sigma 
+ + 0.951102 * temp2 * sigma fac2=0.308877 * temp1 * sigma - 0.951102 * temp2 * 
+ sigma lef=l * factor - 1.5e-08 wef=w / nf * factor + 7e-09 geo_fac=1 / sqrt(multi 
+ * nf * lef * wef * 1e12) vthmisn_25ud18=0.00762502 * geo_fac * fac1 * mismatchflag 
+ dlmisn_25ud18=0.00261377 * geo_fac * lef * fac2 * mismatchflag dwmisn_25ud18= 
+ - 0.00261377 * geo_fac * wef * fac2 * mismatchflag toxmisn_25ud18=0.00261377 * 
+ geo_fac * toxn_25ud18 * fac2 * mismatchflag tnoiax=1.273e5 / (l * 1e6) + 8.395e6 
+ rnoiax=0.0353 / (l * 1e6) + 0.4701 
nch_25ud18_mac ( n1 n2 n3 n4 ) nch_25ud18 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs 
+ m=multi nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model nch_25ud18 bsim4  { 
     1: type=n 
+ lmin=1e-005-(dxln_25ud18+dlmisn_25ud18)             lmax=0.000901
+ wmin=1e-005-(dxwn_25ud18+dwmisn_25ud18)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.555+(dvthn_25ud18+vthmisn_25ud18)
+ k1=0.3969                 kvth0=-3.5e-08            pkvth0=0
+ wkvth0=6.8e-006           lkvth0=2.5e-6             k2=0.0788+dk2n_25ud18
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            xj=8.1e-008               ngate=4.282e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00014300001+dcitn_25ud18                      voff=-0.106
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0311+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 ua=-1.31e-009             ub=3.01e-018
+ uc=1.25e-010              vsat=98400                a0=1.72
+ ags=0.45                  kvsat=0                   a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.058               dwg=0                     dwb=0
+ pclm=0.52000001           pdiblc1=0                 pdiblc2=0.00093500003
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25ud18          cgdo=cgon_25ud18
+ cgbo=0                    cgdl=cgln_25ud18          cgsl=cgln_25ud18
+ clc=1e-007                cle=0.6                   cf=cfn_25ud18
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.33799999           kt1l=0                    kt2=-0.064155
+ ute=-1.65                 ua1=1.0998e-009           ub1=-1.23212e-018
+ uc1=1.2194e-010           prt=0                     at=158518.82
+ fnoimod=1                 tnoimod=1                 noia=noian_25ud18
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25ud18
+ rnoib=0                   noic=noicn_25ud18         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25ud18            cjd=cjn_25ud18
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25ud18        cjswd=cjswn_25ud18
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-08            rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   lcit=0+dlcitn_25ud18      wcit=0+dwcitn_25ud18
+ pcit=0+dpcitn_25ud18      leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18
+ peta0=0+dpeta0n_25ud18    lvth0=0+dlvthn_25ud18     wvth0=0+dwvthn_25ud18
+ pvth0=0+dpvthn_25ud18     lu0=0+dlu0n_25ud18        wu0=0+dwu0n_25ud18
+ pu0=0+dpu0n_25ud18        lk2=0+dlk2n_25ud18        wk2=0+dwk2n_25ud18
+ pk2=0+dpk2n_25ud18        saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=8.5e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=1.5e-2
+ pkvth0we=-11e-17          wkvth0we=-3e-10           lkvth0we=+5.83e-9
+ ku0we=-0.002              pku0we=-5e-17             wku0we=-0.9e-9
+ lku0we=-2e-10             k2we=0.0040               pk2we=-2e-17
+ lk2we=0e-10               wk2we=0.4e-9              minr=1e-3
 
 
     2: type=n 
+ lmin=1.2e-006-(dxln_25ud18+dlmisn_25ud18)           lmax=1e-005-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-005-(dxwn_25ud18+dwmisn_25ud18)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.55634659+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-1.344571e-008+dlvthn_25ud18
+ k1=0.3969                 k2=0.079742614+dk2n_25ud18
+ lk2=-9.4119972e-009+dlk2n_25ud18                    k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00014300001+dcitn_25ud18
+ voff=-0.106               nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.031073068+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=2.6891421e-010+dlu0n_25ud18
+ ua=-1.31e-009             ub=3.0073068e-018         lub=2.6891421e-026
+ uc=1.25e-010              vsat=98400                a0=1.7873296
+ kvsat=0                   la0=-6.7228551e-007       ags=0.45
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.058               dwg=0
+ dwb=0                     pclm=0.52000001           pdiblc1=0
+ pdiblc2=0.00093500003     pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.3366534            lkt1=-1.3445724e-008
+ kt1l=0                    kt2=-0.064155             ute=-1.6769318
+ lute=2.6891421e-007       ua1=1.0998e-009           ub1=-1.2725177e-018
+ lub1=4.0337119e-025       uc1=1.2194e-010           prt=0
+ at=178717.69              lat=-0.20168566           fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lcit=0+dlcitn_25ud18      wcit=0+dwcitn_25ud18      pcit=0+dpcitn_25ud18
+ leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18
+ wvth0=0+dwvthn_25ud18     pvth0=0+dpvthn_25ud18     wu0=0+dwu0n_25ud18
+ pu0=0+dpu0n_25ud18        wk2=0+dwk2n_25ud18        pk2=0+dpk2n_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     3: type=n 
+ lmin=7e-007-(dxln_25ud18+dlmisn_25ud18)             lmax=1.2e-006-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-005-(dxwn_25ud18+dwmisn_25ud18)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.53952+(dvthn_25ud18+vthmisn_25ud18)
+ lvth0=6.4938e-009+dlvthn_25ud18                     kvth0=-3.5e-08
+ pkvth0=0                  wkvth0=6.8e-006           lkvth0=2.5e-6
+ k1=0.3969                 k2=0.071526+dk2n_25ud18   lk2=3.2469e-010+dlk2n_25ud18
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            xj=8.1e-008               ngate=4.282e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=9.505001e-005+dcitn_25ud18                      lcit=5.682075e-011+dlcitn_25ud18
+ voff=-0.11422             lvoff=9.7407e-009         nfactor=0.55
+ eta0=0.35079+deta0n_25ud18                          etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.0313+du0n_25ud18     ua=-1.31e-009
+ ub=2.9478e-018            ku0=-6.6e-8               pku0=2.0e-15
+ wku0=20.8e-07             lku0=7e-7                 lub=9.7407e-026
+ uc=1.1404e-010            luc=1.29876e-017          vsat=98400
+ a0=1.2337                 la0=-1.62345e-008         kvsat=0
+ ags=0.5185                lags=-8.11725e-008        a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.058               dwg=0                     dwb=0
+ pclm=0.52000002           lpclm=-1.62345e-014       pdiblc1=0
+ pdiblc2=0.0010720001      lpdiblc2=-1.6234511e-010  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.33841
+ lkt1=-1.136415e-008       kt1l=0                    kt2=-0.059403839
+ lkt2=-5.6301262e-009      ute=-1.313                lute=-1.62345e-007
+ ua1=1.3184931e-009        lua1=-2.5915132e-016      ub1=-3.6099461e-019
+ lub1=-6.7678369e-025      uc1=1.6616359e-010        luc1=-5.2404958e-017
+ prt=0                     at=8518.8291              lat=-1.980609e-008
+ fnoimod=1                 tnoimod=1                 noia=noian_25ud18
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25ud18
+ rnoib=0                   noic=noicn_25ud18         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25ud18            cjd=cjn_25ud18
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25ud18        cjswd=cjswn_25ud18
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-08            rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wcit=0+dwcitn_25ud18      pcit=0+dpcitn_25ud18
+ leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18
+ wvth0=0+dwvthn_25ud18     pvth0=0+dpvthn_25ud18     lu0=0+dlu0n_25ud18
+ wu0=0+dwu0n_25ud18        pu0=0+dpu0n_25ud18        wk2=0+dwk2n_25ud18
+ pk2=0+dpk2n_25ud18        saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=8.5e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=1.5e-2
+ pkvth0we=-11e-17          wkvth0we=-3e-10           lkvth0we=+5.83e-9
+ ku0we=-0.002              pku0we=-5e-17             wku0we=-0.9e-9
+ lku0we=-2e-10             k2we=0.0040               pk2we=-2e-17
+ lk2we=0e-10               wk2we=0.4e-9              minr=1e-3
 
 
     4: type=n 
+ lmin=3.8e-007-(dxln_25ud18+dlmisn_25ud18)           lmax=7e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-005-(dxwn_25ud18+dwmisn_25ud18)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.539875+(dvthn_25ud18+vthmisn_25ud18)
+ lvth0=6.250625e-009+dlvthn_25ud18                   kvth0=-3.5e-08
+ pkvth0=0                  wkvth0=6.8e-006           lkvth0=2.5e-6
+ k1=0.3969                 k2=0.076904688+dk2n_25ud18
+ lk2=-3.3597109e-009+dlk2n_25ud18                    k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00019726564+dcitn_25ud18
+ lcit=2.5705697e-010+dlcitn_25ud18                   voff=-0.1
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.025026563+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=4.2973047e-009+dlu0n_25ud18
+ ua=-1.3784375e-009        lua=4.6879688e-017        ub=2.5995313e-018
+ lub=3.3597109e-025        uc=1.0220313e-010         luc=2.1095859e-017
+ vsat=98400                a0=1.3582813              la0=-1.0157266e-007
+ kvsat=0                   ags=0.50265626            lags=-7.0319539e-008
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.058000002         lketa=1.5626563e-015
+ dwg=0                     dwb=0                     pclm=0.61125
+ lpclm=-6.250625e-008      pdiblc1=0                 pdiblc2=0.0011771874
+ lpdiblc2=-2.3439841e-010  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.3743906            lkt1=1.3282563e-008
+ kt1l=0                    kt2=-0.06663408           lkt2=-6.774107e-010
+ ute=-1.7439063            lute=1.3282578e-007       ua1=8.3896234e-010
+ lua1=6.9327245e-017       ub1=-7.9796406e-019       lub1=-3.7745962e-025
+ uc1=1.6329304e-010        luc1=-5.0438632e-017      prt=0
+ at=-14293.703             lat=0.015626565           fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wcit=0+dwcitn_25ud18      pcit=0+dpcitn_25ud18      leta0=0+dleta0n_25ud18
+ weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18    wvth0=0+dwvthn_25ud18
+ pvth0=0+dpvthn_25ud18     wu0=0+dwu0n_25ud18        pu0=0+dpu0n_25ud18
+ wk2=0+dwk2n_25ud18        pk2=0+dpk2n_25ud18        saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=8.5e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=1.5e-2            pkvth0we=-11e-17          wkvth0we=-3e-10
+ lkvth0we=+5.83e-9         ku0we=-0.002              pku0we=-5e-17
+ wku0we=-0.9e-9            lku0we=-2e-10             k2we=0.0040
+ pk2we=-2e-17              lk2we=0e-10               wk2we=0.4e-9
+ minr=1e-3
 
 
     5: type=n 
+ lmin=2.8e-007-(dxln_25ud18+dlmisn_25ud18)           lmax=3.8e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-005-(dxwn_25ud18+dwmisn_25ud18)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.73985+(dvthn_25ud18+vthmisn_25ud18)
+ lvth0=-6.674025e-008+dlvthn_25ud18                  kvth0=-3.5e-08
+ pkvth0=0                  wkvth0=6.8e-006           lkvth0=2.5e-6
+ k1=0.3969                 k2=0.053655005+dk2n_25ud18
+ lk2=5.1264231e-009+dlk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00064044992+dcitn_25ud18
+ lcit=4.1881923e-010+dlcitn_25ud18                   voff=-0.28019997
+ lvoff=6.5772989e-008      nfactor=0.55              eta0=-0.04461658+deta0n_25ud18
+ leta0=1.443234e-007+dleta0n_25ud18                  etab=-0.15804
+ letab=1.9344999e-008      ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.034945+du0n_25ud18
+ lu0=6.77075e-010+dlu0n_25ud18                       ku0=-6.6e-8
+ pku0=2.0e-15              wku0=20.8e-07             lku0=7e-7
+ ua=-1.7005e-009           lua=1.644325e-016         ub=3.3345e-018
+ lub=6.77075e-026          uc=2.925e-010             luc=-4.83625e-017
+ vsat=98400                a0=1.3980001              la0=-1.1607003e-007
+ kvsat=0                   ags=1.7145                lags=-5.1264252e-007
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.16929998          lketa=4.0624493e-008
+ dwg=0                     dwb=0                     pclm=1.129
+ lpclm=-2.51485e-007       pdiblc1=0                 pdiblc2=0.00053499994
+ lpdiblc2=1.9345e-017      pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.28500007           lkt1=-1.9344981e-008
+ kt1l=0                    kt2=-0.15809443           lkt2=3.2705618e-008
+ ute=-1.327                lute=-1.9345e-008         ua1=1.82755e-010
+ lua1=3.0884293e-016       ub1=-1.21306e-018         lub1=-2.259496e-025
+ uc1=1.3915308e-010        luc1=-4.1627544e-017      prt=0
+ at=73568.822              lat=-0.016443257          fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ wcit=0+dwcitn_25ud18      pcit=0+dpcitn_25ud18      weta0=0+dweta0n_25ud18
+ peta0=0+dpeta0n_25ud18    wvth0=0+dwvthn_25ud18     pvth0=0+dpvthn_25ud18
+ wu0=0+dwu0n_25ud18        pu0=0+dpu0n_25ud18        wk2=0+dwk2n_25ud18
+ pk2=0+dpk2n_25ud18        saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=8.5e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=1.5e-2
+ pkvth0we=-11e-17          wkvth0we=-3e-10           lkvth0we=+5.83e-9
+ ku0we=-0.002              pku0we=-5e-17             wku0we=-0.9e-9
+ lku0we=-2e-10             k2we=0.0040               pk2we=-2e-17
+ lk2we=0e-10               wk2we=0.4e-9              minr=1e-3
 
 
     6: type=n 
+ lmin=2.6e-07              lmax=2.8e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-005-(dxwn_25ud18+dwmisn_25ud18)             wmax=0.000901
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.733+(dvthn_25ud18+vthmisn_25ud18)
+ lvth0=-6.4925e-008+dlvthn_25ud18                    kvth0=-3.5e-08
+ pkvth0=0                  wkvth0=6.8e-006           lkvth0=2.5e-6
+ k1=0.3969                 k2=-0.04949999+dk2n_25ud18
+ lk2=3.2462497e-008+dlk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00093999989+dcitn_25ud18
+ lcit=3.2462497e-017+dlcitn_25ud18                   voff=0.016999854
+ lvoff=-1.2984964e-008     nfactor=0.55              eta0=-0.84749924+deta0n_25ud18
+ leta0=3.5708731e-007+dleta0n_25ud18                 etab=-0.085039952
+ letab=-1.2984999e-014     ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.0375+du0n_25ud18
+ ua=-1.08e-009             ub=3.59e-018              ku0=-6.6e-8
+ pku0=2.0e-15              wku0=20.8e-07             lku0=7e-7
+ uc=1.0999988e-010         luc=3.24625e-023          vsat=98400
+ kvsat=0                   a0=-1.4900029             la0=6.4925075e-007
+ ags=-0.22000003           a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.016000066
+ lketa=1.623125e-014       dwg=0                     dwb=0
+ pclm=0.18                 pdiblc1=0                 pdiblc2=0.00053500013
+ lpdiblc2=-3.2462507e-017  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.358                kt1l=0
+ kt2=-0.034677067          lkt2=1.623125e-014        ute=-1.4
+ ua1=1.3482e-009           ub1=-2.0657e-018          uc1=-1.7931921e-011
+ luc1=-1.94775e-023        prt=0                     at=11518.796
+ fnoimod=1                 tnoimod=1                 noia=noian_25ud18
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25ud18
+ rnoib=0                   noic=noicn_25ud18         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25ud18            cjd=cjn_25ud18
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25ud18        cjswd=cjswn_25ud18
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-08            rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   wcit=0+dwcitn_25ud18      pcit=0+dpcitn_25ud18
+ weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18    wvth0=0+dwvthn_25ud18
+ pvth0=0+dpvthn_25ud18     lu0=0+dlu0n_25ud18        wu0=0+dwu0n_25ud18
+ pu0=0+dpu0n_25ud18        wk2=0+dwk2n_25ud18        pk2=0+dpk2n_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     7: type=n 
+ lmin=1e-005-(dxln_25ud18+dlmisn_25ud18)             lmax=0.000901
+ wmin=1e-006-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-005-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.555+(dvthn_25ud18+vthmisn_25ud18)
+ k1=0.3969                 kvth0=-3.5e-08            pkvth0=0
+ wkvth0=6.8e-006           lkvth0=2.5e-6             k2=0.077904889+dk2n_25ud18
+ wk2=8.9573769e-009+dwk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=3.7488789e-005+dcitn_25ud18
+ wcit=1.0558508e-009+dwcitn_25ud18                   voff=-0.10577622
+ wvoff=-2.2393442e-009     nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.031223078+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 wu0=-1.2316393e-009+dwu0n_25ud18
+ ua=-1.3189511e-009        wua=8.9573769e-017        ub=3.0267833e-018
+ wub=-1.6795082e-025       uc=1.2880422e-010         wuc=-3.8068852e-017
+ vsat=98400                a0=1.7267133              wa0=-6.7180327e-008
+ kvsat=0                   ags=0.45671333            wags=-6.7180327e-008
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.059790222         wketa=1.7914754e-008
+ dwg=0                     dwb=0                     pclm=0.50769223
+ wpclm=1.2316397e-007      pdiblc1=0                 pdiblc2=0.0010133223
+ wpdiblc2=-7.8377049e-010  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.33744055           wkt1=-5.5983606e-009
+ kt1l=0                    kt2=-0.066289057          wkt2=2.1355507e-008
+ ute=-1.6734967            wute=2.3513114e-007       ua1=1.0521577e-009
+ wua1=4.7675639e-016       ub1=-1.1817387e-018       wub1=-5.0416596e-025
+ uc1=1.1933187e-010        wuc1=2.6099546e-017       prt=0
+ at=158518.82              fnoimod=1                 tnoimod=1
+ noia=noian_25ud18         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_25ud18         rnoib=0                   noic=noicn_25ud18
+ em=1.12e+008              ef=1                      jss=1.32e-07
+ jsd=1.32e-07              jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25ud18
+ cjd=cjn_25ud18            mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25ud18
+ cjswd=cjswn_25ud18        mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25ud18
+ cjswgd=cjswgn_25ud18      mjswgs=0.56               mjswgd=0.56
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.0025             tcjswg=0.00168
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-08
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   lcit=0+dlcitn_25ud18
+ pcit=0+dpcitn_25ud18      leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18
+ peta0=0+dpeta0n_25ud18    lvth0=0+dlvthn_25ud18     wvth0=0+dwvthn_25ud18
+ pvth0=0+dpvthn_25ud18     lu0=0+dlu0n_25ud18        pu0=0+dpu0n_25ud18
+ lk2=0+dlk2n_25ud18        pk2=0+dpk2n_25ud18        saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=8.5e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=1.5e-2            pkvth0we=-11e-17          wkvth0we=-3e-10
+ lkvth0we=+5.83e-9         ku0we=-0.002              pku0we=-5e-17
+ wku0we=-0.9e-9            lku0we=-2e-10             k2we=0.0040
+ pk2we=-2e-17              lk2we=0e-10               wk2we=0.4e-9
+ minr=1e-3
 
 
     8: type=n 
+ lmin=1.2e-006-(dxln_25ud18+dlmisn_25ud18)           lmax=1e-005-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-006-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-005-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.55634659+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-1.344571e-008+dlvthn_25ud18
+ k1=0.3969                 k2=0.078696834+dk2n_25ud18
+ lk2=-7.9075717e-009+dlk2n_25ud18                    wk2=1.0465117e-008+dwk2n_25ud18
+ pk2=-1.5054785e-014+dpk2n_25ud18                    k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=3.8754405e-005+dcitn_25ud18
+ lcit=-1.2637175e-011+dlcitn_25ud18                  wcit=1.0431858e-009+dwcitn_25ud18
+ pcit=1.2646021e-016+dpcitn_25ud18                   voff=-0.10595702
+ lvoff=1.8053107e-009      wvoff=-4.3005588e-010     pvoff=-1.8065744e-014
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.031175052+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=4.7953379e-010+dlu0n_25ud18
+ wu0=-1.0205557e-009+dwu0n_25ud18                    pu0=-2.1076702e-015+dpu0n_25ud18
+ ua=-1.3189511e-009        wua=8.9573769e-017        ub=3.0224328e-018
+ lub=4.3440102e-026        wub=-1.5136567e-025       pub=-1.6560265e-031
+ uc=1.2886449e-010         luc=-6.0177023e-019       wuc=-3.8671948e-017
+ puc=6.0219147e-024        vsat=98400                a0=1.7938922
+ kvsat=0                   la0=-6.7078109e-007       wa0=-6.5672586e-008
+ pa0=-1.5054787e-014       ags=0.45791868            lags=-1.2035403e-008
+ wags=-7.9242247e-008      pags=1.2043828e-013       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.059940891         lketa=1.5044256e-009      wketa=1.9422494e-008
+ pketa=-1.5054787e-014     dwg=0                     dwb=0
+ pclm=0.50603488           lpclm=1.6548681e-008      wpclm=1.3974911e-007
+ ppclm=-1.6560265e-013     pdiblc1=0                 pdiblc2=0.001019349
+ lpdiblc2=-6.0177023e-011  wpdiblc2=-8.440801e-010   ppdiblc2=6.0219147e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25ud18          cgdo=cgon_25ud18
+ cgbo=0                    cgdl=cgln_25ud18          cgsl=cgln_25ud18
+ clc=1e-007                cle=0.6                   cf=cfn_25ud18
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.33613915           lkt1=-1.2994398e-008      wkt1=-5.14604e-009
+ pkt1=-4.516421e-015       kt1l=0                    kt2=-0.066406624
+ lkt2=1.1739033e-009       wkt2=2.2531997e-008       pkt2=-1.174725e-014
+ ute=-1.7028392            lute=2.9298501e-007       wute=2.5925499e-007
+ pute=-2.4087659e-013      ua1=1.0508213e-009        lua1=1.3344255e-017
+ wua1=4.9013004e-016       pua1=-1.3353596e-022      ub1=-1.2253999e-018
+ lub1=4.3595703e-025       wub1=-4.7150832e-025      pub1=-3.2608655e-031
+ uc1=1.1827816e-010        luc1=1.0521347e-017       wuc1=3.6644075e-017
+ puc1=-1.0528712e-022      prt=0                     at=178717.69
+ lat=-0.20168566           fnoimod=1                 tnoimod=1
+ noia=noian_25ud18         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_25ud18         rnoib=0                   noic=noicn_25ud18
+ em=1.12e+008              ef=1                      jss=1.32e-07
+ jsd=1.32e-07              jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25ud18
+ cjd=cjn_25ud18            mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25ud18
+ cjswd=cjswn_25ud18        mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25ud18
+ cjswgd=cjswgn_25ud18      mjswgs=0.56               mjswgd=0.56
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.0025             tcjswg=0.00168
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-08
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   leta0=0+dleta0n_25ud18
+ weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18    wvth0=0+dwvthn_25ud18
+ pvth0=0+dpvthn_25ud18     saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=8.5e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=1.5e-2
+ pkvth0we=-11e-17          wkvth0we=-3e-10           lkvth0we=+5.83e-9
+ ku0we=-0.002              pku0we=-5e-17             wku0we=-0.9e-9
+ lku0we=-2e-10             k2we=0.0040               pk2we=-2e-17
+ lk2we=0e-10               wk2we=0.4e-9              minr=1e-3
 
 
     9: type=n 
+ lmin=7e-007-(dxln_25ud18+dlmisn_25ud18)             lmax=1.2e-006-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-006-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-005-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.53614767+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=1.0490012e-008+dlvthn_25ud18
+ wvth0=3.3746917e-008+dwvthn_25ud18                  pvth0=-3.9990097e-014+dpvthn_25ud18
+ k1=0.3969                 k2=0.071013996+dk2n_25ud18
+ lk2=1.1965911e-009+dlk2n_25ud18                     wk2=5.1236222e-009+dwk2n_25ud18
+ pk2=-8.7251139e-015+dpk2n_25ud18                    k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-2.78615e-005+dcitn_25ud18
+ lcit=6.6302672e-011+dlcitn_25ud18                   wcit=1.2299755e-009+dwcitn_25ud18
+ pcit=-9.4885594e-017+dpcitn_25ud18                  voff=-0.11357328
+ lvoff=1.0830576e-008      wvoff=-6.4717048e-009     pvoff=-1.090639e-014
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.031717681+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=-1.6348142e-010+dlu0n_25ud18
+ wu0=-4.179736e-009+dwu0n_25ud18                     pu0=1.6359585e-015+dpu0n_25ud18
+ ua=-1.3189511e-009        wua=8.9573769e-017        ub=2.9845555e-018
+ lub=8.8324699e-026        wub=-3.6781229e-025       pub=9.0886584e-032
+ uc=1.1617036e-010         luc=1.4440771e-017        wuc=-2.1318534e-017
+ puc=-1.4541881e-023       vsat=98400                a0=1.2016774
+ kvsat=0                   la0=3.0993464e-008        wa0=3.2045016e-007
+ pa0=-4.7261024e-013       ags=0.51166359            lags=-7.5723121e-008
+ wags=6.841194e-008        pags=-5.4531933e-014      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.058671333         wketa=6.7180327e-009      dwg=0
+ dwb=0                     pclm=0.51693426           lpclm=3.6329096e-009
+ wpclm=3.0679096e-008      ppclm=-3.6354688e-014     pdiblc1=0
+ pdiblc2=0.0011055668      lpdiblc2=-1.6234512e-010  wpdiblc2=-3.3590166e-010
+ ppdiblc2=1.8177317e-023   pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.33628859           lkt1=-1.2817315e-008
+ wkt1=-2.1228941e-008      pkt1=1.4541817e-014       kt1l=0
+ kt2=-0.059202921          lkt2=-7.3624841e-009      wkt2=-2.0105814e-009
+ pkt2=1.7335705e-014       ute=-1.2875843            lute=-1.9909199e-007
+ wute=-2.5433464e-007      pute=3.6772712e-013       ua1=1.3133996e-009
+ lua1=-2.9781105e-016      wua1=5.0970722e-017       pua1=3.8686784e-022
+ ub1=-2.6331143e-019       lub1=-7.0411777e-025      wub1=-9.7751561e-025
+ pub1=2.735321e-031        uc1=1.6313471e-010        luc1=-4.2633671e-017
+ wuc1=3.0310017e-017       puc1=-9.7781264e-023      prt=0
+ at=10051.707              lat=-0.0018164798         wat=-0.015339506
+ pat=1.8177315e-008        fnoimod=1                 tnoimod=1
+ noia=noian_25ud18         rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_25ud18         rnoib=0                   noic=noicn_25ud18
+ em=1.12e+008              ef=1                      jss=1.32e-07
+ jsd=1.32e-07              jsws=6.273e-13            jswd=6.273e-13
+ jswgs=6.273e-13           jswgd=6.273e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.2
+ bvd=9.2                   xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_25ud18
+ cjd=cjn_25ud18            mjs=0.31                  mjd=0.31
+ pbsws=0.49                pbswd=0.49                cjsws=cjswn_25ud18
+ cjswd=cjswn_25ud18        mjsws=0.105               mjswd=0.105
+ pbswgs=1                  pbswgd=1                  cjswgs=cjswgn_25ud18
+ cjswgd=cjswgn_25ud18      mjswgs=0.56               mjswgd=0.56
+ tpb=0.00155               tcj=0.00085               tpbsw=0.001
+ tcjsw=0.0003              tpbswg=0.0025             tcjswg=0.00168
+ xtis=3                    xtid=3                    dmcg=9.25e-008
+ dmci=9.25e-008            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-08
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   ngcon=1                   leta0=0+dleta0n_25ud18
+ weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18    saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=8.5e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=1.5e-2            pkvth0we=-11e-17          wkvth0we=-3e-10
+ lkvth0we=+5.83e-9         ku0we=-0.002              pku0we=-5e-17
+ wku0we=-0.9e-9            lku0we=-2e-10             k2we=0.0040
+ pk2we=-2e-17              lk2we=0e-10               wk2we=0.4e-9
+ minr=1e-3
 
 
     10: type=n 
+ lmin=3.8e-007-(dxln_25ud18+dlmisn_25ud18)           lmax=7e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-006-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-005-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.54080508+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=7.2996882e-009+dlvthn_25ud18
+ wvth0=-9.3072744e-009+dwvthn_25ud18                 pvth0=-1.0497976e-014+dpvthn_25ud18
+ k1=0.3969                 k2=0.079107675+dk2n_25ud18
+ lk2=-4.3475788e-009+dlk2n_25ud18                    wk2=-2.2045294e-008+dwk2n_25ud18
+ pk2=9.8855938e-015+dpk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00030758564+dcitn_25ud18
+ lcit=2.5791371e-010+dlcitn_25ud18                   wcit=1.1039722e-009+dwcitn_25ud18
+ pcit=-8.5733644e-018+dpcitn_25ud18                  voff=-0.096741236
+ lvoff=-6.9937549e-010     wvoff=-3.261045e-008      pvoff=6.9986505e-015
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.024873764+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=4.5246017e-009+dlu0n_25ud18
+ wu0=1.5290522e-009+dwu0n_25ud18                     pu0=-2.2745614e-015+dpu0n_25ud18
+ ua=-1.395046e-009         lua=5.2125004e-017        wua=1.6620133e-016
+ pua=-5.2489879e-023       ub=2.6000557e-018         lub=3.5170704e-025
+ wub=-5.248463e-027        pub=-1.5746964e-031       uc=1.0300908e-010
+ luc=2.345625e-017         wuc=-8.0651729e-018       puc=-2.3620433e-023
+ vsat=98400                a0=1.3964808              la0=-1.0244687e-007
+ kvsat=0                   wa0=-3.8226299e-007       pa0=8.7482694e-015
+ ags=0.47186933            lags=-4.8464054e-008      wags=3.0808479e-007
+ pags=-2.1870784e-013      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.056756987
+ lketa=-1.3113276e-009     wketa=-1.2438859e-008     pketa=1.3122471e-014
+ dwg=0                     dwb=0                     pclm=0.61731648
+ lpclm=-6.5128908e-008     wpclm=-6.0707222e-008     ppclm=2.6244939e-014
+ pdiblc1=0                 pdiblc2=0.0012490411      lpdiblc2=-2.60625e-010
+ wpdiblc2=-7.1903945e-010  ppdiblc2=2.624494e-016    pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.37847454
+ lkt1=1.6080063e-008       wkt1=4.0867995e-008       pkt1=-2.7994585e-014
+ kt1l=0                    kt2=-0.067191635          lkt2=-1.8902152e-009
+ wkt2=5.5794486e-009       pkt2=1.2136535e-014       ute=-1.8068876
+ lute=1.5663077e-007       wute=6.3025468e-007       pute=-2.3821657e-013
+ ua1=7.4572584e-010        lua1=9.1045476e-017       wua1=9.330177e-016
+ pua1=-2.1733434e-022      ub1=-6.7427997e-019       lub1=-4.2260431e-025
+ wub1=-1.2377067e-024      pub1=4.5176298e-031       uc1=1.8276754e-010
+ luc1=-5.6082155e-017      wuc1=-1.9488123e-016      puc1=5.6474738e-023
+ prt=0                     at=-19241.29              lat=0.018249223
+ wat=0.049510499           pat=-2.6244939e-008       fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     11: type=n 
+ lmin=2.8e-007-(dxln_25ud18+dlmisn_25ud18)           lmax=3.8e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-006-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-005-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.75758999+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-7.1826805e-008+dlvthn_25ud18
+ wvth0=-1.7752407e-007+dwvthn_25ud18                 pvth0=5.0901156e-014+dpvthn_25ud18
+ k1=0.3969                 k2=0.055612502+dk2n_25ud18
+ lk2=4.2281593e-009+dlk2n_25ud18                     wk2=-1.958867e-008+dwk2n_25ud18
+ pk2=8.9889258e-015+dpk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00096605776+dcitn_25ud18
+ lcit=4.9825603e-010+dlcitn_25ud18                   wcit=3.2583577e-009+dwcitn_25ud18
+ pcit=-7.9492407e-016+dpcitn_25ud18                  voff=-0.28241537
+ lvoff=6.7071684e-008      wvoff=2.2169505e-008      pvoff=-1.2996033e-014
+ nfactor=0.55              eta0=-0.029791305+deta0n_25ud18
+ leta0=1.3891218e-007+dleta0n_25ud18                 weta0=-1.4835653e-007+dweta0n_25ud18
+ peta0=5.4150132e-014+dpeta0n_25ud18                 etab=-0.15951067
+ letab=1.9881793e-008      wetab=1.471697e-008       petab=-5.3716941e-015
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.035918993+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=4.930933e-010+dlu0n_25ud18
+ wu0=-9.7467457e-009+dwu0n_25ud18                    pu0=1.8411048e-015+dpu0n_25ud18
+ ua=-1.7531437e-009        lua=1.8283067e-016        wua=5.2680573e-016
+ pua=-1.8411048e-022       ub=3.4759835e-018         lub=3.1993406e-026
+ wub=-1.4158254e-024       pub=3.5739094e-031        uc=3.0985397e-010
+ luc=-5.2042135e-017       wuc=-1.7366116e-016       puc=3.6822103e-023
+ vsat=98400                a0=1.4604901              la0=-1.2581024e-007
+ kvsat=0                   wa0=-6.2533714e-007       pa0=9.7470332e-014
+ ags=1.788067              lags=-5.288762e-007       wags=-7.3618457e-007
+ pags=1.6245048e-013       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.17618618
+ lketa=4.2280329e-008      wketa=6.8910233e-008      pketa=-1.6569948e-014
+ dwg=0                     dwb=0                     pclm=1.121951
+ lpclm=-2.4932051e-007     wpclm=7.0539343e-008      ppclm=-2.1660057e-014
+ pdiblc1=0                 pdiblc2=0.00053499993     lpdiblc2=2.0427245e-017
+ wpdiblc2=4.0868029e-017   ppdiblc2=-1.0830028e-023  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.27489651
+ lkt1=-2.1725919e-008      wkt1=-1.0110635e-007      pkt1=2.3826052e-014
+ kt1l=0                    kt2=-0.17637098           lkt2=3.7960245e-008
+ wkt2=1.8289336e-007       pkt2=-5.2583044e-014      ute=-1.2773213
+ lute=-3.6660924e-008      wute=-4.9713442e-007      pute=1.7328046e-013
+ ua1=4.3820418e-011        lua1=3.4724096e-016       wua1=1.3903184e-015
+ pua1=-3.8424909e-022      ub1=-1.2604713e-018       lub1=-2.0864449e-025
+ wub1=4.7444467e-025       pub1=-1.7317226e-031      uc1=1.5592657e-010
+ luc1=-4.6285203e-017      wuc1=-1.6785235e-016      puc1=4.6609196e-023
+ prt=0                     at=86777.305              lat=-0.020447564
+ wat=-0.13217729           pat=4.0071105e-008        fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     12: type=n 
+ lmin=2.6e-07              lmax=2.8e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=1e-006-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-005-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.75073439+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-7.001007e-008+dlvthn_25ud18
+ wvth0=-1.7746801e-007+dwvthn_25ud18                 pvth0=5.0886298e-014+dpvthn_25ud18
+ k1=0.3969                 k2=-0.050932169+dk2n_25ud18
+ lk2=3.2462497e-008+dlk2n_25ud18                     wk2=1.4331819e-008+dwk2n_25ud18
+ pk2=-3.6347364e-021+dpk2n_25ud18                    k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00091415354+dcitn_25ud18
+ lcit=3.6094685e-017+dlcitn_25ud18                   wcit=2.5864438e-010+dwcitn_25ud18
+ pcit=-3.6347344e-023+dpcitn_25ud18                  voff=0.034762207
+ lvoff=-1.6980375e-008     wvoff=-1.7774786e-007     pvoff=3.998207e-014
+ nfactor=0.55              eta0=-0.96274464+deta0n_25ud18
+ leta0=3.8614481e-007+dleta0n_25ud18                 weta0=1.1532608e-006+dweta0n_25ud18
+ peta0=-2.9077845e-013+dpeta0n_25ud18                etab=-0.084484983
+ letab=-1.2984999e-014     wetab=-5.5535737e-009     petab=4.5835914e-028
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.037779722+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 wu0=-2.7991803e-009+dwu0n_25ud18
+ ua=-1.0632167e-009        wua=-1.6795082e-016       ub=3.7337771e-018
+ lub=-3.6321894e-026       wub=-1.4387773e-024       pub=3.634732e-031
+ uc=1.1346843e-010         luc=3.3915377e-023        wuc=-3.4709775e-017
+ puc=-1.4538941e-029       vsat=81952.333            lvsat=0.0043586317
+ kvsat=0                   wvsat=0.1645918           pvsat=-4.3616827e-008
+ a0=-2.8349068             la0=1.0124699e-006        wa0=1.3458454e-005
+ pa0=-3.6347343e-012       ags=-0.20769228           lags=7.2643858e-015
+ wags=-1.2316361e-007      pags=-7.2694716e-020      a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.016637831         lketa=1.5868031e-014      wketa=6.382114e-009
+ pketa=3.6347353e-021      dwg=0                     dwb=0
+ pclm=0.18111889           wpclm=-1.1196721e-008     pdiblc1=0
+ pdiblc2=0.00053500013     lpdiblc2=-3.2462505e-017  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.35688111
+ wkt1=-1.1196721e-008      kt1l=0                    kt2=-0.033124827
+ lkt2=1.4778373e-014       wkt2=-1.5533273e-008      pkt2=1.4538942e-020
+ ute=-1.4156644            wute=1.567541e-007        ua1=1.3541635e-009
+ lua1=3.6321924e-023       wua1=-5.9676816e-017      pua1=-3.6347356e-028
+ ub1=-2.047809e-018        wub1=-1.7903557e-025      uc1=-1.8734497e-011
+ luc1=-2.0203939e-023      wuc1=8.0313851e-018       puc1=7.2694712e-030
+ prt=0                     at=9616.6919              lat=-1.8160965e-009
+ wat=0.019034356           pat=1.8173678e-014        fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lu0=0+dlu0n_25ud18        pu0=0+dpu0n_25ud18        saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-6                 llodvth=1
+ wlodvth=1                 stk2=1.5e-9               lodk2=0.5
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=8.5e-9             tku0=0                    wec=-3500
+ web=-250                  scref=1e-6                wpemod=1
+ kvth0we=1.5e-2            pkvth0we=-11e-17          wkvth0we=-3e-10
+ lkvth0we=+5.83e-9         ku0we=-0.002              pku0we=-5e-17
+ wku0we=-0.9e-9            lku0we=-2e-10             k2we=0.0040
+ pk2we=-2e-17              lk2we=0e-10               wk2we=0.4e-9
+ minr=1e-3
 
 
     13: type=n 
+ lmin=1e-005-(dxln_25ud18+dlmisn_25ud18)             lmax=0.000901
+ wmin=6e-007-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-006-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.5474125+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             wvth0=7.6406125e-009+dwvthn_25ud18
+ k1=0.3969                 k2=0.083765+dk2n_25ud18   wk2=3.056245e-009+dwk2n_25ud18
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            xj=8.1e-008               ngate=4.282e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0009039+dcitn_25ud18                          wcit=1.833747e-010+dwcitn_25ud18
+ voff=-0.0973775           wvoff=-1.0696858e-008     nfactor=0.55
+ eta0=0.35079+deta0n_25ud18                          etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.03+du0n_25ud18       ua=-1.23e-009
+ ub=2.814475e-018          ku0=-6.6e-8               pku0=2.0e-15
+ wku0=20.8e-07             lku0=7e-7                 wub=4.5843675e-026
+ uc=1.198325e-010          wuc=-2.9034328e-017       vsat=98400
+ a0=1.66                   ags=0.405175              kvsat=0
+ wags=-1.5281225e-008      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.042
+ dwg=0                     dwb=0                     pclm=0.84245004
+ wpclm=-2.1393715e-007     pdiblc1=0                 pdiblc2=0.00038675002
+ wpdiblc2=-1.5281225e-010  pdiblcb=0                 drout=0.56
+ pvag=0                    delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rdsw=0                    rsw=50                    rdw=50
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7e-007             alpha1=3.5                beta0=17.8
+ agidl=0                   bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 aigc=0.43                 aigsd=0.43
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_25ud18
+ cgdo=cgon_25ud18          cgbo=0                    cgdl=cgln_25ud18
+ cgsl=cgln_25ud18          clc=1e-007                cle=0.6
+ cf=cfn_25ud18             ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.718
+ voffcv=-0.1132            kt1=-0.33996498           wkt1=-3.0562603e-009
+ kt1l=0                    kt2=-0.04639767           wkt2=1.3248807e-009
+ ute=-1.273075             wute=-1.6809348e-007      ua1=1.4987403e-009
+ wua1=2.7047768e-017       ub1=-1.1011974e-018       wub1=-5.8527107e-025
+ uc1=3.0580147e-010        wuc1=-1.6167534e-016      prt=0
+ at=219218.84              wat=-0.061124915          fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lcit=0+dlcitn_25ud18      pcit=0+dpcitn_25ud18      leta0=0+dleta0n_25ud18
+ weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18    lvth0=0+dlvthn_25ud18
+ pvth0=0+dpvthn_25ud18     lu0=0+dlu0n_25ud18        wu0=0+dwu0n_25ud18
+ pu0=0+dpu0n_25ud18        lk2=0+dlk2n_25ud18        pk2=0+dpk2n_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     14: type=n 
+ lmin=1.2e-006-(dxln_25ud18+dlmisn_25ud18)           lmax=1e-005-(dxln_25ud18+dlmisn_25ud18)
+ wmin=6e-007-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-006-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.54651129+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=8.9985416e-009+dlvthn_25ud18
+ wvth0=9.904144e-009+dwvthn_25ud18                   pvth0=-2.2601362e-014+dpvthn_25ud18
+ k1=0.3969                 k2=0.086401591+dk2n_25ud18
+ lk2=-2.6326361e-008+dlk2n_25ud18                    wk2=2.7064267e-009+dwk2n_25ud18
+ pk2=3.4929356e-015+dpk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00088237138+dcitn_25ud18
+ lcit=2.1496329e-010+dlcitn_25ud18                   wcit=1.9366348e-010+dwcitn_25ud18
+ pcit=-1.0273346e-016+dpcitn_25ud18                  voff=-0.09412683
+ lvoff=-3.2457945e-008     wvoff=-1.2343062e-008     pvoff=1.6437354e-014
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.030406805+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=-4.0619491e-009+dlu0n_25ud18
+ wu0=-2.469307e-010+dwu0n_25ud18                     pu0=2.4656031e-015+dpu0n_25ud18
+ ua=-1.23e-009             ub=2.8490723e-018         lub=-3.4545391e-025
+ wub=2.3208361e-026        pub=2.2601362e-031        uc=1.1964125e-010
+ luc=1.909627e-018         wuc=-2.9384146e-017       puc=3.4929377e-024
+ vsat=98400                a0=1.6898506              la0=-2.9805805e-007
+ kvsat=0                   wa0=3.9097335e-008        pa0=-3.9038689e-013
+ ags=0.38111984            lags=2.4019075e-007       wags=-1.905816e-009
+ pags=-1.3355346e-013      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.040653409
+ lketa=-1.344571e-008      dwg=0                     dwb=0
+ pclm=0.90017503           lpclm=-5.7638398e-007     wpclm=-2.5715002e-007
+ ppclm=4.3148054e-013      pdiblc1=0                 pdiblc2=0.00031245187
+ lpdiblc2=7.4186704e-010   wpdiblc2=-1.3223469e-010  ppdiblc2=-2.054669e-016
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25ud18          cgdo=cgon_25ud18
+ cgbo=0                    cgdl=cgln_25ud18          cgsl=cgln_25ud18
+ clc=1e-007                cle=0.6                   cf=cfn_25ud18
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.33695155           lkt1=-3.0089012e-008      wkt1=-4.3279534e-009
+ pkt1=1.2697856e-014       kt1l=0                    kt2=-0.04375242
+ lkt2=-2.6412824e-008      wkt2=-2.8078622e-010      pkt2=1.6032584e-014
+ ute=-1.2478096            lute=-2.5227514e-007      wute=-1.9895981e-007
+ pute=3.0820039e-013       ua1=1.5070676e-009        lua1=-8.3148608e-017
+ wua1=3.0689996e-017       pua1=-3.6367645e-023      ub1=-1.0205339e-018
+ lub1=-8.0542439e-025      wub1=-6.7780833e-025      pub1=9.2398455e-031
+ uc1=3.2584574e-010        luc1=-2.0014212e-016      wuc1=-1.7237649e-016
+ puc1=1.0685099e-022       prt=0                     at=253721.87
+ lat=-0.34451275           wat=-0.07552921           pat=1.4382688e-007
+ fnoimod=1                 tnoimod=1                 noia=noian_25ud18
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_25ud18
+ rnoib=0                   noic=noicn_25ud18         em=1.12e+008
+ ef=1                      jss=1.32e-07              jsd=1.32e-07
+ jsws=6.273e-13            jswd=6.273e-13            jswgs=6.273e-13
+ jswgd=6.273e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.2                   bvd=9.2
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_25ud18            cjd=cjn_25ud18
+ mjs=0.31                  mjd=0.31                  pbsws=0.49
+ pbswd=0.49                cjsws=cjswn_25ud18        cjswd=cjswn_25ud18
+ mjsws=0.105               mjswd=0.105               pbswgs=1
+ pbswgd=1                  cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18
+ mjswgs=0.56               mjswgd=0.56               tpb=0.00155
+ tcj=0.00085               tpbsw=0.001               tcjsw=0.0003
+ tpbswg=0.0025             tcjswg=0.00168            xtis=3
+ xtid=3                    dmcg=9.25e-008            dmci=9.25e-008
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-08            rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ ngcon=1                   leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18
+ peta0=0+dpeta0n_25ud18    saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=8.5e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=1.5e-2
+ pkvth0we=-11e-17          wkvth0we=-3e-10           lkvth0we=+5.83e-9
+ ku0we=-0.002              pku0we=-5e-17             wku0we=-0.9e-9
+ lku0we=-2e-10             k2we=0.0040               pk2we=-2e-17
+ lk2we=0e-10               wk2we=0.4e-9              minr=1e-3
 
 
     15: type=n 
+ lmin=7e-007-(dxln_25ud18+dlmisn_25ud18)             lmax=1.2e-006-(dxln_25ud18+dlmisn_25ud18)
+ wmin=6e-007-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-006-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.5974758+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-5.1394393e-008+dlvthn_25ud18
+ wvth0=-2.8010506e-008+dwvthn_25ud18                 pvth0=2.2327499e-014+dpvthn_25ud18
+ k1=0.3969                 k2=0.066745101+dk2n_25ud18
+ lk2=-3.0334204e-009+dlk2n_25ud18                    wk2=9.4223997e-009+dwk2n_25ud18
+ pk2=-4.4654924e-015+dpk2n_25ud18                    k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0010835973+dcitn_25ud18
+ lcit=-2.3489379e-011+dlcitn_25ud18                  wcit=1.1073651e-010+dwcitn_25ud18
+ pcit=-4.4649987e-018+dpcitn_25ud18                  voff=-0.13607033
+ lvoff=1.7245098e-008      wvoff=1.6182817e-008      pvoff=-1.7365813e-014
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.024498615+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=2.9392562e-009+dlu0n_25ud18
+ wu0=3.0898637e-009+dwu0n_25ud18                     pu0=-1.4884983e-015+dpu0n_25ud18
+ ua=-1.23e-009             ub=2.157373e-018          lub=4.7420975e-025
+ wub=4.6516049e-025        pub=-2.9769966e-031       uc=1.3164766e-010
+ luc=-1.2317971e-017       wuc=-3.6904175e-017       puc=1.2404172e-023
+ vsat=98400                a0=1.8705939              la0=-5.1223886e-007
+ kvsat=0                   wa0=-3.5314874e-007       pa0=7.4424716e-014
+ ags=0.87012528            lags=-3.3928069e-007      wags=-2.9255898e-007
+ pags=2.1087054e-013       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.066552817
+ lketa=1.7245088e-008      wketa=1.4654686e-008      pketa=-1.7365803e-014
+ dwg=0                     dwb=0                     pclm=0.1085391
+ lpclm=3.617046e-007       wpclm=4.4193303e-007      ppclm=-3.9693288e-013
+ pdiblc1=0                 pdiblc2=0.001491295       lpdiblc2=-6.5506207e-010
+ wpdiblc2=-7.2432997e-010  ppdiblc2=4.96166e-016     pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.38034488
+ lkt1=2.1332076e-008       wkt1=2.3135738e-008       pkt1=-1.9846619e-014
+ kt1l=0                    kt2=-0.070749222          lkt2=5.5783868e-009
+ wkt2=9.6165435e-009       pkt2=4.3042483e-015       ute=-1.8966891
+ lute=5.1664713e-007       wute=3.5903391e-007       pute=-3.5302218e-013
+ ua1=1.2902124e-009        lua1=1.7382482e-016       wua1=7.4320238e-017
+ pua1=-8.8069482e-023      ub1=-1.6818137e-018       lub1=-2.1807891e-026
+ wub1=4.5091614e-025       pub1=-4.1355394e-031      uc1=4.2398983e-010
+ luc1=-3.1644286e-016      wuc1=-2.3237108e-016      puc1=1.7794459e-022
+ prt=0                     at=-113075.45             lat=0.090142061
+ wat=0.10864954            pat=-7.4424936e-008       fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     16: type=n 
+ lmin=3.8e-007-(dxln_25ud18+dlmisn_25ud18)           lmax=7e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=6e-007-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-006-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.51835548+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=2.8030265e-009+dlvthn_25ud18
+ wvth0=1.3299474e-008+dwvthn_25ud18                  pvth0=-5.9698374e-015+dpvthn_25ud18
+ k1=0.3969                 k2=0.053813107+dk2n_25ud18
+ lk2=5.8249953e-009+dlk2n_25ud18                     wk2=3.4263354e-009+dwk2n_25ud18
+ pk2=-3.5818833e-016+dpk2n_25ud18                    k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00017598803+dcitn_25ud18
+ lcit=5.9822294e-010+dlcitn_25ud18                   wcit=6.1701354e-010+dwcitn_25ud18
+ pcit=-3.5126477e-016+dpcitn_25ud18                  voff=-0.12867449
+ lvoff=1.2178952e-008      wvoff=-4.5366137e-010     pvoff=-5.9698254e-015
+ nfactor=0.55              eta0=0.35079+deta0n_25ud18
+ etab=-0.10504             ud=0                      lud=0
+ wud=0                     pud=0                     u0=0.022366069+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=4.4000505e-009+dlu0n_25ud18
+ wu0=4.0543018e-009+dwu0n_25ud18                     pu0=-2.1491384e-015+dpu0n_25ud18
+ ua=-1.23e-009             ub=2.2702408e-018         lub=3.9689527e-025
+ wub=3.2687513e-025        pub=-2.0297418e-031       uc=1.136652e-010
+ luc=1.8052586e-023        wuc=-1.8795884e-017       puc=-7.1637904e-030
+ vsat=98400                a0=1.0519674              la0=4.8520283e-008
+ kvsat=0                   wa0=-3.5337983e-008       pa0=-1.4327566e-013
+ ags=0.38183986            lags=-4.8051816e-009      wags=3.9874447e-007
+ pags=-2.6267232e-013      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.032523418
+ lketa=-6.0650501e-009     wketa=-3.6842062e-008     pketa=1.7909469e-014
+ dwg=0                     dwb=0                     pclm=0.79746016
+ lpclm=-1.1020633e-007     wpclm=-2.4211191e-007     ppclm=7.1637905e-014
+ pdiblc1=0                 pdiblc2=0.00053500001     lpdiblc2=-4.316837e-018
+ wpdiblc2=-9.8134118e-017  ppdiblc2=3.5818952e-023   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.30817277
+ lkt1=-2.8105818e-008      wkt1=-2.9925892e-008      pkt1=1.6500598e-014
+ kt1l=0                    kt2=-0.10445471           lkt2=2.8666644e-008
+ wkt2=4.3103363e-008       pkt2=-1.8634223e-014      ute=-0.67163199
+ lute=-3.2251701e-007      wute=-5.1294775e-007      pute=2.4428526e-013
+ ua1=1.8796598e-009        lua1=-2.2994663e-016      wua1=-2.0885376e-016
+ pua1=1.059047e-022        ub1=-1.780366e-018        lub1=4.5700469e-026
+ wub1=-1.2387803e-025      pub1=-1.981994e-032       uc1=-1.4350144e-010
+ luc1=7.2288658e-017       wuc1=1.3367163e-016       puc1=-7.2794671e-023
+ prt=0                     at=47234.038              lat=-0.019669936
+ wat=-0.017430156          pat=1.1939654e-008        fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ leta0=0+dleta0n_25ud18    weta0=0+dweta0n_25ud18    peta0=0+dpeta0n_25ud18
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     17: type=n 
+ lmin=2.8e-007-(dxln_25ud18+dlmisn_25ud18)           lmax=3.8e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=6e-007-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-006-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.70497616+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-6.5313522e-008+dlvthn_25ud18
+ wvth0=-1.2454194e-007+dwvthn_25ud18                 pvth0=4.434228e-014+dpvthn_25ud18
+ k1=0.3969                 k2=0.053034595+dk2n_25ud18
+ lk2=6.1091525e-009+dlk2n_25ud18                     wk2=-1.6992717e-008+dwk2n_25ud18
+ pk2=7.0947657e-015+dpk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0031675552+dcitn_25ud18
+ lcit=-4.9369906e-010+dlcitn_25ud18                  wcit=-9.0419049e-010+dwcitn_25ud18
+ pcit=2.039747e-016+dpcitn_25ud18                    voff=-0.33257979
+ lvoff=8.6604385e-008      wvoff=7.2685074e-008      pvoff=-3.2665464e-014
+ nfactor=0.55              eta0=-0.37818538+deta0n_25ud18
+ leta0=2.6607602e-007+dleta0n_25ud18                 weta0=2.0247631e-007+dweta0n_25ud18
+ peta0=-7.3903854e-014+dpeta0n_25ud18                etab=-0.14489599
+ letab=1.4547435e-008      wetab=-1.2148574e-014     petab=4.4342297e-021
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.035701614+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 lu0=-4.6742356e-010+dlu0n_25ud18
+ wu0=-9.5278453e-009+dwu0n_25ud18                    pu0=2.8083453e-015+dpu0n_25ud18
+ ua=-1.23e-009             ub=2.780191e-018          lub=2.1076348e-025
+ wub=-7.1516229e-025       pub=1.7736947e-031        uc=2.2040718e-010
+ luc=-3.8960807e-017       wuc=-8.3588249e-017       puc=2.3649206e-023
+ vsat=86335.875            lvsat=0.0044034056        wvsat=0.012148574
+ kvsat=0                   pvsat=-4.4342295e-009     a0=1.1719075
+ la0=4.742158e-009         wa0=-3.3473447e-007       pa0=-3.3995937e-014
+ ags=2.3005902             lags=-7.0514904e-007      wags=-1.2522954e-006
+ pags=3.3995722e-013       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.1589023
+ lketa=4.0063241e-008      wketa=5.1505362e-008      pketa=-1.4337341e-014
+ dwg=0                     dwb=0                     pclm=1.4788076
+ lpclm=-3.5889816e-007     wpclm=-2.8881527e-007     ppclm=8.8684634e-014
+ pdiblc1=0                 pdiblc2=0.00053499993     lpdiblc2=2.4350518e-017
+ wpdiblc2=4.0495241e-017   ppdiblc2=-1.4780765e-023  pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.39047504
+ lkt1=1.9345097e-009       wkt1=1.5281225e-008       pkt1=4.8510309e-028
+ kt1l=0                    kt2=0.018139684           lkt2=-1.6080309e-008
+ wkt2=-1.2978873e-008      pkt2=1.8357932e-015       ute=-2.779979
+ lute=4.4702963e-007       wute=1.0160418e-006       pute=-3.1379593e-013
+ ua1=1.2013853e-009        lua1=1.7623542e-017       wua1=2.246505e-016
+ pua1=-5.2324351e-023      ub1=7.0848031e-020        lub1=-6.2999266e-025
+ wub1=-8.6619388e-025      pub1=2.5112534e-031       uc1=9.7815657e-011
+ luc1=-1.5792081e-017      wuc1=-1.0933466e-016      puc1=1.5902622e-023
+ prt=0                     at=-140083.67             lat=0.048701027
+ wat=0.096271707           pat=-2.9561526e-008       fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-6
+ llodvth=1                 wlodvth=1                 stk2=1.5e-9
+ lodk2=0.5                 llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=8.5e-9             tku0=0
+ wec=-3500                 web=-250                  scref=1e-6
+ wpemod=1                  kvth0we=1.5e-2            pkvth0we=-11e-17
+ wkvth0we=-3e-10           lkvth0we=+5.83e-9         ku0we=-0.002
+ pku0we=-5e-17             wku0we=-0.9e-9            lku0we=-2e-10
+ k2we=0.0040               pk2we=-2e-17              lk2we=0e-10
+ wk2we=0.4e-9              minr=1e-3
 
 
     18: type=n 
+ lmin=2.6e-07              lmax=2.8e-007-(dxln_25ud18+dlmisn_25ud18)
+ wmin=6e-007-(dxwn_25ud18+dwmisn_25ud18)             wmax=1e-006-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.68072466+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             lvth0=-5.8886877e-008+dlvthn_25ud18
+ wvth0=-1.0696822e-007+dwvthn_25ud18                 pvth0=3.9685242e-014+dpvthn_25ud18
+ k1=0.3969                 k2=-0.046411938+dk2n_25ud18
+ lk2=3.2462484e-008+dlk2n_25ud18                     wk2=9.7799466e-009+dwk2n_25ud18
+ pk2=9.9213303e-021+dpk2n_25ud18                     k3=-2.272
+ k3b=2.548                 w0=0                      dvt0=28.475
+ dvt1=0.4104               dvt2=0.01095              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.326
+ minv=-0.3                 voffl=-3e-009             dvtp0=8.019e-007
+ dvtp1=3.5                 lpe0=1.3709e-007          lpeb=1.51e-010
+ xj=8.1e-008               ngate=4.282e+020          ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0013045399+dcitn_25ud18
+ wcit=-1.3447463e-010+dwcitn_25ud18                  voff=-0.18446817
+ lvoff=4.7354806e-008      wvoff=4.3017125e-008      pvoff=-2.4803457e-014
+ nfactor=0.55              eta0=-0.11341436+deta0n_25ud18
+ leta0=1.959117e-007+dleta0n_25ud18                  weta0=2.9798517e-007+dweta0n_25ud18
+ peta0=-9.9213701e-014+dpeta0n_25ud18                etab=-0.089999826
+ letab=-4.7468289e-014     wetab=-1.2645213e-013     petab=3.4724668e-020
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.033937752+du0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 wu0=1.0696842e-009+dwu0n_25ud18
+ ua=-1.23e-009             ub=-1.3673452e-018        lub=1.3098606e-024
+ wub=3.6980529e-024        pub=-9.9213254e-031       uc=7.3385104e-011
+ luc=4.4108417e-023        wuc=5.6541316e-018        puc=-2.4803348e-029
+ vsat=259247.28            lvsat=-0.041418117        wvsat=-0.013944211
+ kvsat=0                   pvsat=2.4803586e-009      a0=3.5540213
+ la0=-6.2651801e-007       wa0=7.0248034e-006        pa0=-1.9842735e-012
+ ags=18.229029             lags=-4.9261852e-006      wags=-1.8688942e-005
+ pags=4.9606685e-012       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.0077204601
+ lketa=5.3960791e-014      wketa=-2.5976787e-009     pketa=-3.4724673e-020
+ dwg=0                     dwb=0                     pclm=0.12447495
+ wpclm=4.5843721e-008      pdiblc1=0                 pdiblc2=0.00053500033
+ lpdiblc2=-8.172432e-017   wpdiblc2=-2.0247629e-016  ppdiblc2=4.9606652e-023
+ pdiblcb=0                 drout=0.56                pvag=0
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rdsw=0
+ rsw=50                    rdw=50                    prwg=0
+ prwb=0                    wr=1                      alpha0=7e-007
+ alpha1=3.5                beta0=17.8                agidl=0
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ aigc=0.43                 aigsd=0.43                xrcrg1=12
+ xrcrg2=1                  cgso=cgon_25ud18          cgdo=cgon_25ud18
+ cgbo=0                    cgdl=cgln_25ud18          cgsl=cgln_25ud18
+ clc=1e-007                cle=0.6                   cf=cfn_25ud18
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.718                voffcv=-0.1132
+ kt1=-0.383175             wkt1=1.5281225e-008       kt1l=0
+ kt2=-0.042540966          lkt2=6.3699546e-014       wkt2=-6.0512203e-009
+ pkt2=-3.472467e-020       ute=-1.0930747            wute=-1.6809378e-007
+ ua1=1.2678923e-009        lua1=-8.1724354e-022      wua1=2.719825e-017
+ pua1=4.9606673e-028       ub1=-2.3064846e-018       lub1=4.9261854e-031
+ wub1=8.1450801e-026       pub1=-4.9606683e-037      uc1=3.8223188e-011
+ luc1=-7.7025398e-023      wuc1=-4.9325004e-017      puc1=6.4488679e-029
+ prt=0                     at=43693.601              lat=5.0714539e-008
+ wat=-0.015281091          pat=-3.4724674e-014       fnoimod=1
+ tnoimod=1                 noia=noian_25ud18         rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_25ud18         rnoib=0
+ noic=noicn_25ud18         em=1.12e+008              ef=1
+ jss=1.32e-07              jsd=1.32e-07              jsws=6.273e-13
+ jswd=6.273e-13            jswgs=6.273e-13           jswgd=6.273e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.2                   bvd=9.2                   xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_25ud18            cjd=cjn_25ud18            mjs=0.31
+ mjd=0.31                  pbsws=0.49                pbswd=0.49
+ cjsws=cjswn_25ud18        cjswd=cjswn_25ud18        mjsws=0.105
+ mjswd=0.105               pbswgs=1                  pbswgd=1
+ cjswgs=cjswgn_25ud18      cjswgd=cjswgn_25ud18      mjswgs=0.56
+ mjswgd=0.56               tpb=0.00155               tcj=0.00085
+ tpbsw=0.001               tcjsw=0.0003              tpbswg=0.0025
+ tcjswg=0.00168            xtis=3                    xtid=3
+ dmcg=9.25e-008            dmci=9.25e-008            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-08            rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   ngcon=1
+ lcit=0+dlcitn_25ud18      pcit=0+dpcitn_25ud18      lu0=0+dlu0n_25ud18
+ pu0=0+dpu0n_25ud18        saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-6                 llodvth=1                 wlodvth=1
+ stk2=1.5e-9               lodk2=0.5                 llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=8.5e-9
+ tku0=0                    wec=-3500                 web=-250
+ scref=1e-6                wpemod=1                  kvth0we=1.5e-2
+ pkvth0we=-11e-17          wkvth0we=-3e-10           lkvth0we=+5.83e-9
+ ku0we=-0.002              pku0we=-5e-17             wku0we=-0.9e-9
+ lku0we=-2e-10             k2we=0.0040               pk2we=-2e-17
+ lk2we=0e-10               wk2we=0.4e-9              minr=1e-3
 
 
     19: type=n 
+ lmin=1e-005-(dxln_25ud18+dlmisn_25ud18)             lmax=0.000901
+ wmin=4e-07                wmax=6e-007-(dxwn_25ud18+dwmisn_25ud18)
+ version=4.5               rgeomod=1                 binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_25ud18
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxn_25ud18+toxmisn_25ud18)
+ toxm=5.6e-009             dtox=2.835e-010           epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.5e-08+(dxln_25ud18+dlmisn_25ud18)             xw=7e-09+(dxwn_25ud18+dwmisn_25ud18)
+ dlc=0+dlcn_25ud18         dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.56610502+(dvthn_25ud18+vthmisn_25ud18)
+ kvth0=-3.5e-08            pkvth0=0                  wkvth0=6.8e-006
+ lkvth0=2.5e-6             wvth0=-3.7057474e-009+dwvthn_25ud18
+ k1=0.3969                 k2=0.082695+dk2n_25ud18   wk2=3.705735e-009+dwk2n_25ud18
+ k3=-2.272                 k3b=2.548                 w0=0
+ dvt0=28.475               dvt1=0.4104               dvt2=0.01095
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.326                minv=-0.3                 voffl=-3e-009
+ dvtp0=8.019e-007          dvtp1=3.5                 lpe0=1.3709e-007
+ lpeb=1.51e-010            xj=8.1e-008               ngate=4.282e+020
+ ndep=5.11e+017            nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00109611+dcitn_25ud18                         wcit=6.670323e-011+dwcitn_25ud18
+ voff=-0.112965            wvoff=-1.235245e-009      nfactor=0.55
+ eta0=0.35079+deta0n_25ud18                          etab=-0.10504
+ ud=0                      lud=0                     wud=0
+ pud=0                     u0=0.031628+du0n_25ud18   wu0=-9.88196e-010+dwu0n_25ud18
+ ku0=-6.6e-8               pku0=2.0e-15              wku0=20.8e-07
+ lku0=7e-7                 ua=-1.23e-009             ub=2.89e-018
+ uc=8.014e-011             wuc=-4.94098e-018         vsat=98400
+ a0=1.66                   kvsat=0                   ags=0.35965
+ wags=1.235245e-008        a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.03386
+ wketa=-4.94098e-009       dwg=0                     dwb=0
+ pclm=0.46965012           wpclm=1.2352401e-008      pdiblc1=0
+ pdiblc2=0.00013500004     wpdiblc2=-1.235245e-017   pdiblcb=0
+ drout=0.56                pvag=0                    delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rdsw=0                    rsw=50
+ rdw=50                    prwg=0                    prwb=0
+ wr=1                      alpha0=7e-007             alpha1=3.5
+ beta0=17.8                agidl=0                   bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 aigc=0.43
+ aigsd=0.43                xrcrg1=12                 xrcrg2=1
+ cgso=cgon_25ud18          cgdo=cgon_25ud18          cgbo=0
+ cgdl=cgln_25ud18          cgsl=cgln_25ud18          clc=1e-007
+ cle=0.6                   cf=cfn_25ud18             ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.718                voffcv=-0.1132            kt1=-0.355175
+ wkt1=6.176225e-009        kt1l=0                    kt2=-0.037157622
+ wkt2=-4.2838284e-009      ute=-1.69245              wute=8.646715e-008
+ ua1=1.759824e-009         wua1=-1.3143007e-016      ub1=-2.810821e-018
+ wub1=4.5247049e-025       uc1=-6.6376089e-011       wuc1=6.423644e-017
+ prt=0                     at=118518.81              fnoimod=1

+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)
+ k1=0.12944                kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.33e-8           k2=0.025199979+dk2p_lvt
+ lk2=2.2830436e-010+dlk2p_lvt                        wk2=-7.0449777e-009+dwk2p_lvt
+ pk2=4.9204037e-016+dpk2p_lvt                        k3=-1.2549878
+ k3b=0.79294122            w0=0                      dvt0=2.5
+ dvt1=1                    dvt2=0.0012               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=4.756553e-008
+ dvtp1=3.3913851           lpe0=1.9366257e-007       lpeb=2.5e-009
+ xj=1.1e-007               ngate=1.3715e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0048555202
+ lcit=-1.1176014e-010+dlcitp_lvt                     wcit=-2.6763548e-009+dwcitp_lvt
+ pcit=2.6555575e-016+dpcitp_lvt                      voff=-0.099417327+dvoffp_lvt
+ lvoff=-7.0551981e-010+dlvoffp_lvt                   wvoff=1.3139201e-008+dwvoffp_lvt
+ pvoff=-1.4388268e-015+dpvoffp_lvt                   nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.25+deta0p_lvt      etab=-0.21                u0=0.014833628+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-9.5368312e-011+dlu0p_lvt
+ wu0=-1.0889489e-009+dwu0p_lvt                       pu0=-9.5166826e-017+dpu0p_lvt
+ ua=1.8153927e-009         lua=1.4702807e-17+dluap_lvt
+ wua=-5.3213209e-016       pua=-5.3851315e-23+dpuap_lvt
+ ub=6.8207074e-019         lub=-7.1278111e-26+dlubp_lvt
+ wub=3.8032571e-025        pub=3.2055473e-32+dpubp_lvt
+ uc=1.7146825e-011+ducp_lvt                          luc=-2.8237985e-018
+ wuc=-3.1552137e-019       puc=2.2005754e-024        vsat=88638+dvsatp_lvt+6223.69*ff_flag_lvt
+ kvsat=1                   a0=2.3074027+da0p_lvt     la0=5.2181677e-008+dla0p_lvt
+ wa0=1.2239706e-006+dwa0p_lvt                        pa0=-2.3231661e-013+dpa0p_lvt
+ ags=9.4474512+dagsp_lvt-3.42303*ff_flag_lvt-2.04796*ss_flag_lvt
+ lags=-9.7886473e-007+dlagsp_lvt+7.38723e-07*ff_flag_lvt+1.67892e-07*ss_flag_lvt
+ wags=-4.0189662e-006+dwagsp_lvt+2.10858e-06*ff_flag_lvt+1.26154e-06*ss_flag_lvt
+ pags=7.8265132e-013+dpagsp_lvt-4.55054e-13*ff_flag_lvt-1.03421e-13*ss_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.17071093+dketap_lvt
+ lketa=8.5676244e-009+dlketap_lvt                    wketa=3.8973982e-008+dwketap_lvt
+ pketa=-7.7035372e-016+dpketap_lvt                   dwg=0
+ dwb=0                     pclm=-0.21393052+dpclmp_lvt
+ lpclm=7.0818165e-008+dlpclmp_lvt                    wpclm=2.1336446e-007+dwpclmp_lvt
+ ppclm=-4.6046184e-014+dppclmp_lvt                   pdiblc1=0
+ pdiblc2=-0.017583273      lpdiblc2=1.6633368e-009   wpdiblc2=2.1042338e-008
+ ppdiblc2=-1.4103495e-015  pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.96
+ pditsd=0.8613             pditsl=350000             rsh=15.5
+ rsw=110+drdswp_lvt        rdw=110+drdswp_lvt        prwg=0
+ prwb=0                    wr=1                      alpha0=6.33e-009
+ alpha1=0.017727           beta0=14.154              agidl=1e-008
+ bgidl=3e+009              cgidl=0.225               egidl=0.8
+ aigbacc=0.013008          bigbacc=0.0062797         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0065469            bigc=0.000931576          cigc=0
+ aigsd=0.0049844           bigsd=0.000394153         cigsd=0.039059
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_lvt             cgdo=cgop_lvt             cgbo=0
+ cgdl=cglp_lvt             cgsl=cglp_lvt             clc=1e-007
+ cle=0.6                   cf=cfp_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=6.8311
+ noff=3.1615               voffcv=-0.16125           kt1=-0.2738189
+ lkt1=1.2438396e-009+dlkt1p_lvt                      wkt1=4.5431289e-009+dwkt1p_lvt
+ pkt1=-1.7008244e-015+dpkt1p_lvt                     kt1l=0
+ kt2=-0.042073494          lkt2=-1.469615e-009       wkt2=-1.0482836e-008
+ pkt2=8.593829e-016        ute=-1                    ua1=6.6611043e-009
+ lua1=-3.5848292e-016      wua1=-2.24316e-017        pua1=4.8409636e-024
+ ub1=-1.0679431e-017       lub1=6.3192882e-025       wub1=2.275723e-025
+ pub1=-1.768639e-032       uc1=5.7638443e-011+duc1p_lvt
+ wuc1=-3.3104575e-017      prt=0                     at=197502.81
+ lat=-0.014119043+dlatp_lvt                          wat=-0.019089311+dwatp_lvt
+ pat=2.486733e-009+dpatp_lvt                         jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             weta0=0+dweta0p_lvt
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt-0.00134313*ff_flag_lvt
+ wvsat=0+dwvsatp_lvt-0.00383379*ff_flag_lvt          pvsat=0+dpvsatp_lvt+8.2737e-10*ff_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_lvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_lvt            rnoib=0
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     15: type=p 
+ lmin=6e-08                lmax=9.99969e-008-(dxlp_lvt+dlmisp_lvt)
+ wmin=6e-007-(dxwp_lvt+dwmisp_lvt)                   wmax=1e-006-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)+0.0014199*ff_flag_lvt+0.00443718*ss_flag_lvt+0.0014199*sf_flag_lvt-0.0014199*fs_flag_lvt
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k1=0.12944                k2=0.025039747+dk2p_lvt
+ lk2=2.4144019e-010+dlk2p_lvt                        wk2=-5.939664e-010+dwk2p_lvt
+ pk2=-3.6813543e-017+dpk2p_lvt                       k3=-1.2549878
+ k3b=0.79294122            w0=0                      dvt0=2.5
+ dvt1=1                    dvt2=0.0012               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=4.756553e-008
+ dvtp1=3.3913851           lpe0=1.9366257e-007       lpeb=2.5e-009
+ xj=1.1e-007               ngate=1.3715e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.0017872779+0.00585477*ff_flag_lvt+0.00468381*sf_flag_lvt-0.00468381*fs_flag_lvt
+ lcit=4.3281645e-010+dlcitp_lvt-4.79974e-10*ff_flag_lvt-3.83979e-10*sf_flag_lvt+3.83979e-10*fs_flag_lvt
+ wcit=2.0212057e-009+dwcitp_lvt-3.60654e-09*ff_flag_lvt-2.88523e-09*sf_flag_lvt+2.88523e-09*fs_flag_lvt
+ pcit=-1.1955026e-016+dpcitp_lvt+2.95664e-16*ff_flag_lvt+2.36531e-16*sf_flag_lvt-2.36531e-16*fs_flag_lvt
+ voff=-0.038366457+dvoffp_lvt                        lvoff=-5.7104702e-009+dlvoffp_lvt
+ wvoff=-2.7694533e-008+dwvoffp_lvt                   pvoff=1.9087227e-015+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.25+deta0p_lvt+0.000878215*ff_flag_lvt-0.0470225*ss_flag_lvt
+ etab=-0.38636442          letab=1.4458356e-008      wetab=-3.1026268e-009
+ petab=2.5435335e-016      u0=0.020688642+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-5.7536234e-010+dlu0p_lvt                       wu0=-5.5624347e-009+dwu0p_lvt
+ pu0=2.7156955e-016+dpu0p_lvt                        ua=3.747733e-009
+ lua=-1.4371045e-16+dluap_lvt                        wua=-2.3744413e-015
+ pua=9.7181192e-23+dpuap_lvt                         ub=-2.5347276e-019
+ lub=5.417745e-27+dlubp_lvt                          wub=1.1862405e-024
+ pub=-3.4013419e-32+dpubp_lvt                        uc=-4.1910253e-011+ducp_lvt
+ luc=2.0177007e-018        wuc=5.8376574e-017        puc=-2.6110026e-024
+ vsat=116915.09+dvsatp_lvt-26883*ff_flag_lvt+8782.15*ss_flag_lvt
+ kvsat=1                   lvsat=-0.0023181561+dlvsatp_lvt+0.00137095*ff_flag_lvt-0.00071996*ss_flag_lvt
+ wvsat=-0.01741869+dwvsatp_lvt+0.0179798*ff_flag_lvt-0.00540981*ss_flag_lvt
+ pvsat=1.4279842e-009+dpvsatp_lvt-9.60907e-10*ff_flag_lvt+4.43496e-10*ss_flag_lvt
+ a0=-2.8394081+da0p_lvt    la0=4.7411723e-007+dla0p_lvt
+ wa0=-2.0917048e-006+dwa0p_lvt                       pa0=3.9502458e-014+dpa0p_lvt
+ ags=-6.0944205+dagsp_lvt+0.941079*ff_flag_lvt+7.05339*ss_flag_lvt
+ lags=2.9525791e-007+dlagsp_lvt+3.80951e-07*ff_flag_lvt-5.78236e-07*ss_flag_lvt
+ wags=1.1770386e-005+dwagsp_lvt-1.99959e-06*ff_flag_lvt-5.4098e-06*ss_flag_lvt
+ pags=-5.1175976e-013+dpagsp_lvt-1.18265e-13*ff_flag_lvt+4.43496e-13*ss_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.18588082+dketap_lvt
+ lketa=9.8112522e-009+dlketap_lvt                    wketa=7.0660044e-008+dwketap_lvt
+ pketa=-3.3679771e-015+dpketap_lvt                   dwg=0
+ dwb=0                     pclm=0.9739229+dpclmp_lvt-0.038056*ff_flag_lvt+0.0585477*ss_flag_lvt
+ lpclm=-2.6562059e-008+dlpclmp_lvt+3.11983e-09*ff_flag_lvt-4.79974e-09*ss_flag_lvt
+ wpclm=-5.2375691e-007+dwpclmp_lvt+2.34425e-08*ff_flag_lvt-3.60654e-08*ss_flag_lvt
+ ppclm=1.4383026e-014+dppclmp_lvt-1.92181e-15*ff_flag_lvt+2.95664e-15*ss_flag_lvt
+ pdiblc1=0                 pdiblc2=0.0072499451      lpdiblc2=-3.7249043e-010
+ wpdiblc2=1.1128045e-009   ppdiblc2=2.2347364e-016   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.20071176-0.0585477*ff_flag_lvt-0.0468381*sf_flag_lvt+0.0468381*fs_flag_lvt
+ lkt1=-4.7494835e-009+dlkt1p_lvt+4.79974e-09*ff_flag_lvt+3.83979e-09*sf_flag_lvt-3.83979e-09*fs_flag_lvt
+ wkt1=-4.0005491e-008+dwkt1p_lvt+3.60654e-08*ff_flag_lvt+2.88523e-08*sf_flag_lvt-2.88523e-08*fs_flag_lvt
+ pkt1=1.9512715e-015+dpkt1p_lvt-2.95664e-15*ff_flag_lvt-2.36531e-15*sf_flag_lvt+2.36531e-15*fs_flag_lvt
+ kt1l=0                    kt2=-0.048016382          lkt2=-9.8241698e-010
+ wkt2=-1.8028892e-008      pkt2=1.4780086e-015       ute=-1
+ ua1=2.6305537e-009        lua1=-2.8058386e-017      wua1=-7.5417992e-018
+ pua1=3.6202977e-024       ub1=-2.9117712e-018       lub1=-4.8639462e-027
+ wub1=-2.4715832e-026      pub1=2.9961909e-033       uc1=-2.5935681e-012+duc1p_lvt
+ luc1=4.9378203e-018       wuc1=3.998344e-018        puc1=-3.0416973e-024
+ prt=0                     at=30834.6                lat=-0.00045558338+dlatp_lvt
+ wat=0.017971213+dwatp_lvt pat=-5.5148872e-010+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ weta0=0+dweta0p_lvt-5.40981e-10*ff_flag_lvt+3.60654e-08*ss_flag_lvt
+ lvth0=0+dlvthp_lvt-1.16403e-10*ff_flag_lvt-3.63759e-10*ss_flag_lvt-1.16403e-10*sf_flag_lvt+1.16403e-10*fs_flag_lvt
+ wvth0=0+dwvthp_lvt-1.44261e-09*ff_flag_lvt-4.50817e-09*ss_flag_lvt-1.44261e-09*sf_flag_lvt+1.44261e-09*fs_flag_lvt
+ pvth0=0+dpvthp_lvt+1.18265e-16*ff_flag_lvt+3.6958e-16*ss_flag_lvt+1.18265e-16*sf_flag_lvt-1.18265e-16*fs_flag_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt-7.1996e-11*ff_flag_lvt+3.85491e-09*ss_flag_lvt
+ peta0=0+dpeta0p_lvt+4.43496e-17*ff_flag_lvt-2.95664e-15*ss_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_lvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_lvt            rnoib=0
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     16: type=p 
+ lmin=9.999993e-006-(dxlp_lvt+dlmisp_lvt)            lmax=2.00001e-05
+ wmin=3e-007-(dxwp_lvt+dwmisp_lvt)                   wmax=6e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=2.134663e-08         ll=0
+ wl=0                      lln=0                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=2.134663e-08+ddlcp_lvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+(dvthp_lvt+vthmisp_lvt)                 k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.0081461195+dk2p_lvt  wk2=-4.2266495e-010+dwk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0003                voff=-0.14086765+dvoffp_lvt
+ wvoff=-1.3043905e-009+dwvoffp_lvt                   nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.27106667+deta0p_lvt                          weta0=-1.2977067e-008+dweta0p_lvt
+ etab=-0.22053333          wetab=6.4885333e-009      u0=0.01692365+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=7.5358345e-010+dwu0p_lvt
+ ua=2.0266931e-009         wua=-2.3981489e-018       ub=4.0434845e-019
+ pub=0+dpubp_lvt           lub=0+dlubp_lvt           pua=0+dpuap_lvt
+ lua=0+dluap_lvt           wub=-3.8647994e-026       uc=-1.6020752e-011+ducp_lvt
+ vsat=88638+dvsatp_lvt     a0=5.1707546+da0p_lvt     kvsat=1
+ wa0=3.8820834e-007+dwa0p_lvt                        ags=1.15606+dagsp_lvt
+ wags=6.6805809e-009+dwagsp_lvt                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.0035588714+dketap_lvt                        wketa=3.9677352e-009+dwketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11422+dpclmp_lvt
+ pdiblc1=0                 pdiblc2=-0.00038639647    wpdiblc2=1.4224958e-009
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.96                pditsd=0.8613
+ pditsl=350000             rsh=15.5                  rsw=110+drdswp_lvt
+ rdw=110+drdswp_lvt        prwg=0                    prwb=0
+ wr=1                      alpha0=6.33e-009          alpha1=0.017727
+ beta0=14.154              agidl=1e-008              bgidl=3e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.013008
+ bigbacc=0.0062797         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0065469
+ bigc=0.000931576          cigc=0                    aigsd=0.0049844
+ bigsd=0.000394153         cigsd=0.039059            nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_lvt
+ cgdo=cgop_lvt             cgbo=0                    cgdl=cglp_lvt
+ cgsl=cglp_lvt             clc=1e-007                cle=0.6
+ cf=cfp_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=6.8311               noff=3.1615
+ voffcv=-0.16125           kt1=-0.19833126           wkt1=2.6471399e-009+dwkt1p_lvt
+ kt1l=0                    kt2=-0.049066178          wkt2=-2.2047044e-010
+ ute=-1                    ua1=2.6771479e-009        wua1=-7.5287653e-017
+ ub1=-1.2256926e-018       wub1=3.4797907e-025       uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             pketa=0+dpketap_lvt
+ lketa=0+dlketap_lvt       lk2=0+dlk2p_lvt           pk2=0+dpk2p_lvt
+ lu0=0+dlu0p_lvt           pu0=0+dpu0p_lvt           lags=0+dlagsp_lvt
+ pags=0+dpagsp_lvt         la0=0+dla0p_lvt           pa0=0+dpa0p_lvt
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       lpclm=0+dlpclmp_lvt
+ wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt       lvoff=0+dlvoffp_lvt
+ pvoff=0+dpvoffp_lvt       lcit=0+dlcitp_lvt         wcit=0+dwcitp_lvt
+ pcit=0+dpcitp_lvt         lat=0+dlatp_lvt           wat=0+dwatp_lvt
+ pat=0+dpatp_lvt           lkt1=0+dlkt1p_lvt         pkt1=0+dpkt1p_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_lvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_lvt            rnoib=0
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     17: type=p 
+ lmin=9.999933e-007-(dxlp_lvt+dlmisp_lvt)            lmax=9.999993e-006-(dxlp_lvt+dlmisp_lvt)
+ wmin=3e-007-(dxwp_lvt+dwmisp_lvt)                   wmax=6e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=2.134663e-08         ll=0
+ wl=0                      lln=0                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=2.134663e-08+ddlcp_lvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+(dvthp_lvt+vthmisp_lvt)                 k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.0073229198+dk2p_lvt  lk2=8.1878736e-009+dlk2p_lvt
+ wk2=-2.625643e-010+dwk2p_lvt                        pk2=-1.5924251e-015+dpk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00027896889         lcit=2.0918384e-010+dlcitp_lvt
+ voff=-0.14465587+dvoffp_lvt                         lvoff=3.7679086e-008+dlvoffp_lvt
+ wvoff=-1.0899658e-009+dwvoffp_lvt                   pvoff=-2.1327537e-015+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.27106667+deta0p_lvt
+ weta0=-1.2977067e-008+dweta0p_lvt                   etab=-0.22053333
+ wetab=6.4885333e-009      u0=0.017223391+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-2.9813377e-009+dlu0p_lvt                       wu0=7.230379e-010+dwu0p_lvt
+ pu0=3.0381823e-016+dpu0p_lvt                        ua=2.1345562e-009
+ lua=-1.072849e-15+dluap_lvt                         wua=-3.2457156e-017
+ pua=2.9897891e-22+dpuap_lvt                         ub=2.9798756e-019
+ lub=1.0579079e-24+dlubp_lvt                         wub=-5.4191973e-027
+ pub=-3.305069e-31+dpubp_lvt                         uc=-1.6020752e-011+ducp_lvt
+ vsat=88638+dvsatp_lvt     a0=5.1517382+da0p_lvt     kvsat=1
+ la0=1.8914467e-007+dla0p_lvt                        wa0=4.2389301e-007+dwa0p_lvt
+ pa0=-3.5493402e-013+dpa0p_lvt                       ags=1.1520767+dagsp_lvt
+ lags=3.9620008e-008+dlagsp_lvt                      wags=-7.1741841e-009+dwagsp_lvt
+ pags=1.3780504e-013+dpagsp_lvt                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.0065422887+dketap_lvt                        lketa=-2.9674262e-008+dlketap_lvt
+ wketa=4.3559845e-009+dwketap_lvt                    pketa=-3.8616828e-015+dpketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11422+dpclmp_lvt
+ pdiblc1=0                 pdiblc2=-0.0032278695     lpdiblc2=2.8262427e-008
+ wpdiblc2=2.2954627e-009   ppdiblc2=-8.682878e-015   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.19408119           lkt1=-4.2272922e-008+dlkt1p_lvt
+ wkt1=2.5040314e-009+dwkt1p_lvt                      pkt1=1.4234143e-015+dpkt1p_lvt
+ kt1l=0                    kt2=-0.047357889          lkt2=-1.6991323e-008
+ wkt2=-5.7736012e-010      pkt2=3.5497676e-015       ute=-1
+ ua1=2.6771479e-009        lua1=3.465479e-022        wua1=-7.5287779e-017
+ pua1=1.2554991e-027       ub1=-1.1388191e-018       lub1=-8.640787e-025
+ wub1=3.4822772e-025       pub1=-2.4731996e-033      uc1=1.0129261e-011+duc1p_lvt
+ luc1=3.3526723e-017       wuc1=1.0651537e-018       puc1=-1.0594444e-023
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_lvt
+ wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt
+ peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt       wvsat=0+dwvsatp_lvt
+ pvsat=0+dpvsatp_lvt       lpclm=0+dlpclmp_lvt       wpclm=0+dwpclmp_lvt
+ ppclm=0+dppclmp_lvt       wcit=0+dwcitp_lvt         pcit=0+dpcitp_lvt
+ lat=0+dlatp_lvt           wat=0+dwatp_lvt           pat=0+dpatp_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_lvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_lvt            rnoib=0
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     18: type=p 
+ lmin=2.39995e-007-(dxlp_lvt+dlmisp_lvt)             lmax=9.999933e-007-(dxlp_lvt+dlmisp_lvt)
+ wmin=3e-007-(dxwp_lvt+dwmisp_lvt)                   wmax=6e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=5.0965e-03
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=5.0965e-03            wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)
+ k1=0.12944                kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.33e-8           k2=0.014144478+dk2p_lvt
+ lk2=1.7319507e-009+dlk2p_lvt                        wk2=-1.8560893e-009+dwk2p_lvt
+ pk2=-8.4313055e-017+dpk2p_lvt                       k3=-1.2549878
+ k3b=0.79294122            w0=0                      dvt0=2.5
+ dvt1=1                    dvt2=0.0012               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=4.756553e-008
+ dvtp1=3.3913851           lpe0=1.9366257e-007       lpeb=2.5e-009
+ xj=1.1e-007               ngate=1.3715e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00035807009
+ lcit=1.3432247e-010+dlcitp_lvt                      wcit=-1.8378445e-010+dwcitp_lvt
+ pcit=1.739336e-016+dpcitp_lvt                       voff=-0.11012545+dvoffp_lvt
+ lvoff=4.9994958e-009+dlvoffp_lvt                    wvoff=-3.38121e-009+dwvoffp_lvt
+ pvoff=3.5679851e-017+dpvoffp_lvt                    nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.27106667+deta0p_lvt                          weta0=-1.2977067e-008+dweta0p_lvt
+ etab=-0.22053333          wetab=6.4885333e-009      u0=0.014936257+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-8.1679406e-010+dlu0p_lvt
+ wu0=1.2147979e-009+dwu0p_lvt                        pu0=-1.6158345e-016+dpu0p_lvt
+ ua=1.1044819e-009         lua=-9.7986692e-17+dluap_lvt
+ wua=3.7370854e-016        pua=-8.5416308e-23+dpuap_lvt
+ ub=1.4606316e-018         lub=-4.2418433e-26+dlubp_lvt
+ wub=-4.4962366e-025       pub=8.9888208e-32+dpubp_lvt
+ uc=-3.1274107e-011+ducp_lvt                         luc=1.4435776e-017
+ wuc=2.8229056e-018        puc=-2.6715978e-024       vsat=88638+dvsatp_lvt
+ a0=6.1789073+da0p_lvt     kvsat=1                   la0=-7.8296813e-007+dla0p_lvt
+ wa0=2.0026762e-008+dwa0p_lvt                        pa0=2.7284994e-014+dpa0p_lvt
+ ags=0.41358712+dagsp_lvt  lags=7.3852653e-007+dlagsp_lvt
+ wags=9.9450688e-008+dwagsp_lvt                      pags=3.6895256e-014+dpagsp_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.0068227708+dketap_lvt
+ lketa=-1.7025569e-008+dlketap_lvt                   wketa=-1.8588896e-009+dwketap_lvt
+ pketa=2.020074e-015+dpketap_lvt                     dwg=0
+ dwb=0                     pclm=0.11422+dpclmp_lvt   pdiblc1=0
+ pdiblc2=0.027688335       lpdiblc2=-9.9666839e-010  wpdiblc2=-7.2016484e-009
+ ppdiblc2=3.0518794e-016   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.96
+ pditsd=0.8613             pditsl=350000             rsh=15.5
+ rsw=110+drdswp_lvt        rdw=110+drdswp_lvt        prwg=0
+ prwb=0                    wr=1                      alpha0=6.33e-009
+ alpha1=0.017727           beta0=14.154              agidl=1e-008
+ bgidl=3e+009              cgidl=0.225               egidl=0.8
+ aigbacc=0.013008          bigbacc=0.0062797         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0065469            bigc=0.000931576          cigc=0
+ aigsd=0.0049844           bigsd=0.000394153         cigsd=0.039059
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_lvt             cgdo=cgop_lvt             cgbo=0
+ cgdl=cglp_lvt             cgsl=cglp_lvt             clc=1e-007
+ cle=0.6                   cf=cfp_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=6.8311
+ noff=3.1615               voffcv=-0.16125           kt1=-0.22815023
+ lkt1=-1.0029985e-008+dlkt1p_lvt                     wkt1=4.9823727e-009+dwkt1p_lvt
+ pkt1=-9.2208782e-016+dpkt1p_lvt                     kt1l=0
+ kt2=-0.068742093          lkt2=3.2466882e-009       wkt2=5.1550375e-009
+ pkt2=-1.8753735e-015      ute=-1                    ua1=1.9909979e-009
+ lua1=6.4937275e-016       wua1=-9.7525423e-017      pua1=2.1046961e-023
+ ub1=-3.4032809e-019       lub1=-1.6197706e-024      wub1=3.8747626e-025
+ pub1=-3.961802e-032       uc1=6.9183671e-011+duc1p_lvt
+ luc1=-2.2362371e-017      wuc1=-2.0096764e-017      puc1=9.4331944e-024
+ prt=0                     at=154579.56              lat=-0.0043340919+dlatp_lvt
+ wat=0.0026749454+dwatp_lvt                          pat=-2.5315684e-009+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       lpclm=0+dlpclmp_lvt
+ wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0127             pku0we=1.1e-17
+ wku0we=-4.5e-10           lku0we=-0.3e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap_lvt            rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_lvt            rnoib=0                   noic=noicp_lvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     19: type=p 
+ lmin=9.99969e-008-(dxlp_lvt+dlmisp_lvt)             lmax=2.39995e-007-(dxlp_lvt+dlmisp_lvt)
+ wmin=3e-007-(dxwp_lvt+dwmisp_lvt)                   wmax=6e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)
+ k1=0.12944                kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.33e-8           k2=0.019791922+dk2p_lvt
+ lk2=5.1317576e-010+dlk2p_lvt                        wk2=-3.7136151e-009+dwk2p_lvt
+ pk2=3.1655958e-016+dpk2p_lvt                        k3=-1.2549878
+ k3b=0.79294122            w0=0                      dvt0=2.5
+ dvt1=1                    dvt2=0.0012               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=4.756553e-008
+ dvtp1=3.3913851           lpe0=1.9366257e-007       lpeb=2.5e-009
+ xj=1.1e-007               ngate=1.3715e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00096812064
+ lcit=4.2052769e-010+dlcitp_lvt                      wcit=9.11008e-010+dwcitp_lvt
+ pcit=-6.2333558e-017+dpcitp_lvt                     voff=-0.073541603+dvoffp_lvt
+ lvoff=-2.8956638e-009+dlvoffp_lvt                   wvoff=-2.8002455e-009+dwvoffp_lvt
+ pvoff=-8.9698112e-017+dpvoffp_lvt                   nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.27106667+deta0p_lvt                          weta0=-1.2977067e-008+dweta0p_lvt
+ etab=-0.22053333          wetab=6.4885333e-009      u0=0.012779033+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-3.5124353e-010+dlu0p_lvt
+ wu0=1.7668218e-010+dwu0p_lvt                        pu0=6.2452306e-017+dpu0p_lvt
+ ua=1.1408363e-009         lua=-1.0583233e-16+dluap_lvt
+ wua=-1.1660534e-016       pua=2.039833e-23+dpuap_lvt
+ ub=1.4265379e-018         lub=-3.506067e-26+dlubp_lvt
+ wub=-7.8266089e-026       pub=9.7455291e-33+dpubp_lvt
+ uc=4.2902779e-011+ducp_lvt                          luc=-1.5723382e-018
+ wuc=-1.6181189e-017       puc=1.4296758e-024        vsat=88638+dvsatp_lvt
+ a0=3.9722741+da0p_lvt     kvsat=1                   la0=-3.0675462e-007+dla0p_lvt
+ wa0=1.984098e-007+dwa0p_lvt                         pa0=-1.121185e-014+dpa0p_lvt
+ ags=2.1872891+dagsp_lvt   lags=3.5574391e-007+dlagsp_lvt
+ wags=4.5329369e-007+dwagsp_lvt                      pags=-3.9467602e-014+dpagsp_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.13233902+dketap_lvt
+ lketa=1.0062093e-008+dlketap_lvt                    wketa=1.5336886e-008+dwketap_lvt
+ pketa=-1.6909464e-015+dpketap_lvt                   dwg=0
+ dwb=0                     pclm=0.1356101+dpclmp_lvt lpclm=-4.6161978e-009+dlpclmp_lvt
+ wpclm=-1.952566e-009+dwpclmp_lvt                    ppclm=4.2138327e-016+dppclmp_lvt
+ pdiblc1=0                 pdiblc2=0.02851038        lpdiblc2=-1.1740739e-009
+ wpdiblc2=-7.3513519e-009  ppdiblc2=3.3749547e-016   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.26657049           lkt1=-1.7385082e-009+dlkt1p_lvt
+ wkt1=7.8106307e-011+dwkt1p_lvt                      pkt1=1.363019e-016+dpkt1p_lvt
+ kt1l=0                    kt2=-0.052237715          lkt2=-3.1512171e-010
+ wkt2=-4.2216761e-009      pkt2=1.4821506e-016       ute=-1
+ ua1=6.6835086e-009        lua1=-3.6331799e-016      wua1=-3.6232626e-017
+ pua1=7.8193631e-024       ub1=-1.0651586e-017       lub1=6.0550198e-025
+ wub1=2.1041977e-025       pub1=-1.4074594e-033      uc1=-4.8946516e-011+duc1p_lvt
+ luc1=3.1313043e-018       wuc1=3.255176e-017        puc1=-1.9288835e-024
+ prt=0                     at=194511.62              lat=-0.012951831+dlatp_lvt
+ wat=-0.017246737+dwatp_lvt                          pat=1.76773e-009+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0127             pku0we=1.1e-17
+ wku0we=-4.5e-10           lku0we=-0.3e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap_lvt            rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_lvt            rnoib=0                   noic=noicp_lvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     20: type=p 
+ lmin=6e-08                lmax=9.99969e-008-(dxlp_lvt+dlmisp_lvt)
+ wmin=3e-007-(dxwp_lvt+dwmisp_lvt)                   wmax=6e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)+0.00454091*ff_flag_lvt-0.00591623*ss_flag_lvt-0.0018932*sf_flag_lvt+0.0018932*fs_flag_lvt
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k1=0.12944                k2=0.0249808+dk2p_lvt
+ lk2=8.7791603e-011+dlk2p_lvt                        wk2=-5.5765516e-010+dwk2p_lvt
+ pk2=5.7833988e-017+dpk2p_lvt                        k3=-1.2549878
+ k3b=0.79294122            w0=0                      dvt0=2.5
+ dvt1=1                    dvt2=0.0012               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=4.756553e-008
+ dvtp1=3.3913851           lpe0=1.9366257e-007       lpeb=2.5e-009
+ xj=1.1e-007               ngate=1.3715e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0024997422+0.00121398*ff_flag_lvt+0.000971185*sf_flag_lvt-0.000971185*fs_flag_lvt
+ lcit=1.362323e-010+dlcitp_lvt-9.95221e-11*ff_flag_lvt-7.96177e-11*sf_flag_lvt+7.96177e-11*fs_flag_lvt
+ wcit=-6.1959865e-010+dwcitp_lvt-7.47812e-10*ff_flag_lvt-5.9825e-10*sf_flag_lvt+5.9825e-10*fs_flag_lvt
+ pcit=6.3145575e-017+dpcitp_lvt+6.13056e-17*ff_flag_lvt+4.90445e-17*sf_flag_lvt-4.90445e-17*fs_flag_lvt
+ voff=-0.055467132+dvoffp_lvt                        lvoff=-4.3774089e-009+dlvoffp_lvt
+ wvoff=-1.7160518e-008+dwvoffp_lvt                   pvoff=1.087557e-015+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.27106667+deta0p_lvt-0.0075344*ss_flag_lvt+0.0293783*ff_flag_lvt
+ weta0=-1.2977067e-008+dweta0p_lvt+1.17407e-08*ss_flag_lvt-1.80971e-08*ff_flag_lvt
+ etab=-0.41035458          letab=1.5561545e-008      wetab=1.1675306e-008
+ petab=-4.2521165e-016     u0=0.010332335+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-1.5066326e-010+dlu0p_lvt                       wu0=8.1705052e-010+dwu0p_lvt
+ pu0=9.95491e-018+dpu0p_lvt                          ua=-6.0576619e-010
+ lua=3.7354143e-17+dluap_lvt                         wua=3.0731422e-016
+ pua=-1.4354595e-23+dpuap_lvt                        ub=2.2462994e-018
+ lub=-1.0226471e-25+dlubp_lvt                        wub=-3.5361918e-025
+ pub=3.2318976e-32+dpubp_lvt                         uc=7.9350611e-011+ducp_lvt
+ luc=-4.5603315e-018       wuc=-1.6320118e-017       puc=1.4410652e-024
+ vsat=76911.541+dvsatp_lvt+3519.01*ff_flag_lvt+2427.96*ss_flag_lvt
+ kvsat=1                   lvsat=0.00096133509+dlvsatp_lvt-0.000288488*ff_flag_lvt-0.000199044*ss_flag_lvt
+ wvsat=0.0072234986+dwvsatp_lvt-0.000747808*ff_flag_lvt-0.00149562*ss_flag_lvt
+ pvsat=-5.9218242e-010+dpvsatp_lvt+6.13054e-11*ff_flag_lvt+1.22611e-10*ss_flag_lvt
+ a0=-10.887539+da0p_lvt    la0=9.1145288e-007+dla0p_lvt
+ wa0=2.865944e-006+dwa0p_lvt                         pa0=-2.2989631e-013+dpa0p_lvt
+ ags=12.741529+dagsp_lvt-0.969647*ff_flag_lvt-1.12178*ss_flag_lvt+0.0971185*sf_flag_lvt-0.0971185*fs_flag_lvt
+ lags=-5.0949264e-007+dlagsp_lvt+7.94921e-08*ff_flag_lvt+9.19639e-08*ss_flag_lvt-7.96177e-09*sf_flag_lvt+7.96177e-09*fs_flag_lvt
+ wags=1.674413e-007+dwagsp_lvt-8.22594e-07*ff_flag_lvt-3.73904e-07*ss_flag_lvt-5.9825e-08*sf_flag_lvt+5.9825e-08*fs_flag_lvt
+ pags=-1.6033423e-014+dpagsp_lvt+6.74362e-14*ff_flag_lvt+3.06528e-14*ss_flag_lvt+4.90445e-15*sf_flag_lvt-4.90445e-15*fs_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.069880362+dketap_lvt
+ lketa=4.941732e-009+dlketap_lvt                     wketa=-7.9624005e-010+dwketap_lvt
+ pketa=-3.6835267e-016+dpketap_lvt                   dwg=0
+ dwb=0                     pclm=0.12108447+dpclmp_lvt-0.0279216*ff_flag_lvt+0.0182097*ss_flag_lvt-0.0145678*sf_flag_lvt+0.0145678*fs_flag_lvt
+ lpclm=-3.4253869e-009+dlpclmp_lvt+2.28901e-09*ff_flag_lvt-1.49283e-09*ss_flag_lvt+1.19426e-09*sf_flag_lvt-1.19426e-09*fs_flag_lvt
+ wpclm=1.5915591e-009+dwpclmp_lvt+1.71997e-08*ff_flag_lvt-1.12172e-08*ss_flag_lvt+8.97374e-09*sf_flag_lvt-8.97374e-09*fs_flag_lvt
+ ppclm=1.308359e-016+dppclmp_lvt-1.41003e-15*ff_flag_lvt+9.19584e-16*ss_flag_lvt-7.35667e-16*sf_flag_lvt+7.35667e-16*fs_flag_lvt
+ pdiblc1=0                 pdiblc2=0.014584655       lpdiblc2=-3.2443025e-011
+ wpdiblc2=-3.4053769e-009  ppdiblc2=1.4004439e-017   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.2773523            lkt1=-8.5461562e-010+dlkt1p_lvt
+ wkt1=7.2050769e-009+dwkt1p_lvt                      pkt1=-4.4796715e-016+dpkt1p_lvt
+ kt1l=0                    kt2=-0.068850606          lkt2=1.0468031e-009
+ wkt2=-5.1950104e-009      pkt2=2.2800901e-016       ute=-1
+ ua1=2.795449e-009         lua1=-4.4574865e-017      wua1=-1.0911731e-016
+ pua1=1.3794449e-023       ub1=-3.6153879e-018       lub1=2.8674451e-026
+ wub1=4.0871207e-025       pub1=-1.7663462e-032      uc1=-3.1408228e-011+duc1p_lvt
+ luc1=1.6935155e-018       wuc1=2.1748175e-017       puc1=-1.0432056e-024
+ prt=0                     at=45105.123              lat=-0.00070348598+dlatp_lvt
+ wat=0.0091805706+dwatp_lvt                          pat=-3.9878071e-010+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt-3.72263e-10*ff_flag_lvt+4.85013e-10*ss_flag_lvt+1.55204e-10*sf_flag_lvt-1.55204e-10*fs_flag_lvt
+ wvth0=0+dwvthp_lvt-3.36515e-09*ff_flag_lvt+1.86953e-09*ss_flag_lvt+5.9825e-10*sf_flag_lvt-5.9825e-10*fs_flag_lvt
+ pvth0=0+dpvthp_lvt+2.75875e-16*ff_flag_lvt-1.53264e-16*ss_flag_lvt-4.90445e-17*sf_flag_lvt+4.90445e-17*fs_flag_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt+6.17667e-10*ss_flag_lvt-2.40843e-09*ff_flag_lvt
+ peta0=0+dpeta0p_lvt-9.62498e-16*ss_flag_lvt+1.4836e-15*ff_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_lvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_lvt            rnoib=0
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     21: type=p 
+ lmin=9.999993e-006-(dxlp_lvt+dlmisp_lvt)            lmax=2.00001e-05
+ wmin=1.2e-07              wmax=3e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=2.134663e-08         ll=0
+ wl=0                      lln=0                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=2.134663e-08+ddlcp_lvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+(dvthp_lvt+vthmisp_lvt)                 k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.0058473222+dk2p_lvt  wk2=3.0375501e-010+dwk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0003                voff=-0.15414109+dvoffp_lvt
+ wvoff=2.8900152e-009+dwvoffp_lvt                    nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.24511111+deta0p_lvt                          weta0=-4.7751111e-009+dweta0p_lvt
+ etab=-0.26044444          wetab=1.9100444e-008      u0=0.021078331+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=-5.5929578e-010+dwu0p_lvt
+ ua=2.7223704e-009         wua=-2.2223217e-016       ub=4.0827163e-019
+ pub=0+dpubp_lvt           lub=0+dlubp_lvt           pua=0+dpuap_lvt
+ lua=0+dluap_lvt           wub=-3.9887718e-026       uc=-1.6020752e-011+ducp_lvt
+ vsat=88638+dvsatp_lvt     a0=5.8620408+da0p_lvt     kvsat=1
+ wa0=1.6976189e-007+dwa0p_lvt                        ags=1.1727929+dagsp_lvt
+ wags=1.392993e-009+dwagsp_lvt                       a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.02726517+dketap_lvt                          wketa=-3.5234553e-009+dwketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11422+dpclmp_lvt
+ pdiblc1=0                 pdiblc2=0.0042327966      wpdiblc2=-3.716919e-011
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.96                pditsd=0.8613
+ pditsl=350000             rsh=15.5                  rsw=110+drdswp_lvt
+ rdw=110+drdswp_lvt        prwg=0                    prwb=0
+ wr=1                      alpha0=6.33e-009          alpha1=0.017727
+ beta0=14.154              agidl=1e-008              bgidl=3e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.013008
+ bigbacc=0.0062797         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0065469
+ bigc=0.000931576          cigc=0                    aigsd=0.0049844
+ bigsd=0.000394153         cigsd=0.039059            nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_lvt
+ cgdo=cgop_lvt             cgbo=0                    cgdl=cglp_lvt
+ cgsl=cglp_lvt             clc=1e-007                cle=0.6
+ cf=cfp_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=6.8311               noff=3.1615
+ voffcv=-0.16125           kt1=-0.17204373           wkt1=-5.6597207e-009+dwkt1p_lvt
+ kt1l=0                    kt2=-0.046259127          wkt2=-1.1074983e-009
+ ute=-1                    ua1=2.4915437e-009        wua1=-1.6636702e-017
+ ub1=-1.9055547e-020       wub1=-3.3318252e-026      uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             pketa=0+dpketap_lvt
+ lketa=0+dlketap_lvt       lk2=0+dlk2p_lvt           pk2=0+dpk2p_lvt
+ lu0=0+dlu0p_lvt           pu0=0+dpu0p_lvt           lags=0+dlagsp_lvt
+ pags=0+dpagsp_lvt         la0=0+dla0p_lvt           pa0=0+dpa0p_lvt
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       lpclm=0+dlpclmp_lvt
+ wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt       lvoff=0+dlvoffp_lvt
+ pvoff=0+dpvoffp_lvt       lcit=0+dlcitp_lvt         wcit=0+dwcitp_lvt
+ pcit=0+dpcitp_lvt         lat=0+dlatp_lvt           wat=0+dwatp_lvt
+ pat=0+dpatp_lvt           lkt1=0+dlkt1p_lvt         pkt1=0+dpkt1p_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_lvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_lvt            rnoib=0
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     22: type=p 
+ lmin=9.999933e-007-(dxlp_lvt+dlmisp_lvt)            lmax=9.999993e-006-(dxlp_lvt+dlmisp_lvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=2.134663e-08         ll=0
+ wl=0                      lln=0                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=2.134663e-08+ddlcp_lvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+(dvthp_lvt+vthmisp_lvt)                 k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.0052001787+dk2p_lvt-0.000158902*ff_flag_lvt
+ lk2=6.4367477e-009+dlk2p_lvt+1.5805e-09*ff_flag_lvt
+ wk2=4.0822189e-010+dwk2p_lvt+5.0213e-11*ff_flag_lvt
+ pk2=-1.0390694e-015+dpk2p_lvt-4.99438e-16*ff_flag_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00033522522         lcit=-3.5036409e-010+dlcitp_lvt
+ wcit=-1.7776999e-011+dwcitp_lvt                     pcit=1.7681715e-016+dpcitp_lvt
+ voff=-0.15686036+dvoffp_lvt                         lvoff=2.7046979e-008+dlvoffp_lvt
+ wvoff=2.7666548e-009+dwvoffp_lvt                    pvoff=1.2269923e-015+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.24511111+deta0p_lvt
+ weta0=-4.7751111e-009+dweta0p_lvt                   etab=-0.26044444
+ wetab=1.9100444e-008      u0=0.021354846+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-2.750325e-009+dlu0p_lvt                        wu0=-5.8250198e-010+dwu0p_lvt
+ pu0=2.3081822e-016+dpu0p_lvt                        ua=2.7304005e-009
+ lua=-7.987068e-17+dluap_lvt                         wua=-2.2074397e-016
+ pua=-1.4802229e-23+dpuap_lvt                        ub=4.5685116e-019
+ lub=-4.8319143e-25+dlubp_lvt                        wub=-5.5620093e-026
+ pub=1.564805e-31+dpubp_lvt                          uc=-1.6968876e-011+ducp_lvt
+ luc=9.4304158e-018        wuc=2.9960703e-019        puc=-2.9800114e-024
+ vsat=88638+dvsatp_lvt     a0=6.0269047+da0p_lvt     kvsat=1
+ la0=-1.6398017e-006+dla0p_lvt                       wa0=1.473404e-007+dwa0p_lvt
+ pa0=2.2301303e-013+dpa0p_lvt                        ags=1.121318+dagsp_lvt
+ lags=5.1198997e-007+dlagsp_lvt                      wags=2.5455579e-009+dwagsp_lvt
+ pags=-1.1463871e-014+dpagsp_lvt                     a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.033492099+dketap_lvt                         lketa=-6.1935523e-008+dlketap_lvt
+ wketa=-4.1601556e-009+dwketap_lvt                   pketa=6.3328757e-015+dpketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11422+dpclmp_lvt
+ pdiblc1=0                 pdiblc2=0.0042149125      lpdiblc2=1.7788256e-010
+ wpdiblc2=-5.645638e-011   ppdiblc2=1.918381e-016    pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.16763809           lkt1=-4.3820196e-008+dlkt1p_lvt
+ wkt1=-5.8519866e-009+dwkt1p_lvt                     pkt1=1.912353e-015+dpkt1p_lvt
+ kt1l=0                    kt2=-0.045452094          lkt2=-8.0270803e-009
+ wkt2=-1.1795914e-009      pkt2=7.1706695e-016       ute=-1
+ ua1=2.497566e-009         lua1=-5.9901077e-017      wua1=-1.8539914e-017
+ pua1=1.8930105e-023       ub1=9.4639459e-020        lub1=-1.130856e-024
+ wub1=-4.1545191e-026      pub1=8.1828431e-032       uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_lvt
+ wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt
+ peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt       wvsat=0+dwvsatp_lvt
+ pvsat=0+dpvsatp_lvt       lpclm=0+dlpclmp_lvt       wpclm=0+dwpclmp_lvt
+ ppclm=0+dppclmp_lvt       lat=0+dlatp_lvt           wat=0+dwatp_lvt
+ pat=0+dpatp_lvt           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0127             pku0we=1.1e-17            wku0we=-4.5e-10
+ lku0we=-0.3e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap_lvt
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp_lvt
+ rnoib=0                   noic=noicp_lvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     23: type=p 
+ lmin=2.39995e-007-(dxlp_lvt+dlmisp_lvt)             lmax=9.999933e-007-(dxlp_lvt+dlmisp_lvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=5.0965e-03
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=5.0965e-03            wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)
+ k1=0.12944                kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.33e-8           k2=0.0095150242+dk2p_lvt+0.00195748*ff_flag_lvt
+ lk2=2.353178e-009+dlk2p_lvt-4.22444e-10*ff_flag_lvt
+ wk2=-3.9318185e-010+dwk2p_lvt-6.18564e-10*ff_flag_lvt
+ pk2=-2.8062087e-016+dpk2p_lvt+1.33492e-16*ff_flag_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0010729659         lcit=9.82348e-010+dlcitp_lvt
+ wcit=2.6842293e-010+dwcitp_lvt                      pcit=-9.4042467e-017+dpcitp_lvt
+ voff=-0.13715964+dvoffp_lvt                         lvoff=8.4022124e-009+dlvoffp_lvt
+ wvoff=5.1615944e-009+dwvoffp_lvt                    pvoff=-1.0395786e-015+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.24511111+deta0p_lvt
+ weta0=-4.7751111e-009+dweta0p_lvt                   etab=-0.26044444
+ wetab=1.9100444e-008      u0=0.020046163+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-1.511787e-009+dlu0p_lvt                        wu0=-3.9993235e-010+dwu0p_lvt
+ pu0=5.8034314e-017+dpu0p_lvt                        ua=3.1793094e-009
+ lua=-5.04718e-16+dluap_lvt                          wua=-2.8193692e-016
+ pua=4.3110785e-23+dpuap_lvt                         ub=-5.209241e-019
+ lub=4.4217508e-25+dlubp_lvt                         wub=1.7654795e-025
+ pub=-6.3243343e-32+dpubp_lvt                        uc=-1.3985858e-011+ducp_lvt
+ luc=6.6072879e-018        wuc=-2.6401813e-018       puc=-1.9779574e-025
+ vsat=88638+dvsatp_lvt     a0=4.3176504+da0p_lvt     kvsat=1
+ la0=-2.2163477e-008+dla0p_lvt                       wa0=6.0818392e-007+dwa0p_lvt
+ pa0=-2.1312928e-013+dpa0p_lvt                       ags=0.75285735+dagsp_lvt
+ lags=8.6070113e-007+dlagsp_lvt                      wags=-7.7587045e-009+dwagsp_lvt
+ pags=-1.7119173e-015+dpagsp_lvt                     a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.019582673+dketap_lvt                        lketa=-1.1705559e-008+dlketap_lvt
+ wketa=2.1732394e-009+dwketap_lvt                    pketa=3.3895066e-016+dpketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11676921+dpclmp_lvt
+ lpclm=-2.4125767e-009+dlpclmp_lvt                   wpclm=-8.0555182e-010+dwpclmp_lvt
+ ppclm=7.6237424e-016+dppclmp_lvt                    pdiblc1=0
+ pdiblc2=0.0043534288      lpdiblc2=4.6790728e-011   wpdiblc2=1.7218188e-010
+ ppdiblc2=-2.4545142e-017  pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.96
+ pditsd=0.8613             pditsl=350000             rsh=15.5
+ rsw=110+drdswp_lvt        rdw=110+drdswp_lvt        prwg=0
+ prwb=0                    wr=1                      alpha0=6.33e-009
+ alpha1=0.017727           beta0=14.154              agidl=1e-008
+ bgidl=3e+009              cgidl=0.225               egidl=0.8
+ aigbacc=0.013008          bigbacc=0.0062797         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0065469            bigc=0.000931576          cigc=0
+ aigsd=0.0049844           bigsd=0.000394153         cigsd=0.039059
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_lvt             cgdo=cgop_lvt             cgbo=0
+ cgdl=cglp_lvt             cgsl=cglp_lvt             clc=1e-007
+ cle=0.6                   cf=cfp_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=6.8311
+ noff=3.1615               voffcv=-0.16125           kt1=-0.19691142
+ lkt1=-1.6115917e-008+dlkt1p_lvt                     wkt1=-4.8890889e-009+dwkt1p_lvt
+ pkt1=1.0010667e-015+dpkt1p_lvt                      kt1l=0
+ kt2=-0.048568194          lkt2=-5.0780032e-009      wkt2=-1.2199148e-009
+ pkt2=7.55229e-016         ute=-1                    ua1=1.6763786e-009
+ lua1=7.1727074e-016       wua1=1.894265e-018        pua1=-4.0880133e-025
+ ub1=6.146643e-019         lub1=-1.6230075e-024      wub1=8.5698667e-026
+ pub1=-3.8595156e-032      uc1=1.2301674e-011+duc1p_lvt
+ luc1=1.1340958e-018       wuc1=-2.1220528e-018      puc1=2.0083108e-024
+ prt=0                     at=154019.09              lat=-0.0038036673+dlatp_lvt
+ wat=0.0028520525+dwatp_lvt                          pat=-2.6991825e-009+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0127             pku0we=1.1e-17
+ wku0we=-4.5e-10           lku0we=-0.3e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap_lvt            rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_lvt            rnoib=0                   noic=noicp_lvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     24: type=p 
+ lmin=9.99969e-008-(dxlp_lvt+dlmisp_lvt)             lmax=2.39995e-007-(dxlp_lvt+dlmisp_lvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)
+ k1=0.12944                kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.33e-8           k2=0.012434333+dk2p_lvt
+ lk2=1.7231618e-009+dlk2p_lvt                        wk2=-1.388617e-009+dwk2p_lvt
+ pk2=-6.5796013e-017+dpk2p_lvt                       k3=-1.2549878
+ k3b=0.79294122            w0=0                      dvt0=2.5
+ dvt1=1                    dvt2=0.0012               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=4.756553e-008
+ dvtp1=3.3913851           lpe0=1.9366257e-007       lpeb=2.5e-009
+ xj=1.1e-007               ngate=1.3715e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0024395919
+ lcit=2.243029e-010+dlcitp_lvt                       wcit=-1.6582915e-010+dwcitp_lvt
+ pcit=-3.265252e-019+dpcitp_lvt                      voff=-0.080320993+dvoffp_lvt
+ lvoff=-3.8641357e-009+dlvoffp_lvt                   wvoff=-6.5795807e-010+dwvoffp_lvt
+ pvoff=2.1633902e-016+dpvoffp_lvt                    nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.24511111+deta0p_lvt                          weta0=-4.7751111e-009+dweta0p_lvt
+ etab=-0.26044444          wetab=1.9100444e-008      u0=0.013811826+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-1.6635485e-010+dlu0p_lvt
+ wu0=-1.496806e-010+dwu0p_lvt                        pu0=4.0274848e-018+dpu0p_lvt
+ ua=1.0706117e-009         lua=-4.9639967e-17+dluap_lvt
+ wua=-9.4414374e-017       pua=2.6415432e-24+dpuap_lvt
+ ub=1.6050453e-018         lub=-1.6630382e-26+dlubp_lvt
+ wub=-1.3467442e-025       pub=3.921558e-33+dpubp_lvt
+ uc=-7.3829593e-012+ducp_lvt                         luc=5.1823164e-018
+ wuc=-2.908958e-019        puc=-7.0479504e-025       vsat=88638+dvsatp_lvt
+ a0=6.8037681+da0p_lvt     kvsat=1                   la0=-5.5869253e-007+dla0p_lvt
+ wa0=-6.963423e-007+dwa0p_lvt                        pa0=6.8400529e-014+dpa0p_lvt
+ ags=2.0486912+dagsp_lvt   lags=5.8104721e-007+dlagsp_lvt
+ wags=4.970906e-007+dwagsp_lvt                       pags=-1.1066345e-013+dpagsp_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.079307507+dketap_lvt
+ lketa=1.1836577e-009+dlketap_lvt                    wketa=-1.4210729e-009+dwketap_lvt
+ pketa=1.1146392e-015+dpketap_lvt                    dwg=0
+ dwb=0                     pclm=0.14273646+dpclmp_lvt
+ lpclm=-8.0165683e-009+dlpclmp_lvt                   wpclm=-4.2044959e-009+dwpclmp_lvt
+ ppclm=1.4959004e-015+dppclmp_lvt                    pdiblc1=0
+ pdiblc2=0.0072140051      lpdiblc2=-5.7055024e-010  wpdiblc2=-6.2169761e-010
+ ppdiblc2=1.4678199e-016   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.96
+ pditsd=0.8613             pditsl=350000             rsh=15.5
+ rsw=110+drdswp_lvt        rdw=110+drdswp_lvt        prwg=0
+ prwb=0                    wr=1                      alpha0=6.33e-009
+ alpha1=0.017727           beta0=14.154              agidl=1e-008
+ bgidl=3e+009              cgidl=0.225               egidl=0.8
+ aigbacc=0.013008          bigbacc=0.0062797         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0065469            bigc=0.000931576          cigc=0
+ aigsd=0.0049844           bigsd=0.000394153         cigsd=0.039059
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_lvt             cgdo=cgop_lvt             cgbo=0
+ cgdl=cglp_lvt             cgsl=cglp_lvt             clc=1e-007
+ cle=0.6                   cf=cfp_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=6.8311
+ noff=3.1615               voffcv=-0.16125           kt1=-0.25965253
+ lkt1=-2.575758e-009+dlkt1p_lvt                      wkt1=-2.1079674e-009+dwkt1p_lvt
+ pkt1=4.0087284e-016+dpkt1p_lvt                      kt1l=0
+ kt2=-0.077995833          lkt2=1.2727756e-009       wkt2=3.9178892e-009
+ pkt2=-3.5356049e-016      ute=-1                    ua1=6.5892277e-009
+ lua1=-3.4297123e-016      wua1=-6.4398703e-018      pua1=1.3897884e-024
+ ub1=-9.6449434e-018       lub1=5.9111841e-025       wub1=-1.0767933e-025
+ pub1=3.1377481e-033       uc1=3.0291737e-011+duc1p_lvt
+ luc1=-2.7483397e-018      wuc1=7.5124718e-018       puc1=-7.0915946e-026
+ prt=0                     at=178386.2               lat=-0.0090623339+dlatp_lvt
+ wat=-0.012151106+dwatp_lvt                          pat=5.3864905e-010+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0127             pku0we=1.1e-17
+ wku0we=-4.5e-10           lku0we=-0.3e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap_lvt            rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_lvt            rnoib=0                   noic=noicp_lvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     25: type=p 
+ lmin=6e-08                lmax=9.99969e-008-(dxlp_lvt+dlmisp_lvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_lvt+dwmisp_lvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_lvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_lvt+toxmisp_lvt)
+ toxm=2.2e-009             dtox=3.685e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_lvt+dlmisp_lvt)                  xw=1.6e-08+(dxwp_lvt+dwmisp_lvt)
+ dlc=1.25625e-09+ddlcp_lvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.196+(dvthp_lvt+vthmisp_lvt)-0.0107235*ff_flag_lvt
+ k1=0.12944                kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.33e-8           k2=0.045288622+dk2p_lvt+0.00435394*ff_flag_lvt-0.00348315*ss_flag_lvt
+ lk2=-9.7023273e-010+dlk2p_lvt-3.56936e-10*ff_flag_lvt+2.85549e-10*ss_flag_lvt
+ wk2=-6.974927e-009+dwk2p_lvt-1.37584e-09*ff_flag_lvt+1.10068e-09*ss_flag_lvt
+ pk2=3.9216968e-016+dpk2p_lvt+1.12792e-16*ff_flag_lvt-9.02333e-17*ss_flag_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00080636172-0.0020233*ff_flag_lvt-0.00161864*sf_flag_lvt+0.00161864*fs_flag_lvt
+ lcit=4.9040618e-010+dlcitp_lvt+1.6587e-10*ff_flag_lvt+1.32696e-10*sf_flag_lvt-1.32696e-10*fs_flag_lvt
+ wcit=4.2513019e-010+dwcitp_lvt+2.75169e-10*ff_flag_lvt+2.20135e-10*sf_flag_lvt-2.20135e-10*fs_flag_lvt
+ pcit=-4.8773372e-017+dpcitp_lvt-2.25583e-17*ff_flag_lvt-1.80467e-17*sf_flag_lvt+1.80467e-17*fs_flag_lvt
+ voff=-0.11868198+dvoffp_lvt                         lvoff=-7.1930206e-010+dlvoffp_lvt
+ wvoff=2.8153744e-009+dwvoffp_lvt                    pvoff=-6.8404774e-017+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.24511111+deta0p_lvt-0.0489639*ff_flag_lvt+0.0519988*ss_flag_lvt
+ weta0=-4.7751111e-009+dweta0p_lvt+6.65909e-09*ff_flag_lvt-7.07184e-09*ss_flag_lvt
+ etab=-0.50255035+0.0069663*ff_flag_lvt              letab=1.9847842e-008-5.71097e-10*ff_flag_lvt
+ wetab=4.080917e-008-2.20135e-09*ff_flag_lvt         petab=-1.7796814e-015+1.80467e-16*ff_flag_lvt
+ u0=0.013485222+du0p_lvt   ku0=-0.5354e-9            pku0=2e-16
+ wku0=0e-7                 lku0=-4.0055e-8           lu0=-1.3957984e-010+dlu0p_lvt
+ wu0=-1.7926179e-010+dwu0p_lvt                       pu0=6.4525509e-018+dpu0p_lvt
+ ua=6.3727238e-010         lua=-1.4114805e-17+dluap_lvt
+ wua=-8.5485969e-017       pua=1.9095926e-24+dpuap_lvt
+ ub=1.3415957e-018         lub=4.9672152e-27+dlubp_lvt
+ wub=-6.7732831e-026       pub=-1.5663138e-33+dpubp_lvt
+ uc=5.5831409e-011+ducp_lvt                          luc=2.421196e-024
+ wuc=-8.8880501e-018       puc=-3.2928266e-031       vsat=104478+dvsatp_lvt+2023.3*ff_flag_lvt-4046.6*ss_flag_lvt
+ kvsat=1                   lvsat=-0.0012985634+dlvsatp_lvt-0.00016587*ff_flag_lvt+0.00033174*ss_flag_lvt
+ wvsat=-0.0014875031+dwvsatp_lvt-0.000275169*ff_flag_lvt+0.000550338*ss_flag_lvt
+ pvsat=1.219455e-010+dpvsatp_lvt+2.25584e-11*ff_flag_lvt-4.51167e-11*ss_flag_lvt
+ a0=1.8188806+da0p_lvt     la0=-1.5003145e-007+dla0p_lvt
+ wa0=-1.1492846e-006+dwa0p_lvt                       pa0=1.0553274e-013+dpa0p_lvt
+ ags=19.150389+dagsp_lvt-6.27223*ff_flag_lvt-4.0466*ss_flag_lvt-0.161864*sf_flag_lvt+0.161864*fs_flag_lvt
+ lags=-8.2094994e-007+dlagsp_lvt+5.14197e-07*ff_flag_lvt+3.3174e-07*ss_flag_lvt+1.32696e-08*sf_flag_lvt-1.32696e-08*fs_flag_lvt
+ wags=-1.8577585e-006+dwagsp_lvt+8.53024e-07*ff_flag_lvt+5.50338e-07*ss_flag_lvt+2.20135e-08*sf_flag_lvt-2.20135e-08*fs_flag_lvt
+ pags=8.2387085e-014+dpagsp_lvt-6.99308e-14*ff_flag_lvt-4.51167e-14*ss_flag_lvt-1.80467e-15*sf_flag_lvt+1.80467e-15*fs_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.175055+dketap_lvt lketa=9.0330371e-009+dlketap_lvt
+ wketa=3.2438945e-008+dwketap_lvt                    pketa=-1.6612051e-015+dpketap_lvt
+ dwg=0                     dwb=0                     pclm=0.083301948+dpclmp_lvt+0.0595977*ff_flag_lvt-0.0477653*ss_flag_lvt+0.0347291*sf_flag_lvt-0.0347291*fs_flag_lvt
+ lpclm=-3.1441269e-009+dlpclmp_lvt-4.88582e-09*ff_flag_lvt+3.91579e-09*ss_flag_lvt-2.84709e-09*sf_flag_lvt+2.84709e-09*fs_flag_lvt
+ wpclm=1.3530837e-008+dwpclmp_lvt-1.04564e-08*ff_flag_lvt+9.63091e-09*ss_flag_lvt-6.60406e-09*sf_flag_lvt+6.60406e-09*fs_flag_lvt
+ ppclm=4.1957743e-017+dppclmp_lvt+8.57217e-16*ff_flag_lvt-7.89542e-16*ss_flag_lvt+5.414e-16*sf_flag_lvt-5.414e-16*fs_flag_lvt
+ pdiblc1=0                 pdiblc2=-0.0026378837     lpdiblc2=2.371076e-010
+ wpdiblc2=2.0369454e-009   ppdiblc2=-7.117356e-017   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.24217817           lkt1=-4.0083064e-009+dlkt1p_lvt
+ wkt1=-3.909947e-009+dwkt1p_lvt                      pkt1=5.4859912e-016+dpkt1p_lvt
+ kt1l=0                    kt2=-0.10871916+0.0069663*sf_flag_lvt
+ lkt2=3.7914739e-009-5.71097e-10*sf_flag_lvt         wkt2=7.4034525e-009-2.20135e-09*sf_flag_lvt
+ pkt2=-6.3930697e-016+1.80467e-16*sf_flag_lvt        ute=-1
+ ua1=2.2273517e-009        lua1=1.4615361e-017       wua1=7.040144e-017
+ pua1=-4.9096622e-024      ub1=-1.8991901e-018       lub1=-4.3878442e-026
+ wub1=-1.3360643e-025      pub1=5.2632525e-033       uc1=8.9688767e-011+duc1p_lvt
+ luc1=-7.6177082e-018      wuc1=-1.6518476e-017      puc1=1.8991411e-024
+ prt=0                     at=100232.54              lat=-0.0026552964+dlatp_lvt
+ wat=-0.0082396924+dwatp_lvt                         pat=2.1799139e-010+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt+8.79112e-10*ff_flag_lvt          wvth0=0+dwvthp_lvt+1.4584e-09*ff_flag_lvt
+ pvth0=0+dpvthp_lvt-1.19559e-16*ff_flag_lvt          lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt+4.01406e-09*ff_flag_lvt-4.26286e-09*ss_flag_lvt
+ peta0=0+dpeta0p_lvt-5.45912e-16*ff_flag_lvt+5.79749e-16*ss_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_lvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_lvt            rnoib=0
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
     } 
ends pch_lvt_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                      1.0V DEVICE MODELS                    
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch_lvt bsim4  { 
     1: type=n 
+ lmin=9.999977e-006-dxln_lvt                         lmax=2.00001e-05
+ wmin=1e-005-dxwn_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13060648+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ k1=0.14382                k2=0.035830827+dk2n_lvt   k3=-1.8449512
+ k3b=1.4703914             w0=0                      dvt0=0.68502703
+ dvt1=0.55390526           dvt2=0.28043048           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.51219786
+ minv=-0.16                voffl=0                   dvtp0=2.3021105e-006
+ dvtp1=4.6632516           lpe0=9.588928e-008        lpeb=4.9314511e-008
+ xj=1.1e-007               ngate=8.131e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.001
+ voff=-0.13                nfactor=0.8+dnfactorn_lvt eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.06087679+du0n_lvt    ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ ua=-1.8612873e-010        ub=3e-018                 uc=2e-010
+ pub=0+dpubn_lvt           lub=0+dlubn_lvt           pua=0+dpuan_lvt
+ lua=0+dluan_lvt           vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=2                      ags=0.99550247+dagsn_lvt  a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.07435             dwg=0                     dwb=0
+ pclm=0.81422667+dpclmn_lvt                          pdiblc1=0
+ pdiblc2=0.01              pdiblcb=-0.037159959      drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.70129737
+ pditsd=0.6367075          pditsl=977352.75          rsh=16
+ rsw=45+drdswn_lvt         rdw=45+drdswn_lvt         prwg=0
+ prwb=0                    wr=1                      alpha0=9.96e-008
+ alpha1=1.252              beta0=13.29               agidl=1.7376647e-008
+ bgidl=1.3887812e+009      cgidl=1.4802648           egidl=0.81976
+ aigbacc=0.012866428       bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010985             bigc=0.0016755            cigc=0
+ aigsd=0.009264            bigsd=0.001144168         cigsd=0.087095398
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_lvt             cgdo=cgon_lvt             cgbo=0
+ cgdl=cgln_lvt             cgsl=cgln_lvt             clc=1e-007
+ cle=0.6                   cf=cfn_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=10.65
+ noff=2.526                voffcv=-0.19263           kt1=-0.26688901
+ kt1l=0                    kt2=-0.038763119          ute=-1
+ ua1=5e-009                ub1=-1.3578661e-018       uc1=4.868748e-011
+ prt=0                     at=200000+datn_lvt        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ wvth0=0+dwvthn_lvt        pvth0=0+dpvthn_lvt        lk2=0+dlk2n_lvt
+ wk2=0+dwk2n_lvt           pk2=0+dpk2n_lvt           lcit=0+dlcitn_lvt
+ wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt       lu0=0+dlu0n_lvt
+ wu0=0+dwu0n_lvt           pu0=0+dpu0n_lvt           lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       lags=0+dlagsn_lvt
+ ppclm=0+dppclmn_lvt       la0=0+dla0n_lvt           wa0=0+dwa0n_lvt
+ pa0=0+dpa0n_lvt           lat=0+dlatn_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           lkt1=0+dlkt1n_lvt         wkt1=0+dwkt1n_lvt
+ pkt1=0+dpkt1n_lvt         pags=0+dpagsn_lvt         wags=0+dwagsn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     2: type=n 
+ lmin=9.999773e-007-dxln_lvt                         lmax=9.999977e-006-dxln_lvt
+ wmin=1e-005-dxwn_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.12983081+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=7.7133462e-009+dlvthn_lvt                     k1=0.14382
+ k2=0.03602401+dk2n_lvt    lk2=-1.9210513e-009+dlk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.1299727           lvoff=-2.7150557e-010
+ nfactor=0.77901778+dnfactorn_lvt                    lnfactor=2.0865141e-007+dlnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.061805464+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-9.2349277e-009+dlu0n_lvt
+ ua=-1.8014301e-010        pua=0+dpuan_lvt           lua=-5.9523179e-17+dluan_lvt
+ ub=3.0020502e-018         pub=0+dpubn_lvt           lub=-2.038758e-26+dlubn_lvt
+ uc=2e-010                 vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=1.8281959              la0=1.7084542e-006+dla0n_lvt
+ ags=0.9067164+dagsn_lvt   lags=8.8290637e-007+dlagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.07165903          lketa=-2.6759544e-008
+ dwg=0                     dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.010524556       lpdiblc2=-5.2162854e-009
+ pdiblcb=-0.037159959      drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.70129737          pditsd=0.6367075
+ pditsl=977352.75          rsh=16                    rsw=45+drdswn_lvt
+ rdw=45+drdswn_lvt         prwg=0                    prwb=0
+ wr=1                      alpha0=9.96e-008          alpha1=1.252
+ beta0=13.29               agidl=1.7376647e-008      bgidl=1.3887812e+009
+ cgidl=1.4802648           egidl=0.81976             aigbacc=0.012866428
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010985
+ bigc=0.0016755            cigc=0                    aigsd=0.009264
+ bigsd=0.001144168         cigsd=0.087095398         nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_lvt
+ cgdo=cgon_lvt             cgbo=0                    cgdl=cgln_lvt
+ cgsl=cgln_lvt             clc=1e-007                cle=0.6
+ cf=cfn_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=10.65                noff=2.526
+ voffcv=-0.19263           kt1=-0.26162018           lkt1=-5.2394299e-008+dlkt1n_lvt
+ kt1l=0                    kt2=-0.038213797          lkt2=-5.4625689e-009
+ ute=-1                    ua1=5.035311e-009         lua1=-3.5113946e-016
+ ub1=-1.2113584e-018       lub1=-1.4569021e-024      uc1=4.868748e-011
+ prt=0                     at=202077.24+datn_lvt     lat=-0.02065649+dlatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ wvth0=0+dwvthn_lvt        pvth0=0+dpvthn_lvt        wk2=0+dwk2n_lvt
+ pk2=0+dpk2n_lvt           lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt
+ wu0=0+dwu0n_lvt           pu0=0+dpu0n_lvt           lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       ppclm=0+dppclmn_lvt
+ wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           wkt1=0+dwkt1n_lvt         pkt1=0+dpkt1n_lvt
+ pags=0+dpagsn_lvt         wags=0+dwagsn_lvt         saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     3: type=n 
+ lmin=2.399969e-007-dxln_lvt                         lmax=9.999773e-007-dxln_lvt
+ wmin=1e-005-dxwn_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=3.259685e-09+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13657635+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=1.3442138e-009+dlvthn_lvt                     k1=0.14382
+ k2=0.035612678+dk2n_lvt   lk2=-1.5326723e-009+dlk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.12842223          lvoff=-1.7354595e-009
+ nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.052694396+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-6.3225688e-010+dlu0n_lvt                       ua=-1.9277264e-010
+ pua=0+dpuan_lvt           lua=-4.7598284e-17+dluan_lvt
+ ub=3.1064417e-018         pub=0+dpubn_lvt           lub=-1.1895403e-25+dlubn_lvt
+ uc=2.0581506e-010         luc=-5.4905755e-018       vsat=95273.906+dvsatn_lvt
+ kvsat=1                   a0=4.155215               la0=-4.8871723e-007+dla0n_lvt
+ ags=2.1139597+dagsn_lvt   lags=-2.5697271e-007+dlagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.1085526           lketa=8.0753642e-009
+ dwg=0                     dwb=0                     pclm=1.0175889+dpclmn_lvt
+ lpclm=-1.9201466e-007     pdiblc1=0                 pdiblc2=0.0034112025
+ lpdiblc2=1.5001426e-009   pdiblcb=-0.037159959      drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.70129737
+ pditsd=0.6367075          pditsl=977352.75          rsh=16
+ rsw=45+drdswn_lvt         rdw=45+drdswn_lvt         prwg=0
+ prwb=0                    wr=1                      alpha0=9.96e-008
+ alpha1=1.252              beta0=13.29               agidl=1.7376647e-008
+ bgidl=1.3887812e+009      cgidl=1.4802648           egidl=0.81976
+ aigbacc=0.012866428       bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010985             bigc=0.0016755            cigc=0
+ aigsd=0.009264            bigsd=0.001144168         cigsd=0.087095398
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_lvt             cgdo=cgon_lvt             cgbo=0
+ cgdl=cgln_lvt             cgsl=cgln_lvt             clc=1e-007
+ cle=0.6                   cf=cfn_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=10.65
+ noff=2.526                voffcv=-0.19263           kt1=-0.31255958
+ lkt1=-4.2973159e-009+dlkt1n_lvt                     kt1l=0
+ kt2=-0.04248448           lkt2=-1.43019e-009        ute=-1
+ ua1=3.9981239e-009        lua1=6.281726e-016        ub1=-1.3676591e-018
+ lub1=-1.309323e-024       uc1=4.868748e-011         prt=0
+ at=228703.09+datn_lvt     lat=-0.045796621+dlatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ wvth0=0+dwvthn_lvt        pvth0=0+dpvthn_lvt        wk2=0+dwk2n_lvt
+ pk2=0+dpk2n_lvt           lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt
+ pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt
+ peta0=0+dpeta0n_lvt       wu0=0+dwu0n_lvt           pu0=0+dpu0n_lvt
+ lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt
+ ppclm=0+dppclmn_lvt       wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt
+ wat=0+dwatn_lvt           pat=0+dpatn_lvt           wkt1=0+dwkt1n_lvt
+ pkt1=0+dpkt1n_lvt         pags=0+dpagsn_lvt         wags=0+dwagsn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     4: type=n 
+ lmin=9.998929e-008-dxln_lvt                         lmax=2.399969e-007-dxln_lvt
+ wmin=1e-005-dxwn_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.143+dvthn_lvt      k1=0.14382                kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ k2=0.014486529+dk2n_lvt   lk2=2.8881857e-009+dlk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00010706           lcit=2.3166338e-010+dlcitn_lvt
+ voff=-0.12481824          lvoff=-2.48963e-009       nfactor=1+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.056183067+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-1.3622962e-009+dlu0n_lvt
+ ua=-1.0771852e-010        pua=0+dpuan_lvt           lua=-6.5396708e-17+dluan_lvt
+ ub=2.4791052e-018         pub=0+dpubn_lvt           lub=1.23224e-26+dlubn_lvt
+ uc=1.6740109e-010         luc=2.5479307e-018        vsat=95273.906+dvsatn_lvt
+ kvsat=1                   a0=1.7446737              la0=1.5712641e-008+dla0n_lvt
+ ags=0.36079396+dagsn_lvt  lags=1.0989474e-007+dlagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.052054559         lketa=-3.7474156e-009
+ dwg=0                     dwb=0                     pclm=0.1+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.013906719       lpdiblc2=-6.9614912e-010
+ pdiblcb=-0.037159959      drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.70129737          pditsd=0.6367075
+ pditsl=977352.75          rsh=16                    rsw=45+drdswn_lvt
+ rdw=45+drdswn_lvt         prwg=0                    prwb=0
+ wr=1                      alpha0=9.96e-008          alpha1=1.252
+ beta0=13.29               agidl=1.7376647e-008      bgidl=1.3887812e+009
+ cgidl=1.4802648           egidl=0.81976             aigbacc=0.012866428
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010985
+ bigc=0.0016755            cigc=0                    aigsd=0.009264
+ bigsd=0.001144168         cigsd=0.087095398         nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_lvt
+ cgdo=cgon_lvt             cgbo=0                    cgdl=cgln_lvt
+ cgsl=cgln_lvt             clc=1e-007                cle=0.6
+ cf=cfn_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=10.65                noff=2.526
+ voffcv=-0.19263           kt1=-0.3196317            lkt1=-2.8174053e-009+dlkt1n_lvt
+ kt1l=0                    kt2=-0.043438332          lkt2=-1.2305869e-009
+ ute=-1                    ua1=7.2980931e-009        lua1=-6.2378953e-017
+ ub1=-8.4236472e-018       lub1=1.6721309e-025       uc1=-1.1425765e-010
+ luc1=3.4097898e-017       prt=0                     at=9431.916+datn_lvt
+ lat=8.8065396e-005+dlatn_lvt                        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ wvth0=0+dwvthn_lvt        pvth0=0+dpvthn_lvt        wk2=0+dwk2n_lvt
+ pk2=0+dpk2n_lvt           wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt
+ wu0=0+dwu0n_lvt           pu0=0+dpu0n_lvt           lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       ppclm=0+dppclmn_lvt
+ wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           wkt1=0+dwkt1n_lvt         pkt1=0+dpkt1n_lvt
+ pags=0+dpagsn_lvt         wags=0+dwagsn_lvt         saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     5: type=n 
+ lmin=6e-08                lmax=9.998929e-008-dxln_lvt
+ wmin=1e-005-dxwn_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.14426157+dvthn_lvt+0.000330957*ff_flag_lvt   kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=-9.8604318e-011+dlvthn_lvt-2.58675e-11*ff_flag_lvt
+ k1=0.14382                k2=0.089728503+dk2n_lvt   lk2=-2.992727e-009+dlk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00093002598        lcit=2.959864e-010+dlcitn_lvt
+ voff=-0.13111126          lvoff=-1.9977677e-009     nfactor=1+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.11348087
+ letab=3.3135583e-009      u0=0.042335662+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-2.7998306e-010+dlu0n_lvt                       ua=-1.5613605e-009
+ pua=0+dpuan_lvt           lua=4.8219951e-17+dluan_lvt
+ ub=3.1115806e-018         pub=0+dpubn_lvt           lub=-3.7111877e-26+dlubn_lvt
+ uc=2e-010                 vsat=84246.202+dvsatn_lvt kvsat=1
+ lvsat=0.00086192534+dlvsatn_lvt                     a0=3.7754708
+ la0=-1.4301446e-007+dla0n_lvt                       ags=1.7668168+dagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.27902282          lketa=1.3992424e-008
+ dwg=0                     dwb=0                     pclm=0.021299874+dpclmn_lvt
+ lpclm=6.1512019e-009      pdiblc1=0                 pdiblc2=-0.00051385526
+ lpdiblc2=4.3096293e-010   pdiblcb=-0.037159959      drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.70129737
+ pditsd=0.6367075          pditsl=977352.75          rsh=16
+ rsw=45+drdswn_lvt         rdw=45+drdswn_lvt         prwg=0
+ prwb=0                    wr=1                      alpha0=9.96e-008
+ alpha1=1.252              beta0=13.29               agidl=1.7376647e-008
+ bgidl=1.3887812e+009      cgidl=1.4802648           egidl=0.81976
+ aigbacc=0.012866428       bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010985             bigc=0.0016755            cigc=0
+ aigsd=0.009264            bigsd=0.001144168         cigsd=0.087095398
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_lvt             cgdo=cgon_lvt             cgbo=0
+ cgdl=cgln_lvt             cgsl=cgln_lvt             clc=1e-007
+ cle=0.6                   cf=cfn_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=10.65
+ noff=2.526                voffcv=-0.19263           kt1=-0.3355631
+ lkt1=-1.5722071e-009+dlkt1n_lvt                     kt1l=0
+ kt2=-0.063338245          lkt2=3.2479027e-010       ute=-1
+ ua1=9.1292929e-009        lua1=-2.0550553e-016      ub1=-1.0307919e-017
+ lub1=3.1448779e-025       uc1=1.1353437e-010        luc1=1.6293674e-017
+ prt=0                     at=-2844.4718+datn_lvt    lat=0.0010475879+dlatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ wvth0=0+dwvthn_lvt+0.0*ff_flag_lvt                  pvth0=0+dpvthn_lvt+0.0*ff_flag_lvt
+ wk2=0+dwk2n_lvt           pk2=0+dpk2n_lvt           wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt
+ pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt
+ peta0=0+dpeta0n_lvt       wu0=0+dwu0n_lvt           pu0=0+dpu0n_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       lags=0+dlagsn_lvt
+ ppclm=0+dppclmn_lvt       wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt
+ wat=0+dwatn_lvt           pat=0+dpatn_lvt           wkt1=0+dwkt1n_lvt
+ pkt1=0+dpkt1n_lvt         pags=0+dpagsn_lvt         wags=0+dwagsn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     6: type=n 
+ lmin=9.999977e-006-dxln_lvt                         lmax=2.00001e-05
+ wmin=1e-006-dxwn_lvt      wmax=1e-005-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13083913+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ wvth0=-2.3302676e-009+dwvthn_lvt                    k1=0.14382
+ k2=0.035097703+dk2n_lvt   wk2=7.3429632e-009+dwk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.13                nfactor=0.8+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.061957635+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               wu0=-1.0825746e-008+dwu0n_lvt
+ ua=-1.4681957e-010        wua=-3.9372051e-016       ub=3.0032267e-018
+ pub=0+dpubn_lvt           lub=0+dlubn_lvt           pua=0+dpuan_lvt
+ lua=0+dluan_lvt           wub=-3.2318568e-026       uc=2.0242481e-010
+ wuc=-2.428685e-017        vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=2                      ags=0.999151+dagsn_lvt-0.0225778*ss_flag_lvt+1.1e-08*ff_flag_lvt
+ wags=-3.6543755e-008+dwagsn_lvt+2.26139e-07*ss_flag_lvt-4.9e-13*ff_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.0714544           wketa=-2.900233e-008
+ dwg=0                     dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.0098511023      wpdiblc2=1.4913597e-009
+ pdiblcb=-0.037159959      drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.70129737          pditsd=0.6367075
+ pditsl=977352.75          rsh=16                    rsw=45+drdswn_lvt
+ rdw=45+drdswn_lvt         prwg=0                    prwb=0
+ wr=1                      alpha0=9.96e-008          alpha1=1.252
+ beta0=13.29               agidl=1.7376647e-008      bgidl=1.3887812e+009
+ cgidl=1.4802648           egidl=0.81976             aigbacc=0.012866428
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010985
+ bigc=0.0016755            cigc=0                    aigsd=0.009264
+ bigsd=0.001144168         cigsd=0.087095398         nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_lvt
+ cgdo=cgon_lvt             cgbo=0                    cgdl=cgln_lvt
+ cgsl=cgln_lvt             clc=1e-007                cle=0.6
+ cf=cfn_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=10.65                noff=2.526
+ voffcv=-0.19263           kt1=-0.2663211            wkt1=-5.6881528e-009+dwkt1n_lvt
+ kt1l=0                    kt2=-0.038526122          wkt2=-2.3737598e-009
+ ute=-1                    ua1=5.1128889e-009        wua1=-1.1306951e-015
+ ub1=-1.4232168e-018       wub1=6.5455274e-025       uc1=4.868748e-011
+ prt=0                     at=200000+datn_lvt        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ pvth0=0+dpvthn_lvt        lk2=0+dlk2n_lvt           pk2=0+dpk2n_lvt
+ lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt
+ lu0=0+dlu0n_lvt           pu0=0+dpu0n_lvt           lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       lags=0+dlagsn_lvt+0.0*ss_flag_lvt+0.0*ff_flag_lvt
+ ppclm=0+dppclmn_lvt       la0=0+dla0n_lvt           wa0=0+dwa0n_lvt
+ pa0=0+dpa0n_lvt           lat=0+dlatn_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           lkt1=0+dlkt1n_lvt         pkt1=0+dpkt1n_lvt
+ pags=0+dpagsn_lvt+0.0*ss_flag_lvt+0.0*ff_flag_lvt   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     7: type=n 
+ lmin=9.999773e-007-dxln_lvt                         lmax=9.999977e-006-dxln_lvt
+ wmin=1e-006-dxwn_lvt      wmax=1e-005-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13009972+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=7.3528556e-009+dlvthn_lvt                     wvth0=-2.6933611e-009+dwvthn_lvt
+ pvth0=3.6106739e-015+dpvthn_lvt                     k1=0.14382
+ k2=0.035232645+dk2n_lvt   lk2=-1.3418866e-009+dlk2n_lvt
+ wk2=7.9263097e-009+dwk2n_lvt                        pk2=-5.8009134e-015+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.12995184          lvoff=-4.7894375e-010
+ wvoff=-2.0893594e-010     pvoff=2.0777008e-015      nfactor=0.77901778+dnfactorn_lvt
+ lnfactor=2.0865141e-007+dlnfactorn_lvt              eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.062985271+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-1.0219015e-008+dlu0n_lvt                       wu0=-1.1816939e-008+dwu0n_lvt
+ pu0=9.856621e-015+dpu0n_lvt                         ua=-1.3765428e-010
+ lua=-9.1141466e-17+dluan_lvt                        wua=-4.2556709e-016
+ pua=3.1668876e-22+dpuan_lvt                         ub=3.0054331e-018
+ lub=-2.1941051e-26+dlubn_lvt                        wub=-3.3883255e-026
+ pub=1.5559565e-32+dpubn_lvt                         uc=2.0267919e-010
+ luc=-2.5296953e-018       wuc=-2.6834811e-017       puc=2.5337428e-023
+ vsat=95273.906+dvsatn_lvt kvsat=1                   a0=1.8281959
+ la0=1.7084542e-006+dla0n_lvt                        ags=0.90893987+dagsn_lvt-0.0261308*ss_flag_lvt+0.00177648*ff_flag_lvt
+ lags=8.970776e-007+dlagsn_lvt+3.53316e-08*ss_flag_lvt-1.76658e-08*ff_flag_lvt
+ wags=-2.2270196e-008+dwagsn_lvt+2.61725e-07*ss_flag_lvt-1.77936e-08*ff_flag_lvt
+ pags=-1.4193913e-013+dpagsn_lvt-3.53882e-13*ss_flag_lvt+1.76941e-13*ff_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.068459649         lketa=-2.9780399e-008
+ wketa=-3.2044996e-008     pketa=3.0256885e-014      dwg=0
+ dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.010360037       lpdiblc2=-5.0609467e-009
+ wpdiblc2=1.6478199e-009   ppdiblc2=-1.5558716e-015  pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.26099648           lkt1=-5.2949094e-008+dlkt1n_lvt
+ wkt1=-6.2469536e-009+dwkt1n_lvt                     pkt1=5.5568262e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.037948983          lkt2=-5.7391858e-009
+ wkt2=-2.652374e-009       pkt2=2.7705949e-015       ute=-1
+ ua1=5.1600432e-009        lua1=-4.689116e-016       wua1=-1.2493176e-015
+ pua1=1.1796057e-021       ub1=-1.2900671e-018       lub1=-1.3240676e-024
+ wub1=7.8834633e-025       pub1=-1.3304703e-030      uc1=4.868748e-011
+ prt=0                     at=202077.24+datn_lvt     lat=-0.02065649+dlatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       ppclm=0+dppclmn_lvt
+ wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.00345
+ pkvth0we=0.2e-17          wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0022             pku0we=-0.65e-17          wku0we=-4.5e-10
+ lku0we=1.55e-10           k2we=0.00077              pk2we=0.025e-17
+ wk2we=-0.2e-10            lk2we=-1.6e-11            fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_lvt            noib=noibn_lvt            noic=noicn_lvt
+ em=1.5e+7                   ef=1                    lintnoi=0
+ minr=1e-3
 
 
     8: type=n 
+ lmin=2.399969e-007-dxln_lvt                         lmax=9.999773e-007-dxln_lvt
+ wmin=1e-006-dxwn_lvt      wmax=1e-005-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=3.259685e-09+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13643131+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=1.3745631e-009+dlvthn_lvt                     wvth0=1.4526388e-009+dwvthn_lvt
+ pvth0=-3.0397919e-016+dpvthn_lvt                    k1=0.14382
+ k2=0.035482309+dk2n_lvt   lk2=-1.5776195e-009+dlk2n_lvt
+ wk2=1.3057789e-009+dwk2n_lvt                        pk2=4.5019168e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.12866683          lvoff=-1.6922507e-009
+ wvoff=2.4499081e-009      pvoff=-4.3277973e-016     nfactor=1+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.052824621+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-6.2533021e-010+dlu0n_lvt
+ wu0=-1.3043369e-009+dwu0n_lvt                       pu0=-6.9377534e-017+dpu0n_lvt
+ ua=-1.7399409e-010        lua=-5.6829415e-17+dluan_lvt
+ wua=-1.8808589e-016       pua=9.245901e-23+dpuan_lvt
+ ub=3.099095e-018          lub=-1.1037665e-25+dlubn_lvt
+ wub=7.3584038e-026        pub=-8.5911053e-32+dpubn_lvt
+ uc=2.0396356e-010         luc=-3.7423917e-018       wuc=1.8544598e-017
+ puc=-1.7509809e-023       vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=4.1497395              la0=-4.8354731e-007+dla0n_lvt
+ wa0=5.4842191e-008+dwa0n_lvt                        pa0=-5.1781997e-014+dpa0n_lvt
+ ags=2.1453019+dagsn_lvt-0.0217548*ff_flag_lvt+0.0145032*ss_flag_lvt
+ lags=-2.702954e-007+dlagsn_lvt+4.5524e-09*ff_flag_lvt-3.03493e-09*ss_flag_lvt
+ wags=-3.1392358e-007+dwagsn_lvt+2.17896e-07*ff_flag_lvt-1.45264e-07*ss_flag_lvt
+ pags=1.3344e-013+dpagsn_lvt-4.55969e-14*ff_flag_lvt+3.03979e-14*ss_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.10880211          lketa=8.3109511e-009
+ wketa=2.4990875e-009      pketa=-2.3596384e-015     dwg=0
+ dwb=0                     pclm=1.0210417+dpclmn_lvt lpclm=-1.9527475e-007
+ wpclm=-3.4582746e-008     ppclm=3.2653029e-014+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=0.003231845       lpdiblc2=1.669492e-009
+ wpdiblc2=1.7964455e-009   ppdiblc2=-1.6962039e-015  pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.31230357           lkt1=-4.5049418e-009+dlkt1n_lvt
+ wkt1=-2.5642115e-009+dwkt1n_lvt                     pkt1=2.0795812e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.042680953          lkt2=-1.2712602e-009
+ wkt2=1.9678722e-009       pkt2=-1.5918416e-015      ute=-1
+ ua1=3.9820524e-009        lua1=6.4334728e-016       wua1=1.6097182e-016
+ pua1=-1.5198959e-022      ub1=-1.2854923e-018       lub1=-1.3283871e-024
+ wub1=-8.229823e-025       pub1=1.9094622e-031       uc1=4.868748e-011
+ prt=0                     at=229184.55+datn_lvt     lat=-0.04625121+dlatn_lvt
+ wat=-0.0048222463+dwatn_lvt                         pat=4.553165e-009+dpatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt
+ lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     9: type=n 
+ lmin=9.998929e-008-dxln_lvt                         lmax=2.399969e-007-dxln_lvt
+ wmin=1e-006-dxwn_lvt      wmax=1e-005-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.143+dvthn_lvt      k1=0.14382                kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ k2=0.014122349+dk2n_lvt   lk2=2.8921657e-009+dlk2n_lvt
+ wk2=3.647627e-009+dwk2n_lvt                         pk2=-3.9863432e-017+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00017725657        lcit=2.4635271e-010+dlcitn_lvt
+ wcit=7.0308885e-010+dwcitn_lvt                      pcit=-1.4712837e-016+dpcitn_lvt
+ voff=-0.12423404          lvoff=-2.6198556e-009     wvoff=-5.8513422e-009
+ pvoff=1.3043399e-015      nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.05644885+du0n_lvt    ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-1.3837364e-009+dlu0n_lvt                       wu0=-2.6620839e-009+dwu0n_lvt
+ pu0=2.1474459e-016+dpu0n_lvt                        ua=-1.2025645e-010
+ lua=-6.8074554e-17+dluan_lvt                        wua=1.2557991e-016
+ pua=2.6821305e-23+dpuan_lvt                         ub=2.4891417e-018
+ lub=1.726218e-26+dlubn_lvt                          wub=-1.0052573e-025
+ pub=-4.9476844e-32+dpubn_lvt                        uc=1.7643303e-010
+ luc=2.0186471e-018        wuc=-9.0463877e-017       puc=5.3013045e-024
+ vsat=95273.906+dvsatn_lvt kvsat=1                   a0=1.7495699
+ la0=1.8712201e-008+dla0n_lvt                        wa0=-4.904006e-008+dwa0n_lvt
+ pa0=-3.0043597e-014+dpa0n_lvt                       ags=0.30919965+dagsn_lvt+0.403815*ff_flag_lvt+0.572071*ss_flag_lvt
+ lags=1.1392735e-007+dlagsn_lvt-8.45023e-08*ff_flag_lvt-1.19712e-07*ss_flag_lvt
+ wags=5.1676852e-007+dwagsn_lvt-4.04461e-06*ff_flag_lvt-5.72986e-06*ss_flag_lvt
+ pags=-4.0390628e-014+dpagsn_lvt+8.46375e-13*ff_flag_lvt+1.19903e-12*ss_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.050474193         lketa=-3.8947485e-009
+ wketa=-1.5828948e-008     pketa=1.4756864e-015      dwg=0
+ dwb=0                     pclm=0.080644056+dpclmn_lvt
+ lpclm=1.5128606e-009      wpclm=1.9386913e-007      ppclm=-1.5152811e-014+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=0.014912188       lpdiblc2=-7.7473662e-010
+ wpdiblc2=-1.0070783e-008  ppdiblc2=7.8713241e-016   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.31762776           lkt1=-3.3908014e-009+dlkt1n_lvt
+ wkt1=-2.0071399e-008+dwkt1n_lvt                     pkt1=5.7431353e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.043020773          lkt2=-1.2001494e-009
+ wkt2=-4.1822769e-009      pkt2=-3.0486136e-016      ute=-1
+ ua1=7.1348429e-009        lua1=-1.6405671e-017      wua1=1.6351131e-015
+ pua1=-4.604684e-022       ub1=-8.1705925e-018       lub1=1.1238896e-025
+ wub1=-2.534596e-024       pub1=5.491185e-031        uc1=-1.1425765e-010
+ luc1=3.4097898e-017       prt=0                     at=8349.9815+datn_lvt
+ lat=-3.936902e-005+dlatn_lvt                        wat=0.010836656+dwatn_lvt
+ pat=1.2763831e-009+dpatn_lvt                        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ wvth0=0+dwvthn_lvt        pvth0=0+dpvthn_lvt        lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     10: type=n 
+ lmin=6e-08                lmax=9.998929e-008-dxln_lvt
+ wmin=1e-006-dxwn_lvt      wmax=1e-005-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.14315908+dvthn_lvt+0.000368318*ff_flag_lvt   kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=-1.2433798e-011+dlvthn_lvt-2.87876e-11*ff_flag_lvt
+ wvth0=1.1042527e-008+dwvthn_lvt-3.74211e-10*ff_flag_lvt
+ pvth0=-8.6308393e-016+dpvthn_lvt+2.92482e-17*ff_flag_lvt
+ k1=0.14382                k2=0.090159398+dk2n_lvt   lk2=-3.0508901e-009+dlk2n_lvt
+ wk2=-4.3158484e-009+dwk2n_lvt                       pk2=5.825618e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00068244002        lcit=2.8583785e-010+dlcitn_lvt
+ wcit=-2.479821e-009+dwcitn_lvt                      pcit=1.0164786e-016+dpcitn_lvt
+ voff=-0.13031116          lvoff=-2.1448676e-009     wvoff=-8.0137358e-009
+ pvoff=1.4733526e-015      nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt-0.00120802*ff_flag_lvt+0.00336252*ss_flag_lvt
+ etab=-0.11325274          letab=3.2957279e-009      wetab=-2.2849165e-009
+ petab=1.7858907e-016      u0=0.04217239+du0n_lvt    ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-2.6788821e-010+dlu0n_lvt                       wu0=1.6353392e-009+dwu0n_lvt
+ pu0=-1.21142e-016+dpu0n_lvt                         ua=-1.614783e-009
+ lua=4.8737637e-17+dluan_lvt                         wua=5.3507899e-016
+ pua=-5.1851432e-24+dpuan_lvt                        ub=3.1770395e-018
+ lub=-3.650391e-26+dlubn_lvt                         wub=-6.5563634e-025
+ pub=-6.0893982e-33+dpubn_lvt                        uc=1.9915048e-010
+ luc=2.4305099e-019        wuc=8.5087831e-018        puc=-2.4343987e-024
+ vsat=84246.202+dvsatn_lvt kvsat=1                   lvsat=0.00086192534+dlvsatn_lvt
+ a0=3.8704272              la0=-1.4705401e-007+dla0n_lvt
+ wa0=-9.5108311e-007+dwa0n_lvt                       pa0=4.0460088e-014+dpa0n_lvt
+ ags=1.7668168+dagsn_lvt-0.988678*ff_flag_lvt-2.39173*ss_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.27917438          lketa=1.3980458e-008
+ wketa=1.5180684e-009      pketa=1.1984353e-016      dwg=0
+ dwb=0                     pclm=0.010054598+dpclmn_lvt+0.00448336*ff_flag_lvt-0.0112084*ss_flag_lvt
+ lpclm=7.0301326e-009-3.50418e-10*ff_flag_lvt+8.76046e-10*ss_flag_lvt
+ wpclm=1.1263268e-007-4.49053e-08*ff_flag_lvt+1.12263e-07*ss_flag_lvt
+ ppclm=-8.8033704e-015+dppclmn_lvt+3.50979e-15*ff_flag_lvt-8.77447e-15*ss_flag_lvt
+ pdiblc1=0                 pdiblc2=0.00020529191     lpdiblc2=3.7475438e-010
+ wpdiblc2=-7.2029781e-009  ppdiblc2=5.6298476e-016   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.34596869           lkt1=-1.1756748e-009+dlkt1n_lvt
+ wkt1=1.0422238e-007+dwkt1n_lvt                      pkt1=-3.9716667e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.0623381            lkt2=3.0969283e-010
+ wkt2=-1.0017452e-008      pkt2=1.5121596e-016       ute=-1
+ ua1=9.829536e-009         lua1=-2.2702288e-016      wua1=-7.0136344e-015
+ pua1=2.1551771e-022       ub1=-1.115525e-017        lub1=3.456698e-025
+ wub1=8.4868663e-024       pub1=-3.1231899e-031      uc1=1.1353437e-010
+ luc1=1.6293674e-017       prt=0                     at=-5707.8374+datn_lvt
+ lat=0.0010593901+dlatn_lvt                          wat=0.02867947+dwatn_lvt
+ pat=-1.1821127e-010+dpatn_lvt                       jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt+9.44183e-11*ff_flag_lvt-2.62814e-10*ss_flag_lvt
+ weta0=0+dweta0n_lvt+1.20995e-08*ff_flag_lvt-3.3679e-08*ss_flag_lvt
+ peta0=0+dpeta0n_lvt-9.45693e-16*ff_flag_lvt+2.63234e-15*ss_flag_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       lags=0+dlagsn_lvt+2.43347e-08*ff_flag_lvt+1.11939e-07*ss_flag_lvt
+ pags=0+dpagsn_lvt-2.43735e-13*ff_flag_lvt-1.12118e-12*ss_flag_lvt
+ wags=0+dwagsn_lvt+9.90259e-06*ff_flag_lvt+2.39556e-05*ss_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     11: type=n 
+ lmin=9.999977e-006-dxln_lvt                         lmax=2.00001e-05
+ wmin=6e-007-dxwn_lvt      wmax=1e-006-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.12673976+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ wvth0=1.8346969e-009+dwvthn_lvt                     k1=0.14382
+ k2=0.040288492+dk2n_lvt   wk2=2.069122e-009+dwk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.13                nfactor=0.8+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.048704508+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               wu0=2.6394308e-009+dwu0n_lvt
+ ua=-7.9372864e-010        wua=2.6353911e-016        ub=2.9574944e-018
+ pub=0+dpubn_lvt           lub=0+dlubn_lvt           pua=0+dpuan_lvt
+ lua=0+dluan_lvt           wub=1.414541e-026         uc=1.4544188e-010
+ wuc=3.3607802e-017        vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=2                      ags=0.87212419+dagsn_lvt+0.508*ss_flag_lvt+0.0*ff_flag_lvt
+ wags=9.2515486e-008+dwagsn_lvt-3.12928e-07*ss_flag_lvt+0.0*ff_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.1                 dwg=0
+ dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.013748258       wpdiblc2=-2.4681508e-009
+ pdiblcb=-0.037159959      drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.70129737          pditsd=0.6367075
+ pditsl=977352.75          rsh=16                    rsw=45+drdswn_lvt
+ rdw=45+drdswn_lvt         prwg=0                    prwb=0
+ wr=1                      alpha0=9.96e-008          alpha1=1.252
+ beta0=13.29               agidl=1.7376647e-008      bgidl=1.3887812e+009
+ cgidl=1.4802648           egidl=0.81976             aigbacc=0.012866428
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010985
+ bigc=0.0016755            cigc=0                    aigsd=0.009264
+ bigsd=0.001144168         cigsd=0.087095398         nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_lvt
+ cgdo=cgon_lvt             cgbo=0                    cgdl=cgln_lvt
+ cgsl=cgln_lvt             clc=1e-007                cle=0.6
+ cf=cfn_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=10.65                noff=2.526
+ voffcv=-0.19263           kt1=-0.27488258           wkt1=3.0103048e-009+dwkt1n_lvt
+ kt1l=0                    kt2=-0.032940099          wkt2=-8.0491591e-009
+ ute=-1                    ua1=3.23e-009             wua1=7.8232e-016
+ ub1=3.5418966e-019        wub1=-1.1512923e-024      uc1=4.868748e-011
+ prt=0                     at=200000+datn_lvt        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ pvth0=0+dpvthn_lvt        lk2=0+dlk2n_lvt           pk2=0+dpk2n_lvt
+ lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt
+ lu0=0+dlu0n_lvt           pu0=0+dpu0n_lvt           lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       lags=0+dlagsn_lvt+0.0*ss_flag_lvt+0.0*ff_flag_lvt
+ ppclm=0+dppclmn_lvt       la0=0+dla0n_lvt           wa0=0+dwa0n_lvt
+ pa0=0+dpa0n_lvt           lat=0+dlatn_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           lkt1=0+dlkt1n_lvt         pkt1=0+dpkt1n_lvt
+ pags=0+dpagsn_lvt+0.0*ss_flag_lvt+0.0*ff_flag_lvt   saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     12: type=n 
+ lmin=9.999773e-007-dxln_lvt                         lmax=9.999977e-006-dxln_lvt
+ wmin=6e-007-dxwn_lvt      wmax=1e-006-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.12609977+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=6.3641227e-009+dlvthn_lvt                     wvth0=1.3705845e-009+dwvthn_lvt
+ pvth0=4.6152265e-015+dpvthn_lvt                     k1=0.14382
+ k2=0.040995341+dk2n_lvt   lk2=-7.0290511e-009+dlk2n_lvt
+ wk2=2.0714102e-009+dwk2n_lvt                        pk2=-2.2754239e-017+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.13046101          lvoff=4.5843738e-009
+ wvoff=3.0838376e-010      pvoff=-3.0666298e-015     nfactor=0.77901778+dnfactorn_lvt
+ lnfactor=2.0865141e-007+dlnfactorn_lvt              eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.04832113+du0n_lvt    ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=3.8123921e-009+dlu0n_lvt                        wu0=3.0818283e-009+dwu0n_lvt
+ pu0=-4.3992888e-015+dpu0n_lvt                       ua=-8.4600085e-010
+ lua=5.1980532e-16+dluan_lvt                         wua=2.9411303e-016
+ pua=-3.0403317e-22+dpuan_lvt                        ub=2.959187e-018
+ lub=-1.6831357e-26+dlubn_lvt                        wub=1.310278e-026
+ pub=1.0368116e-32+dpubn_lvt                         uc=1.3971813e-010
+ luc=5.6918145e-017        wuc=3.7133634e-017        puc=-3.5061577e-023
+ vsat=95273.906+dvsatn_lvt kvsat=1                   a0=1.8281959
+ la0=1.7084542e-006+dla0n_lvt                        ags=0.79553093+dagsn_lvt+0.587939*ss_flag_lvt-0.0399707*ff_flag_lvt
+ lags=7.6165876e-007+dlagsn_lvt-7.94959e-07*ss_flag_lvt+3.97481e-07*ff_flag_lvt
+ wags=9.2953287e-008+dwagsn_lvt-3.62173e-07*ss_flag_lvt+2.46224e-08*ff_flag_lvt
+ pags=-4.3535784e-015+dpagsn_lvt+4.89697e-13*ss_flag_lvt-2.44848e-13*ff_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.1                 dwg=0
+ dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.015231519       lpdiblc2=-1.4749838e-008
+ wpdiblc2=-3.3016056e-009  ppdiblc2=8.2880418e-015   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.2704188            lkt1=-4.4388712e-008+dlkt1n_lvt
+ wkt1=3.3261192e-009+dwkt1n_lvt                      pkt1=-3.1405217e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.033117647          lkt2=1.7655683e-009
+ wkt2=-7.5610117e-009      pkt2=-4.8542353e-015      ute=-1
+ ua1=3.0645493e-009        lua1=1.6452746e-015       wua1=8.7970416e-016
+ pua1=-9.6840752e-022      ub1=7.618729e-019         lub1=-4.0540837e-024
+ wub1=-1.2964247e-024      pub1=1.4432261e-030       uc1=4.9080792e-011
+ luc1=-3.9111779e-018      wuc1=-3.9960547e-019      puc1=3.9737567e-024
+ prt=0                     at=202077.24+datn_lvt     lat=-0.02065649+dlatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       ppclm=0+dppclmn_lvt
+ wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.00345
+ pkvth0we=0.2e-17          wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0022             pku0we=-0.65e-17          wku0we=-4.5e-10
+ lku0we=1.55e-10           k2we=0.00077              pk2we=0.025e-17
+ wk2we=-0.2e-10            lk2we=-1.6e-11            fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_lvt            noib=noibn_lvt            noic=noicn_lvt
+ em=1.5e+7                   ef=1                    lintnoi=0
+ minr=1e-3
 
 
     13: type=n 
+ lmin=2.399969e-007-dxln_lvt                         lmax=9.999773e-007-dxln_lvt
+ wmin=6e-007-dxwn_lvt      wmax=1e-006-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=3.259685e-09+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.12994714+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=2.7314424e-009+dlvthn_lvt                     wvth0=8.0405643e-009+dwvthn_lvt
+ pvth0=-1.6825685e-015+dpvthn_lvt                    k1=0.14382
+ k2=0.034237485+dk2n_lvt   lk2=-6.4828326e-010+dlk2n_lvt
+ wk2=2.5705203e-009+dwk2n_lvt                        pk2=-4.9401397e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.12334633          lvoff=-2.1333068e-009
+ wvoff=-2.9557161e-009     pvoff=1.5333247e-017      nfactor=1+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.053263478+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-8.5417292e-010+dlu0n_lvt
+ wu0=-1.7502152e-009+dwu0n_lvt                       pu0=1.6312666e-016+dpu0n_lvt
+ ua=-3.0715391e-010        lua=1.1026034e-17+dluan_lvt
+ wua=-5.2795518e-017       pua=2.3517874e-23+dpuan_lvt
+ ub=3.168135e-018          lub=-2.1412003e-25+dlubn_lvt
+ wub=3.4394635e-027        pub=1.9492219e-32+dpubn_lvt
+ uc=2.1819082e-010         luc=-1.7175772e-017       wuc=4.0896999e-018
+ puc=-3.8614947e-024       vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=4.3268233              la0=-6.5074984e-007+dla0n_lvt
+ wa0=-1.2507495e-007+dwa0n_lvt                       pa0=1.1809577e-013+dpa0n_lvt
+ ags=1.9750736+dagsn_lvt+0.489482*ff_flag_lvt-0.326322*ss_flag_lvt
+ lags=-3.5206547e-007+dlagsn_lvt-1.02429e-07*ff_flag_lvt+6.8286e-08*ss_flag_lvt
+ wags=-1.409717e-007+dwagsn_lvt-3.01521e-07*ff_flag_lvt+2.01014e-07*ss_flag_lvt
+ pags=2.1651839e-013+dpagsn_lvt+6.30963e-14*ff_flag_lvt-4.20642e-14*ss_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.11432724          lketa=1.3527779e-008
+ wketa=8.1126193e-009      pketa=-7.6599351e-015     dwg=0
+ dwb=0                     pclm=0.98461446+dpclmn_lvt
+ lpclm=-1.6088015e-007     wpclm=2.427326e-009       ppclm=-2.2918812e-015+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=0.00022025756     lpdiblc2=-5.7620519e-010
+ wpdiblc2=4.8562183e-009   ppdiblc2=5.8542447e-016   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.31538677           lkt1=-1.9299557e-009+dlkt1n_lvt
+ wkt1=5.6831682e-010+dwkt1n_lvt                      pkt1=-5.3660474e-016+dpkt1n_lvt
+ kt1l=0                    kt2=-0.023710315          lkt2=-7.1168342e-009
+ wkt2=-1.7306295e-008      pkt2=4.3472617e-015       ute=-1
+ ua1=4.3250226e-009        lua1=4.5513578e-016       wua1=-1.8748586e-016
+ pua1=3.9233291e-023       ub1=-2.3272429e-018       lub1=-1.1373405e-024
+ wub1=2.3543631e-025       pub1=-3.1570874e-033      uc1=4.3871016e-011
+ luc1=1.0078933e-018       wuc1=4.8935277e-018       puc1=-1.0240196e-024
+ prt=0                     at=220053.39+datn_lvt     lat=-0.03762957+dlatn_lvt
+ wat=0.0044550108+dwatn_lvt                          pat=-4.2064212e-009+dpatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt
+ lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     14: type=n 
+ lmin=9.998929e-008-dxln_lvt                         lmax=2.399969e-007-dxln_lvt
+ wmin=6e-007-dxwn_lvt      wmax=1e-006-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.14194966+dvthn_lvt kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lvth0=2.1979349e-010+dlvthn_lvt
+ wvth0=1.0671422e-009+dwvthn_lvt                     pvth0=-2.2331019e-016+dpvthn_lvt
+ k1=0.14382                k2=0.016375028+dk2n_lvt   lk2=3.0896145e-009+dlk2n_lvt
+ wk2=1.358905e-009+dwk2n_lvt                         pk2=-2.4047136e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00051476001         lcit=1.0154132e-010+dlcitn_lvt
+ voff=-0.1221126           lvoff=-2.3914762e-009     wvoff=-8.0067205e-009
+ pvoff=1.0723064e-015      nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.055076235+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-1.2335105e-009+dlu0n_lvt                       wu0=-1.2675068e-009+dwu0n_lvt
+ pu0=6.2115095e-017+dpu0n_lvt                        ua=-1.2576798e-010
+ lua=-2.6930785e-17+dluan_lvt                        wua=1.3117963e-016
+ pua=-1.4980765e-23+dpuan_lvt                        ub=2.3771732e-018
+ lub=-4.8603357e-26+dlubn_lvt                        wub=1.3234348e-026
+ pub=1.7442542e-32+dpubn_lvt                         uc=2.0591366e-011
+ luc=2.417389e-017         wuc=6.7871251e-017        puc=-1.7208422e-023
+ vsat=95273.906+dvsatn_lvt kvsat=1                   a0=1.2799051
+ la0=-1.3151715e-008+dla0n_lvt                       wa0=4.2813937e-007+dwa0n_lvt
+ pa0=2.3301422e-015+dpa0n_lvt                        ags=-0.58623918+dagsn_lvt-9.08583*ff_flag_lvt-12.8716*ss_flag_lvt
+ lags=1.8391485e-007+dlagsn_lvt+1.9013e-06*ff_flag_lvt+2.69351e-06*ss_flag_lvt
+ wags=1.4265344e-006+dwagsn_lvt+5.59687e-06*ff_flag_lvt+7.9289e-06*ss_flag_lvt
+ pags=-1.1149793e-013+dpagsn_lvt-1.1712e-12*ff_flag_lvt-1.6592e-12*ss_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.020098495          lketa=-1.460215e-008
+ wketa=-8.7530799e-008     pketa=1.2354407e-014      dwg=0
+ dwb=0                     pclm=0.25744706+dpclmn_lvt
+ lpclm=-8.7131028e-009     wpclm=1.4237282e-008      ppclm=-4.7632325e-015+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=-0.0070245163     lpdiblc2=9.398362e-010
+ wpdiblc2=1.2216909e-008   ppdiblc2=-9.5487357e-016  pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.34372647           lkt1=4.0004112e-009+dlkt1n_lvt
+ wkt1=6.4448913e-009+dwkt1n_lvt                      pkt1=-1.7663367e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.056706918          lkt2=-2.1196514e-010
+ wkt2=9.7228466e-009       pkt2=-1.3088566e-015      ute=-1
+ ua1=8.6753306e-009        lua1=-4.5520969e-016      wua1=6.9977591e-017
+ pua1=-1.4643511e-023      ub1=-1.0700531e-017       lub1=6.1485367e-025
+ wub1=3.5821255e-026       pub1=3.8614358e-032       uc1=-1.1425765e-010
+ luc1=3.4097898e-017       prt=0                     at=43136.193+datn_lvt
+ lat=-0.00060787784+dlatn_lvt                        wat=-0.024506135+dwatn_lvt
+ pat=1.8539881e-009+dpatn_lvt                        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt
+ pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt
+ peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt
+ pvsat=0+dpvsatn_lvt       saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.00345
+ pkvth0we=0.2e-17          wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0022             pku0we=-0.65e-17          wku0we=-4.5e-10
+ lku0we=1.55e-10           k2we=0.00077              pk2we=0.025e-17
+ wk2we=-0.2e-10            lk2we=-1.6e-11            fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_lvt            noib=noibn_lvt            noic=noicn_lvt
+ em=1.5e+7                   ef=1                    lintnoi=0
+ minr=1e-3
 
 
     15: type=n 
+ lmin=6e-08                lmax=9.998929e-008-dxln_lvt
+ wmin=6e-007-dxwn_lvt      wmax=1e-006-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.17471496+dvthn_lvt kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lvth0=-2.3411423e-009+dlvthn_lvt
+ wvth0=-2.1018248e-008+dwvthn_lvt                    pvth0=1.5028839e-015+dpvthn_lvt
+ k1=0.14382                k2=0.099553244+dk2n_lvt   lk2=-3.4115949e-009+dlk2n_lvt
+ wk2=-1.3859995e-008+dwk2n_lvt                       pk2=9.4903786e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0031232087         lcit=3.8588496e-010+dlcitn_lvt
+ voff=-0.16357189          lvoff=8.4898142e-010      wvoff=2.577916e-008
+ pvoff=-1.568398e-015      nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt+0.0125698*ff_flag_lvt-0.051872*ss_flag_lvt
+ etab=-0.12298557          letab=4.0564459e-009      wetab=7.6036385e-009
+ petab=-5.9430039e-016     u0=0.045926778+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-5.1838894e-010+dlu0n_lvt                       wu0=-2.1791196e-009+dwu0n_lvt
+ pu0=1.3336675e-016+dpu0n_lvt                        ua=-9.629404e-010
+ lua=3.8502612e-17+dluan_lvt                         wua=-1.2719304e-016
+ pua=5.2136426e-24+dpuan_lvt                         ub=2.4070959e-018
+ lub=-5.0942117e-26+dlubn_lvt                        wub=1.2662638e-025
+ pub=8.5798206e-33+dpubn_lvt                         uc=5.548269e-010
+ luc=-1.758196e-017        wuc=-3.5285846e-016       puc=1.5675812e-023
+ vsat=77453.132+dvsatn_lvt-5096.73*ss_flag_lvt       kvsat=1
+ lvsat=0.0013928717+dlvsatn_lvt+0.000398359*ss_flag_lvt
+ wvsat=0.0069017588+dwvsatn_lvt+0.00517828*ss_flag_lvt
+ pvsat=-5.3944147e-010+dpvsatn_lvt-4.04733e-10*ss_flag_lvt
+ a0=1.9865187+0.849455*ss_flag_lvt-1.01935*ff_flag_lvt
+ la0=-6.8380638e-008+dla0n_lvt-6.63932e-08*ss_flag_lvt+7.96719e-08*ff_flag_lvt
+ wa0=9.6296787e-007+dwa0n_lvt-8.63047e-07*ss_flag_lvt+1.03566e-06*ff_flag_lvt
+ pa0=-3.9472053e-014+dpa0n_lvt+6.74555e-14*ss_flag_lvt-8.09466e-14*ff_flag_lvt
+ ags=1.7668168+dagsn_lvt+28.1914*ff_flag_lvt+58.9108*ss_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.42546732          lketa=2.0223274e-008
+ wketa=1.5015169e-007      pketa=-6.2228569e-015     dwg=0
+ dwb=0                     pclm=0.324106+dpclmn_lvt-0.0618011*ff_flag_lvt+0.231802*ss_flag_lvt
+ lpclm=-1.3923165e-008+4.83032e-09*ff_flag_lvt-1.81176e-08*ss_flag_lvt
+ wpclm=-2.0644354e-007+2.24393e-08*ff_flag_lvt-1.34635e-07*ss_flag_lvt
+ ppclm=1.248518e-014+dppclmn_lvt-1.75385e-15*ff_flag_lvt+1.05231e-14*ss_flag_lvt
+ pdiblc1=0                 pdiblc2=-0.025186004      lpdiblc2=2.359338e-009
+ wpdiblc2=1.8594578e-008   ppdiblc2=-1.4533522e-015  pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.21052437           lkt1=-6.4106652e-009+dlkt1n_lvt
+ wkt1=-3.3389042e-008+dwkt1n_lvt                     pkt1=1.3470835e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.059074199          lkt2=-2.6938479e-011
+ wkt2=-1.3333576e-008      pkt2=4.9323337e-016       ute=-1
+ ua1=1.7145856e-009        lua1=8.8842139e-017       wua1=1.2311551e-015
+ pua1=-1.0540115e-022      ub1=-2.5853666e-018       lub1=-1.942756e-026
+ wub1=-2.201353e-025       pub1=5.8619923e-032       uc1=1.1353437e-010
+ luc1=1.6293674e-017       prt=0                     at=35184.212+datn_lvt
+ lat=1.364899e-005+dlatn_lvt                         wat=-0.012866851+dwatn_lvt
+ pat=9.442617e-010+dpatn_lvt                         jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt
+ pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt-9.82446e-10*ff_flag_lvt+4.0543e-09*ss_flag_lvt
+ weta0=0+dweta0n_lvt-1.8987e-09*ff_flag_lvt+2.24392e-08*ss_flag_lvt
+ peta0=0+dpeta0n_lvt+1.48405e-16*ff_flag_lvt-1.75385e-15*ss_flag_lvt
+ lags=0+dlagsn_lvt-1.01228e-06*ff_flag_lvt-2.91699e-06*ss_flag_lvt
+ pags=0+dpagsn_lvt+8.09466e-13*ff_flag_lvt+1.95621e-12*ss_flag_lvt
+ wags=0+dwagsn_lvt-1.97444e-05*ff_flag_lvt-3.83278e-05*ss_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     16: type=n 
+ lmin=9.999977e-006-dxln_lvt                         lmax=2.00001e-05
+ wmin=3e-007-dxwn_lvt      wmax=6e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13439647+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ wvth0=-2.8818412e-009+dwvthn_lvt                    k1=0.14382
+ k2=0.041714286+dk2n_lvt   wk2=1.1908325e-009+dwk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.13580387          wvoff=3.5751819e-009
+ nfactor=0.8+dnfactorn_lvt eta0=0.090503943+deta0n_lvt
+ weta0=1.8103008e-014+dweta0n_lvt                    etab=-0.071086318
+ u0=0.052989299+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               ua=-6.3991258e-010
+ wua=1.6878841e-016        ub=3.1555448e-018         pub=0+dpubn_lvt
+ lub=0+dlubn_lvt           pua=0+dpuan_lvt           lua=0+dluan_lvt
+ wub=-1.0785364e-025       uc=2.1089099e-010         wuc=-6.7088515e-018
+ vsat=95273.906+dvsatn_lvt kvsat=1                   a0=2
+ ags=1.2686565+dagsn_lvt   wags=-1.5174841e-007+dwagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.123226            wketa=1.4307216e-008
+ dwg=0                     dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.0065875779      wpdiblc2=1.9428283e-009
+ pdiblcb=-0.037159959      drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.70129737          pditsd=0.6367075
+ pditsl=977352.75          rsh=16                    rsw=45+drdswn_lvt
+ rdw=45+drdswn_lvt         prwg=0                    prwb=0
+ wr=1                      alpha0=9.96e-008          alpha1=1.252
+ beta0=13.29               agidl=1.7376647e-008      bgidl=1.3887812e+009
+ cgidl=1.4802648           egidl=0.81976             aigbacc=0.012866428
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010985
+ bigc=0.0016755            cigc=0                    aigsd=0.009264
+ bigsd=0.001144168         cigsd=0.087095398         nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_lvt
+ cgdo=cgon_lvt             cgbo=0                    cgdl=cgln_lvt
+ cgsl=cgln_lvt             clc=1e-007                cle=0.6
+ cf=cfn_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=10.65                noff=2.526
+ voffcv=-0.19263           kt1=-0.27303558           wkt1=1.8725518e-009+dwkt1n_lvt
+ kt1l=0                    kt2=-0.061892032          wkt2=9.7852312e-009
+ ute=-1                    ua1=5.0266667e-009        wua1=-3.2442667e-016
+ ub1=-2.2023597e-018       wub1=4.2354214e-025       uc1=4.868748e-011
+ prt=0                     at=200000+datn_lvt        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ pvth0=0+dpvthn_lvt        lk2=0+dlk2n_lvt           pk2=0+dpk2n_lvt
+ lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt
+ lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt       peta0=0+dpeta0n_lvt       lu0=0+dlu0n_lvt
+ wu0=0+dwu0n_lvt           pu0=0+dpu0n_lvt           lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       lags=0+dlagsn_lvt
+ ppclm=0+dppclmn_lvt       la0=0+dla0n_lvt           wa0=0+dwa0n_lvt
+ pa0=0+dpa0n_lvt           lat=0+dlatn_lvt           wat=0+dwatn_lvt
+ pat=0+dpatn_lvt           lkt1=0+dlkt1n_lvt         pkt1=0+dpkt1n_lvt
+ pags=0+dpagsn_lvt         saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.00345
+ pkvth0we=0.2e-17          wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0022             pku0we=-0.65e-17          wku0we=-4.5e-10
+ lku0we=1.55e-10           k2we=0.00077              pk2we=0.025e-17
+ wk2we=-0.2e-10            lk2we=-1.6e-11            fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_lvt            noib=noibn_lvt            noic=noicn_lvt
+ em=1.5e+7                   ef=1                    lintnoi=0
+ minr=1e-3
 
 
     17: type=n 
+ lmin=9.999773e-007-dxln_lvt                         lmax=9.999977e-006-dxln_lvt
+ wmin=3e-007-dxwn_lvt      wmax=6e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.13349387+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=8.9756897e-009+dlvthn_lvt                     wvth0=-3.1841784e-009+dwvthn_lvt
+ pvth0=3.0065012e-015+dpvthn_lvt                     k1=0.14382
+ k2=0.042305873+dk2n_lvt   lk2=-5.8828562e-009+dlk2n_lvt
+ wk2=1.2641225e-009+dwk2n_lvt                        pk2=-7.2881033e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.13694561          lvoff=1.1353718e-008
+ wvoff=4.3028971e-009      pvoff=-7.2365456e-015     nfactor=0.77901778+dnfactorn_lvt
+ lnfactor=2.0865141e-007+dlnfactorn_lvt              eta0=0.09050394+deta0n_lvt
+ leta0=3.0659239e-014+dleta0n_lvt                    weta0=2.0002215e-014+dweta0n_lvt
+ peta0=-1.8886091e-020+dpeta0n_lvt                   etab=-0.071086318
+ u0=0.05334611+du0n_lvt    ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-3.5482022e-009+dlu0n_lvt
+ wu0=-1.355939e-011+dwu0n_lvt                        pu0=1.3483728e-016+dpu0n_lvt
+ ua=-6.5224683e-010        lua=1.2265428e-16+dluan_lvt
+ wua=1.7476055e-016        pua=-5.9388137e-23+dpuan_lvt
+ ub=3.1739134e-018         lub=-1.8266083e-25+dlubn_lvt
+ wub=-1.1916869e-025       pub=1.1251907e-31+dpubn_lvt
+ uc=2.0800562e-010         luc=2.8692707e-017        wuc=-4.9314629e-018
+ puc=-1.7674707e-023       vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=1.8281959              la0=1.7084542e-006+dla0n_lvt
+ ags=1.2321948+dagsn_lvt   lags=3.6258264e-007+dlagsn_lvt
+ wags=-1.7603164e-007+dwagsn_lvt                     pags=2.4147731e-013+dpagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.12566267          lketa=2.4230689e-008
+ wketa=1.5808202e-008      pketa=-1.4926104e-014     dwg=0
+ dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.0060001713      lpdiblc2=5.8412889e-009
+ wpdiblc2=2.3849043e-009   ppdiblc2=-4.3960923e-015  pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.26801677           lkt1=-4.9908015e-008+dlkt1n_lvt
+ wkt1=1.8464694e-009+dwkt1n_lvt                      pkt1=2.5936898e-016+dpkt1n_lvt
+ kt1l=0                    kt2=-0.06212921           lkt2=2.3585458e-009
+ wkt2=1.0310111e-008       pkt2=-5.2195094e-015      ute=-1
+ ua1=5.0745603e-009        lua1=-4.7626424e-016      wua1=-3.5846263e-016
+ pua1=3.3846041e-022       ub1=-2.1133678e-018       lub1=-8.8495338e-025
+ wub1=4.7472356e-025       pub1=-5.0895821e-031      uc1=4.8432082e-011
+ luc1=2.5397259e-018       prt=0                     at=202077.24+datn_lvt
+ lat=-0.02065649+dlatn_lvt jss=1.368e-07             jsd=1.368e-07
+ jsws=1.828e-13            jswd=1.828e-13            jswgs=1.828e-13
+ jswgd=1.828e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.05                  bvd=9.05
+ xjbvs=1                   xjbvd=1                   pbs=0.73
+ pbd=0.73                  cjs=cjn_lvt               cjd=cjn_lvt
+ mjs=0.31                  mjd=0.31                  pbsws=1
+ pbswd=1                   cjsws=cjswn_lvt           cjswd=cjswn_lvt
+ mjsws=0.08                mjswd=0.08                pbswgs=0.48
+ pbswgd=0.48               cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.60e-03
+ tcj=7.5e-04               tpbsw=1.0e-04             tcjsw=9e-04
+ tpbswg=1e-04              tcjswg=5.9e-03            xtis=3
+ xtid=3                    jtsswgs=1.99e-010         jtsswgd=1.99e-010
+ njtsswg=4.876362          xtsswgs=-0.1076           xtsswgd=-0.1076
+ tnjtsswg=-0.5             vtsswgs=20                vtsswgd=20
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt
+ ppclm=0+dppclmn_lvt       wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt
+ wat=0+dwatn_lvt           pat=0+dpatn_lvt           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     18: type=n 
+ lmin=2.399969e-007-dxln_lvt                         lmax=9.999773e-007-dxln_lvt
+ wmin=3e-007-dxwn_lvt      wmax=6e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=3.259685e-09+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.143+dvthn_lvt      k1=0.14382
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=0.038579809+dk2n_lvt   lk2=-2.3647064e-009+dlk2n_lvt
+ wk2=-1.0435139e-010+dwk2n_lvt                       pk2=5.6330268e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.11980953          lvoff=-4.8261667e-009
+ wvoff=-5.1343837e-009     pvoff=1.6741349e-015      nfactor=1+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.049438774+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=1.4110397e-010+dlu0n_lvt
+ wu0=6.0580217e-010+dwu0n_lvt                        pu0=-4.499639e-016+dpu0n_lvt
+ ua=-5.9497058e-010        lua=6.8574053e-17+dluan_lvt
+ wua=1.2449956e-016        pua=-1.1931706e-23+dpuan_lvt
+ ub=3.1552042e-018         lub=-1.6499558e-25+dlubn_lvt
+ wub=1.1404827e-026        pub=-1.0768437e-32+dpubn_lvt
+ uc=2.7415589e-010         luc=-3.3766381e-017       wuc=-3.0384786e-017
+ puc=6.3583203e-024        vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=3.5830983              la0=5.1475347e-008+dla0n_lvt
+ wa0=3.3305967e-007+dwa0n_lvt                        pa0=-3.1447494e-013+dpa0n_lvt
+ ags=1.3734974+dagsn_lvt   lags=2.2916468e-007+dlagsn_lvt
+ wags=2.2959925e-007+dwagsn_lvt                      pags=-1.4151938e-013+dpagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.096033301         lketa=-3.7453573e-009
+ wketa=-3.1564463e-009     pketa=2.9803166e-015      dwg=0
+ dwb=0                     pclm=0.96485282+dpclmn_lvt
+ lpclm=-1.4222121e-007     wpclm=1.4600498e-008      ppclm=-1.378579e-014+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=0.012589526       lpdiblc2=-3.8037948e-010
+ wpdiblc2=-2.7632508e-009  ppdiblc2=4.6479583e-016   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.31965328           lkt1=-1.1528234e-009+dlkt1n_lvt
+ wkt1=3.1964876e-009+dwkt1n_lvt                      pkt1=-1.0153182e-015+dpkt1n_lvt
+ kt1l=0                    kt2=-0.061446198          lkt2=1.7136458e-009
+ wkt2=5.9390081e-009       pkt2=-1.092314e-015       ute=-1
+ ua1=3.8707042e-009        lua1=6.604167e-016        wua1=9.237424e-017
+ pua1=-8.7219758e-023      ub1=-1.5878773e-018       lub1=-1.3811215e-024
+ wub1=-2.2001295e-025      pub1=1.47012e-031         uc1=5.1815054e-011
+ luc1=-6.5447617e-019      prt=0                     at=225733.66+datn_lvt
+ lat=-0.042992881+dlatn_lvt                          wat=0.00095596501+dwatn_lvt
+ pat=-9.0262216e-010+dpatn_lvt                       jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ wvth0=0+dwvthn_lvt        pvth0=0+dpvthn_lvt        lcit=0+dlcitn_lvt
+ wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     19: type=n 
+ lmin=9.998929e-008-dxln_lvt                         lmax=2.399969e-007-dxln_lvt
+ wmin=3e-007-dxwn_lvt      wmax=6e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.14440045+dvthn_lvt kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lvth0=-2.9305799e-010+dlvthn_lvt
+ wvth0=-4.4254193e-010+dwvthn_lvt                    pvth0=9.2606324e-017+dpvthn_lvt
+ k1=0.14382                k2=0.01124558+dk2n_lvt    lk2=3.3552543e-009+dlk2n_lvt
+ wk2=4.5186447e-009+dwk2n_lvt                        pk2=-4.0410548e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00051476001         lcit=1.0154132e-010+dlcitn_lvt
+ voff=-0.14409247          lvoff=2.552812e-010       wvoff=5.5328774e-009
+ pvoff=-5.5809614e-016     nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.057020617+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-1.4454724e-009+dlu0n_lvt                       wu0=-2.4652459e-009+dwu0n_lvt
+ pu0=1.9268362e-016+dpu0n_lvt                        ua=3.7286373e-011
+ lua=-6.3732038e-17+dluan_lvt                        wua=3.0738143e-017
+ pua=7.6888071e-24+dpuan_lvt                         ub=2.6254185e-018
+ lub=-5.4132631e-26+dlubn_lvt                        wub=-1.3968479e-025
+ pub=2.0848575e-32+dpubn_lvt                         uc=1.3077197e-010
+ luc=-3.7618603e-018       vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=4.4462101              la0=-1.2913944e-007+dla0n_lvt
+ wa0=-1.5223046e-006+dwa0n_lvt                       pa0=7.3778578e-014+dpa0n_lvt
+ ags=2.8870202+dagsn_lvt   lags=-8.7555105e-008+dlagsn_lvt
+ wags=-7.1299343e-007+dwagsn_lvt                     pags=5.5727567e-014+dpagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.15072241          lketa=7.698886e-009
+ wketa=1.7694879e-008      pketa=-1.3830317e-015     dwg=0
+ dwb=0                     pclm=0.41026054+dpclmn_lvt
+ lpclm=-2.6167231e-008     wpclm=-7.9895825e-008     ppclm=5.9885102e-015+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=0.01421285        lpdiblc2=-7.2007637e-010
+ wpdiblc2=-8.6530921e-010  ppdiblc2=6.7632568e-017   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.32289598           lkt1=-4.7425677e-010+dlkt1n_lvt
+ wkt1=-6.3866959e-009+dwkt1n_lvt                     pkt1=9.9005874e-016+dpkt1n_lvt
+ kt1l=0                    kt2=-0.037044563          lkt2=-3.3926404e-009
+ wkt2=-2.3891644e-009      pkt2=6.5043935e-016       ute=-1
+ ua1=9.4876133e-009        lua1=-5.1497769e-016      wua1=-4.303885e-016
+ pua1=2.2173574e-023       ub1=-1.1942123e-017       lub1=7.8560795e-025
+ wub1=8.006421e-025        pub1=-6.6570278e-032      uc1=-1.1425765e-010
+ luc1=3.4097898e-017       prt=0                     at=20480.588+datn_lvt
+ lat=-4.1623083e-005+dlatn_lvt                       wat=-0.010550282+dwatn_lvt
+ pat=1.5051751e-009+dpatn_lvt                        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt
+ pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt       weta0=0+dweta0n_lvt
+ peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt
+ pvsat=0+dpvsatn_lvt       saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.00345
+ pkvth0we=0.2e-17          wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0022             pku0we=-0.65e-17          wku0we=-4.5e-10
+ lku0we=1.55e-10           k2we=0.00077              pk2we=0.025e-17
+ wk2we=-0.2e-10            lk2we=-1.6e-11            fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noian_lvt            noib=noibn_lvt            noic=noicn_lvt
+ em=1.5e+7                   ef=1                    lintnoi=0
+ minr=1e-3
 
 
     20: type=n 
+ lmin=6e-08                lmax=9.998929e-008-dxln_lvt
+ wmin=3e-007-dxwn_lvt      wmax=6e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.13806056+dvthn_lvt+0.00116203*ff_flag_lvt    kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=2.0246753e-010+dlvthn_lvt-9.08236e-11*ff_flag_lvt
+ wvth0=1.5608622e-009+dwvthn_lvt-7.15808e-10*ff_flag_lvt
+ pvth0=-6.397974e-017+dpvthn_lvt+5.59474e-17*ff_flag_lvt
+ k1=0.14382                k2=0.080443219+dk2n_lvt   lk2=-2.0532332e-009+dlk2n_lvt
+ wk2=-2.0882199e-009+dwk2n_lvt                       pk2=1.1228706e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0031232087         lcit=3.8588496e-010+dlcitn_lvt
+ voff=-0.11146388          lvoff=-2.2949698e-009     wvoff=-6.3193754e-009
+ pvoff=3.6827594e-016      nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt+0.0151814*ff_flag_lvt-0.0189307*ss_flag_lvt
+ etab=-0.096873935         letab=2.0155601e-009      wetab=-8.4811317e-009
+ petab=6.6288525e-016      u0=0.035656069+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=2.2438067e-010+dlu0n_lvt                        wu0=4.1476373e-009+dwu0n_lvt
+ pu0=-3.2417933e-016+dpu0n_lvt                       ua=-1.6101539e-009
+ lua=6.5031892e-17+dluan_lvt                         wua=2.7149046e-016
+ pua=-1.1128394e-23+dpuan_lvt                        ub=1.7972555e-018
+ lub=1.0596587e-26+dlubn_lvt                         wub=5.0228805e-025
+ pub=-2.9328022e-32+dpubn_lvt                        uc=-1.7995272e-011
+ luc=7.8657872e-018        vsat=81687.78+dvsatn_lvt+6795.64*ss_flag_lvt
+ kvsat=1                   lvsat=0.0010618916+dlvsatn_lvt-0.000531146*ss_flag_lvt
+ wvsat=0.0042932157+dwvsatn_lvt-0.00214742*ss_flag_lvt
+ pvsat=-3.3555774e-010+dpvsatn_lvt+1.67842e-10*ss_flag_lvt
+ a0=5.5240674-1.13261*ss_flag_lvt+1.35913*ff_flag_lvt
+ la0=-2.1338476e-007+dla0n_lvt+8.85243e-08*ss_flag_lvt-1.06229e-07*ff_flag_lvt
+ wa0=-1.2161621e-006+dwa0n_lvt+3.57904e-07*ss_flag_lvt-4.29485e-07*ff_flag_lvt
+ pa0=4.9850485e-014+dpa0n_lvt-2.79737e-14*ss_flag_lvt+3.35684e-14*ff_flag_lvt
+ ags=1.7668168+dagsn_lvt-7.92825*ff_flag_lvt-6.79564*ss_flag_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.18171457          lketa=1.0121233e-008
+ dwg=0                     dwb=0                     pclm=0.026487157+dpclmn_lvt-0.0216225*ss_flag_lvt-0.0520999*ff_flag_lvt
+ lpclm=3.8284972e-009+1.69001e-09*ss_flag_lvt+4.07212e-09*ff_flag_lvt
+ wpclm=-2.3110334e-008+2.14742e-08*ss_flag_lvt+1.64636e-08*ff_flag_lvt
+ ppclm=1.5501562e-015+dppclmn_lvt-1.67842e-15*ss_flag_lvt-1.28679e-15*ff_flag_lvt
+ pdiblc1=0                 pdiblc2=0.005             pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.28517739           lkt1=-3.4223417e-009+dlkt1n_lvt
+ wkt1=1.2597215e-008+dwkt1n_lvt                      pkt1=-4.9372371e-016+dpkt1n_lvt
+ kt1l=0                    kt2=-0.093504742          lkt2=1.0202872e-009
+ wkt2=7.8756388e-009       pkt2=-1.5185766e-016      ute=-1
+ ua1=3.8574683e-009        lua1=-7.4925557e-017      wua1=-8.8860629e-017
+ pua1=-4.5202447e-024      ub1=-1.925396e-018        lub1=2.7005608e-027
+ wub1=-6.2667722e-025      pub1=4.4989e-032          uc1=-4.2784196e-010
+ luc1=5.8607647e-017       wuc1=3.3348782e-016       puc1=-2.6065408e-023
+ prt=0                     at=-28788.549+datn_lvt    lat=0.0038092527+dlatn_lvt
+ wat=0.026540369+dwatn_lvt pat=-1.3938302e-009+dpatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt-1.18657e-09*ff_flag_lvt+1.47962e-09*ss_flag_lvt
+ weta0=0+dweta0n_lvt-3.50746e-09*ff_flag_lvt+2.14743e-09*ss_flag_lvt
+ peta0=0+dpeta0n_lvt+2.74142e-16*ff_flag_lvt-1.67842e-16*ss_flag_lvt
+ lags=0+dlagsn_lvt+6.1967e-07*ff_flag_lvt+5.31146e-07*ss_flag_lvt
+ pags=0+dpagsn_lvt-1.95816e-13*ff_flag_lvt-1.67842e-13*ss_flag_lvt
+ wags=0+dwagsn_lvt+2.50533e-06*ff_flag_lvt+2.14742e-06*ss_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     21: type=n 
+ lmin=9.999977e-006-dxln_lvt                         lmax=2.00001e-05
+ wmin=1.2e-07              wmax=3e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.12254115+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ wvth0=8.6444242e-010+dwvthn_lvt                     k1=0.14382
+ k2=0.045372615+dk2n_lvt   wk2=3.4800628e-011+dwk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.12051578          wvoff=-1.2558542e-009
+ nfactor=0.8+dnfactorn_lvt eta0=0.090504021+deta0n_lvt
+ weta0=-6.66128e-015+dweta0n_lvt                     etab=-0.071086318
+ u0=0.052989299+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               ua=-1.3980037e-010
+ wua=1.0752955e-017        ub=2.9560851e-018         pub=0+dpubn_lvt
+ lub=0+dlubn_lvt           pua=0+dpuan_lvt           lua=0+dluan_lvt
+ wub=-4.4824352e-026       uc=2.5657761e-010         wuc=-2.1145823e-017
+ vsat=95273.906+dvsatn_lvt kvsat=1                   a0=2
+ ags=0.7228479+dagsn_lvt   wags=2.0727104e-008+dwagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.07795             dwg=0
+ dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.015001832       wpdiblc2=-7.160761e-010
+ pdiblcb=-0.037159959      drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.70129737          pditsd=0.6367075
+ pditsl=977352.75          rsh=16                    rsw=45+drdswn_lvt
+ rdw=45+drdswn_lvt         prwg=0                    prwb=0
+ wr=1                      alpha0=9.96e-008          alpha1=1.252
+ beta0=13.29               agidl=1.7376647e-008      bgidl=1.3887812e+009
+ cgidl=1.4802648           egidl=0.81976             aigbacc=0.012866428
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010985
+ bigc=0.0016755            cigc=0                    aigsd=0.009264
+ bigsd=0.001144168         cigsd=0.087095398         nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_lvt
+ cgdo=cgon_lvt             cgbo=0                    cgdl=cgln_lvt
+ cgsl=cgln_lvt             clc=1e-007                cle=0.6
+ cf=cfn_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=10.65                noff=2.526
+ voffcv=-0.19263           kt1=-0.27873905           wkt1=3.6748491e-009+dwkt1n_lvt
+ kt1l=0                    kt2=-0.035175385          wkt2=1.3427708e-009
+ ute=-1                    ua1=4e-009                ub1=-3.7344419e-019
+ wub1=-1.5439516e-025      uc1=4.868748e-011         prt=0
+ at=200000+datn_lvt        jss=1.368e-07             jsd=1.368e-07
+ jsws=1.828e-13            jswd=1.828e-13            jswgs=1.828e-13
+ jswgd=1.828e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.05                  bvd=9.05
+ xjbvs=1                   xjbvd=1                   pbs=0.73
+ pbd=0.73                  cjs=cjn_lvt               cjd=cjn_lvt
+ mjs=0.31                  mjd=0.31                  pbsws=1
+ pbswd=1                   cjsws=cjswn_lvt           cjswd=cjswn_lvt
+ mjsws=0.08                mjswd=0.08                pbswgs=0.48
+ pbswgd=0.48               cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.60e-03
+ tcj=7.5e-04               tpbsw=1.0e-04             tcjsw=9e-04
+ tpbswg=1e-04              tcjswg=5.9e-03            xtis=3
+ xtid=3                    jtsswgs=1.99e-010         jtsswgd=1.99e-010
+ njtsswg=4.876362          xtsswgs=-0.1076           xtsswgd=-0.1076
+ tnjtsswg=-0.5             vtsswgs=20                vtsswgd=20
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lvth0=0+dlvthn_lvt        pvth0=0+dpvthn_lvt
+ lk2=0+dlk2n_lvt           pk2=0+dpk2n_lvt           lcit=0+dlcitn_lvt
+ wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ peta0=0+dpeta0n_lvt       lu0=0+dlu0n_lvt           wu0=0+dwu0n_lvt
+ pu0=0+dpu0n_lvt           lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt
+ pvsat=0+dpvsatn_lvt       lags=0+dlagsn_lvt         ppclm=0+dppclmn_lvt
+ la0=0+dla0n_lvt           wa0=0+dwa0n_lvt           pa0=0+dpa0n_lvt
+ lat=0+dlatn_lvt           wat=0+dwatn_lvt           pat=0+dpatn_lvt
+ lkt1=0+dlkt1n_lvt         pkt1=0+dpkt1n_lvt         pags=0+dpagsn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     22: type=n 
+ lmin=9.999773e-007-dxln_lvt                         lmax=9.999977e-006-dxln_lvt
+ wmin=1.2e-07              wmax=3e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.058866e-08+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.12039478+dvthn_lvt kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=2.1343844e-008+dlvthn_lvt                     wvth0=9.5513204e-010+dwvthn_lvt
+ pvth0=-9.0183567e-016+dpvthn_lvt                    k1=0.14382
+ k2=0.046414208+dk2n_lvt   lk2=-1.0357805e-008+dlk2n_lvt
+ wk2=-3.4111243e-011+dwk2n_lvt                       pk2=6.8527343e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.1191487           lvoff=-1.3594452e-008
+ wvoff=-1.3209249e-009     pvoff=6.4707589e-016      nfactor=0.77901778+dnfactorn_lvt
+ lnfactor=2.0865141e-007+dlnfactorn_lvt              eta0=0.090504026+deta0n_lvt
+ leta0=-5.1098731e-014+dleta0n_lvt                   weta0=-7.3601223e-015+dweta0n_lvt
+ peta0=6.9494275e-021+dpeta0n_lvt                    etab=-0.071086318
+ u0=0.053311127+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-3.2003215e-009+dlu0n_lvt
+ wu0=-2.5046733e-012+dwu0n_lvt                       pu0=2.4906972e-017+dpu0n_lvt
+ ua=-1.3747823e-010        lua=-2.3091874e-17+dluan_lvt
+ wua=1.2093671e-017        pua=-1.333235e-23+dpuan_lvt
+ ub=2.9535281e-018         lub=2.5426985e-26+dlubn_lvt
+ wub=-4.9526925e-026       pub=4.6763323e-32+dpubn_lvt
+ uc=2.5831416e-010         luc=-1.7268556e-017       wuc=-2.082896e-017
+ puc=-3.1509484e-024       vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=1.8319443              la0=1.6711792e-006+dla0n_lvt
+ wa0=-1.1845001e-009+dwa0n_lvt                       pa0=1.1778906e-014+dpa0n_lvt
+ ags=0.62175634+dagsn_lvt  lags=1.0052747e-006+dlagsn_lvt
+ wags=1.6866903e-008+dwagsn_lvt                      pags=3.8386609e-014+dpagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.07563671          lketa=-2.3003818e-008
+ dwg=0                     dwb=0                     pclm=0.81422667+dpclmn_lvt
+ pdiblc1=0                 pdiblc2=0.016051136       lpdiblc2=-1.0434482e-008
+ wpdiblc2=-7.9120044e-010  ppdiblc2=7.4705146e-016   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.27370684           lkt1=-5.004128e-008+dlkt1n_lvt
+ wkt1=3.6445319e-009+dwkt1n_lvt                      pkt1=3.0148061e-016+dpkt1n_lvt
+ kt1l=0                    kt2=-0.03370319           lkt2=-1.4639795e-008
+ wkt2=1.3274889e-009       pkt2=1.5196637e-016       ute=-1
+ ua1=3.9268967e-009        lua1=7.2695335e-016       wua1=4.1990653e-018
+ pua1=-4.1756345e-023      ub1=-8.862903e-020        lub1=-2.8322589e-024
+ wub1=-1.6509389e-025      pub1=1.0639034e-031       uc1=4.8432082e-011
+ luc1=2.5397259e-018       prt=0                     at=202077.24+datn_lvt
+ lat=-0.02065649+dlatn_lvt jss=1.368e-07             jsd=1.368e-07
+ jsws=1.828e-13            jswd=1.828e-13            jswgs=1.828e-13
+ jswgd=1.828e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.05                  bvd=9.05
+ xjbvs=1                   xjbvd=1                   pbs=0.73
+ pbd=0.73                  cjs=cjn_lvt               cjd=cjn_lvt
+ mjs=0.31                  mjd=0.31                  pbsws=1
+ pbswd=1                   cjsws=cjswn_lvt           cjswd=cjswn_lvt
+ mjsws=0.08                mjswd=0.08                pbswgs=0.48
+ pbswgd=0.48               cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.60e-03
+ tcj=7.5e-04               tpbsw=1.0e-04             tcjsw=9e-04
+ tpbswg=1e-04              tcjswg=5.9e-03            xtis=3
+ xtid=3                    jtsswgs=1.99e-010         jtsswgd=1.99e-010
+ njtsswg=4.876362          xtsswgs=-0.1076           xtsswgd=-0.1076
+ tnjtsswg=-0.5             vtsswgs=20                vtsswgd=20
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lcit=0+dlcitn_lvt         wcit=0+dwcitn_lvt
+ pcit=0+dpcitn_lvt         wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt
+ ppclm=0+dppclmn_lvt       wat=0+dwatn_lvt           pat=0+dpatn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
 
     23: type=n 
+ lmin=2.399969e-007-dxln_lvt                         lmax=9.999773e-007-dxln_lvt
+ wmin=1.2e-07              wmax=3e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=3.259685e-09+ddlcn_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.143+dvthn_lvt      k1=0.14382
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=0.034616473+dk2n_lvt   lk2=7.8161597e-010+dlk2n_lvt
+ wk2=1.1480627e-009+dwk2n_lvt                        pk2=-4.3093519e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.001                 voff=-0.13487248          lvoff=1.2519355e-009
+ wvoff=-3.7449276e-010     pvoff=-2.4654534e-016     nfactor=1+dnfactorn_lvt
+ eta0=0.090503972+deta0n_lvt                         etab=-0.071086318
+ u0=0.052092886+du0n_lvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-2.0500584e-009+dlu0n_lvt
+ wu0=-2.32897e-010+dwu0n_lvt                         pu0=2.4244341e-016+dpu0n_lvt
+ ua=-1.9782913e-010        lua=3.3891444e-17+dluan_lvt
+ wua=-9.9714499e-019       pua=-9.7200163e-25+dpuan_lvt
+ ub=3.2436578e-018         lub=-2.4851351e-25+dlubn_lvt
+ wub=-1.6546522e-026       pub=1.5623226e-32+dpubn_lvt
+ uc=2.7625138e-010         luc=-3.4204882e-017       wuc=-3.104696e-017
+ puc=6.4968869e-024        vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=4.5755452              la0=-9.1932875e-007+dla0n_lvt
+ wa0=1.9446459e-008+dwa0n_lvt                        pa0=-7.7008454e-015+dpa0n_lvt
+ ags=1.8198903+dagsn_lvt   lags=-1.2600336e-007+dlagsn_lvt
+ wags=8.8539097e-008+dwagsn_lvt                      pags=-2.9286277e-014+dpagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.10602205+0.00129078*ff_flag_lvt
+ pketa=0+3.85126e-16*ff_flag_lvt                     wketa=0-4.07886e-10*ff_flag_lvt
+ lketa=5.6860242e-009-1.21875e-09*ff_flag_lvt        dwg=0
+ dwb=0                     pclm=1.0667044+dpclmn_lvt lpclm=-2.3838946e-007
+ wpclm=-1.7584596e-008     ppclm=1.6603376e-014+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=0.0029724404      lpdiblc2=1.9144218e-009
+ wpdiblc2=2.757481e-010    ppdiblc2=-2.6036136e-016  pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.32235929           lkt1=-4.1036368e-009+dlkt1n_lvt
+ wkt1=4.0515874e-009+dwkt1n_lvt                      pkt1=-8.2861186e-017+dpkt1n_lvt
+ kt1l=0                    kt2=-0.048131035          lkt2=-1.017024e-009
+ wkt2=1.7314168e-009       pkt2=-2.2942235e-016      ute=-1
+ ua1=4.3257535e-009        lua1=3.5035283e-016       wua1=-5.1421323e-017
+ pua1=1.0760426e-023       ub1=-2.1934152e-018       lub1=-8.4491982e-025
+ wub1=-2.8662969e-026      pub1=-2.2427738e-032      uc1=5.1815054e-011
+ luc1=-6.5447617e-019      prt=0                     at=228908.57+datn_lvt
+ lat=-0.045990629+dlatn_lvt                          wat=-4.7306046e-005+dwatn_lvt
+ pat=4.4666369e-011+dpatn_lvt                        jss=1.368e-07
+ jsd=1.368e-07             jsws=1.828e-13            jswd=1.828e-13
+ jswgs=1.828e-13           jswgd=1.828e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.05
+ bvd=9.05                  xjbvs=1                   xjbvd=1
+ pbs=0.73                  pbd=0.73                  cjs=cjn_lvt
+ cjd=cjn_lvt               mjs=0.31                  mjd=0.31
+ pbsws=1                   pbswd=1                   cjsws=cjswn_lvt
+ cjswd=cjswn_lvt           mjsws=0.08                mjswd=0.08
+ pbswgs=0.48               pbswgd=0.48               cjswgs=cjswgn_lvt
+ cjswgd=cjswgn_lvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.60e-03              tcj=7.5e-04               tpbsw=1.0e-04
+ tcjsw=9e-04               tpbswg=1e-04              tcjswg=5.9e-03
+ xtis=3                    xtid=3                    jtsswgs=1.99e-010
+ jtsswgd=1.99e-010         njtsswg=4.876362          xtsswgs=-0.1076
+ xtsswgd=-0.1076           tnjtsswg=-0.5             vtsswgs=20
+ vtsswgd=20                dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn_lvt
+ wvth0=0+dwvthn_lvt        pvth0=0+dpvthn_lvt        lcit=0+dlcitn_lvt
+ wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     24: type=n 
+ lmin=9.998929e-008-dxln_lvt                         lmax=2.399969e-007-dxln_lvt
+ wmin=1.2e-07              wmax=3e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.13849548+dvthn_lvt kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lvth0=9.426153e-010+dlvthn_lvt
+ wvth0=1.4234275e-009+dwvthn_lvt                     pvth0=-2.9786643e-016+dpvthn_lvt
+ k1=0.14382                k2=0.026763445+dk2n_lvt   lk2=2.4249407e-009+dlk2n_lvt
+ wk2=-3.8500045e-010+dwk2n_lvt                       pk2=-1.101264e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00051476001         lcit=1.0154132e-010+dlcitn_lvt
+ voff=-0.12173609          lvoff=-1.4969859e-009     wvoff=-1.5317402e-009
+ pvoff=-4.3797387e-018     nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt
+ etab=-0.071086318         u0=0.044543401+du0n_lvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-4.7025317e-010+dlu0n_lvt                       wu0=1.4775544e-009+dwu0n_lvt
+ pu0=-1.1548565e-016+dpu0n_lvt                       ua=2.374244e-010
+ lua=-5.7189708e-17+dluan_lvt                        wua=-3.2505472e-017
+ pua=5.6214309e-24+dpuan_lvt                         ub=1.9301345e-018
+ lub=2.6354382e-26+dlubn_lvt                         wub=8.0024955e-026
+ pub=-4.5853213e-33+dpubn_lvt                        uc=1.3077197e-010
+ luc=-3.7618603e-018       vsat=95273.906+dvsatn_lvt kvsat=1
+ a0=-0.39732302            la0=1.2129365e-007+dla0n_lvt
+ wa0=8.2519185e-009+dwa0n_lvt                        pa0=-5.3582759e-015+dpa0n_lvt
+ ags=0.890408+dagsn_lvt    lags=6.8500108e-008+dlagsn_lvt
+ wags=-8.206396e-008+dwagsn_lvt                      pags=6.4141191e-015+dpagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.094725959-0.00723603*ff_flag_lvt
+ pketa=0-1.78719e-16*ff_flag_lvt                     wketa=0+2.28659e-09*ff_flag_lvt
+ lketa=3.3222033e-009+5.65566e-10*ff_flag_lvt        dwg=0
+ dwb=0                     pclm=-0.13513857+dpclmn_lvt
+ lpclm=1.3108198e-008      wpclm=9.2450295e-008      ppclm=-6.4225254e-015+dppclmn_lvt
+ pdiblc1=0                 pdiblc2=0.016366397       lpdiblc2=-8.8839759e-010
+ wpdiblc2=-1.54583e-009    ppdiblc2=1.2082207e-016   pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.36658355           lkt1=5.1507311e-009+dlkt1n_lvt
+ wkt1=7.4185769e-009+dwkt1n_lvt                      pkt1=-7.8743741e-016+dpkt1n_lvt
+ kt1l=0                    kt2=-0.050246825          lkt2=-5.7427386e-010
+ wkt2=1.7827506e-009       pkt2=-2.4016446e-016      ute=-1
+ ua1=9.2811999e-009        lua1=-6.8662389e-016      wua1=-3.6516187e-016
+ pua1=7.6413773e-023       ub1=-1.0208688e-017       lub1=8.3235618e-025
+ wub1=2.5287665e-025       pub1=-8.1342719e-032      uc1=-1.7807765e-010
+ luc1=4.7452871e-017       wuc1=2.016712e-017        puc1=-4.2201716e-024
+ prt=0                     at=-27204.384+datn_lvt    lat=0.007603567+dlatn_lvt
+ wat=0.0045181689+dwatn_lvt                          pat=-9.1070491e-010+dpatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ wcit=0+dwcitn_lvt         pcit=0+dpcitn_lvt         lnfactor=0+dlnfactorn_lvt
+ wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt leta0=0+dleta0n_lvt
+ weta0=0+dweta0n_lvt       peta0=0+dpeta0n_lvt       lvsat=0+dlvsatn_lvt
+ wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.00345           pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0022             pku0we=-0.65e-17
+ wku0we=-4.5e-10           lku0we=1.55e-10           k2we=0.00077
+ pk2we=0.025e-17           wk2we=-0.2e-10            lk2we=-1.6e-11
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_lvt            noib=noibn_lvt
+ noic=noicn_lvt            em=1.5e+7                   ef=1
+ lintnoi=0                 minr=1e-3
 
 
     25: type=n 
+ lmin=6e-08                lmax=9.998929e-008-dxln_lvt
+ wmin=1.2e-07              wmax=3e-007-dxwn_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_lvt             toxm=2e-009
+ dtox=2.0788e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_lvt
+ xw=1.6e-08+dxwn_lvt       dlc=2.8625e-10+ddlcn_lvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.14805594+dvthn_lvt-0.00193671*ff_flag_lvt    kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ lvth0=1.9536986e-010+dlvthn_lvt+1.51373e-10*ff_flag_lvt
+ wvth0=-1.5976774e-009+dwvthn_lvt+2.63392e-10*ff_flag_lvt
+ pvth0=-6.1736876e-017+dpvthn_lvt-2.05867e-17*ff_flag_lvt
+ k1=0.14382                k2=0.084233872+dk2n_lvt   lk2=-2.0669478e-009+dlk2n_lvt
+ wk2=-3.2860662e-009+dwk2n_lvt                       pk2=1.166209e-016+dpk2n_lvt
+ k3=-1.8449512             k3b=1.4703914             w0=0
+ dvt0=0.68502703           dvt1=0.55390526           dvt2=0.28043048
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.51219786           minv=-0.16                voffl=0
+ dvtp0=2.3021105e-006      dvtp1=4.6632516           lpe0=9.588928e-008
+ lpeb=4.9314511e-008       xj=1.1e-007               ngate=8.131e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.003091759          lcit=3.8342685e-010+dlcitn_lvt
+ wcit=-9.9381125e-012+dwcitn_lvt                     pcit=7.7676288e-019+dpcitn_lvt
+ voff=-0.12365376          lvoff=-1.3471006e-009     wvoff=-2.4673722e-009
+ pvoff=6.8749259e-017      nfactor=1+dnfactorn_lvt   eta0=0.090503972+deta0n_lvt+0.00716582*ff_flag_lvt-0.0213038*ss_flag_lvt
+ etab=-0.12384543          letab=4.1236519e-009      wetab=4.1859461e-011
+ petab=-3.2717354e-018     u0=0.041926+du0n_lvt      lu0=-2.6567712e-010+dlu0n_lvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=2.1663392e-009+dwu0n_lvt
+ pu0=-1.6932107e-016+dpu0n_lvt                       ua=-1.1847872e-009
+ lua=5.3970347e-17+dluan_lvt                         wua=1.3707458e-016
+ pua=-7.6329457e-24+dpuan_lvt                        ub=2.7343569e-018
+ lub=-3.6503636e-26+dlubn_lvt                        wub=2.0616402e-025
+ pub=-1.4444351e-32+dpubn_lvt                        uc=-2.1671029e-010
+ luc=2.3397353e-017        wuc=6.2793945e-017        puc=-4.9079748e-024
+ vsat=95273.906+dvsatn_lvt kvsat=1                   a0=2.0767317
+ la0=-7.2078468e-008+dla0n_lvt                       wa0=-1.2680404e-007+dwa0n_lvt
+ pa0=5.1976974e-015+dpa0n_lvt                        ags=1.7668168+dagsn_lvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.2092866-0.0333408*ss_flag_lvt
+ lketa=1.2276263e-008+2.60592e-09*ss_flag_lvt        wketa=8.7127608e-009+1.05357e-08*ss_flag_lvt
+ pketa=-6.8098938e-016-8.23468e-16*ss_flag_lvt       dwg=0
+ dwb=0                     pclm=-0.075743781+dpclmn_lvt+0.0813418*ss_flag_lvt
+ lpclm=8.4659017e-009-6.35766e-09*ss_flag_lvt        wpclm=9.1946424e-009-1.10625e-08*ss_flag_lvt
+ ppclm=8.4736387e-017+dppclmn_lvt+8.64641e-16*ss_flag_lvt
+ pdiblc1=0                 pdiblc2=0.005             pdiblcb=-0.037159959
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.70129737          pditsd=0.6367075          pditsl=977352.75
+ rsh=16                    rsw=45+drdswn_lvt         rdw=45+drdswn_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=9.96e-008          alpha1=1.252              beta0=13.29
+ agidl=1.7376647e-008      bgidl=1.3887812e+009      cgidl=1.4802648
+ egidl=0.81976             aigbacc=0.012866428       bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010985             bigc=0.0016755
+ cigc=0                    aigsd=0.009264            bigsd=0.001144168
+ cigsd=0.087095398         nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_lvt             cgdo=cgon_lvt
+ cgbo=0                    cgdl=cgln_lvt             cgsl=cgln_lvt
+ clc=1e-007                cle=0.6                   cf=cfn_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=10.65                noff=2.526                voffcv=-0.19263
+ kt1=-0.22595013+0.00666816*ff_flag_lvt              lkt1=-5.8411769e-009+dlkt1n_lvt-5.21182e-10*ff_flag_lvt
+ wkt1=-6.1185981e-009+dwkt1n_lvt-2.10714e-09*ff_flag_lvt
+ pkt1=2.7062818e-016+dpkt1n_lvt+1.64694e-16*ff_flag_lvt
+ kt1l=0                    kt2=-0.066808211          lkt2=7.2016404e-010
+ wkt2=-5.6046496e-010      pkt2=-5.7018736e-017      ute=-1
+ ua1=-1.3956637e-009       lua1=1.4787977e-016       wua1=1.5711291e-015
+ pua1=-7.4926728e-023      ub1=1.4788549e-018        lub1=-8.1142176e-026
+ wub1=-1.7024205e-024      pub1=7.1483305e-032       uc1=8.525948e-010
+ luc1=-3.3104487e-017      wuc1=-7.1130199e-017      puc1=2.9156269e-024
+ prt=0                     at=112697.96+datn_lvt     lat=-0.0033312+dlatn_lvt
+ wat=-0.018169367+dwatn_lvt                          pat=8.6255286e-010+dpatn_lvt
+ jss=1.368e-07             jsd=1.368e-07             jsws=1.828e-13
+ jswd=1.828e-13            jswgs=1.828e-13           jswgd=1.828e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.05                  bvd=9.05                  xjbvs=1
+ xjbvd=1                   pbs=0.73                  pbd=0.73
+ cjs=cjn_lvt               cjd=cjn_lvt               mjs=0.31
+ mjd=0.31                  pbsws=1                   pbswd=1
+ cjsws=cjswn_lvt           cjswd=cjswn_lvt           mjsws=0.08
+ mjswd=0.08                pbswgs=0.48               pbswgd=0.48
+ cjswgs=cjswgn_lvt         cjswgd=cjswgn_lvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.60e-03              tcj=7.5e-04
+ tpbsw=1.0e-04             tcjsw=9e-04               tpbswg=1e-04
+ tcjswg=5.9e-03            xtis=3                    xtid=3
+ jtsswgs=1.99e-010         jtsswgd=1.99e-010         njtsswg=4.876362
+ xtsswgs=-0.1076           xtsswgd=-0.1076           tnjtsswg=-0.5
+ vtsswgs=20                vtsswgd=20                dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lnfactor=0+dlnfactorn_lvt wnfactor=0+dwnfactorn_lvt pnfactor=0+dpnfactorn_lvt
+ leta0=0+dleta0n_lvt-5.60079e-10*ff_flag_lvt+1.6651e-09*ss_flag_lvt
+ weta0=0+dweta0n_lvt-9.74552e-10*ff_flag_lvt+2.89732e-09*ss_flag_lvt
+ peta0=0+dpeta0n_lvt+7.61708e-17*ff_flag_lvt-2.26454e-16*ss_flag_lvt
+ lvsat=0+dlvsatn_lvt       wvsat=0+dwvsatn_lvt       pvsat=0+dpvsatn_lvt
+ lags=0+dlagsn_lvt         pags=0+dpagsn_lvt         wags=0+dwagsn_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.00345           pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0022
+ pku0we=-0.65e-17          wku0we=-4.5e-10           lku0we=1.55e-10
+ k2we=0.00077              pk2we=0.025e-17           wk2we=-0.2e-10
+ lk2we=-1.6e-11            fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_lvt
+ noib=noibn_lvt            noic=noicn_lvt            em=1.5e+7
+ ef=1                    lintnoi=0                 minr=1e-3
 
// *********************************************************************************************
//                                                                            
//                   *
//                                      1.0V DEVICE MODELS                    
//                   *
//                                                                            
//                   *
// *********************************************************************************************
     } 
model pch_lvt bsim4  { 
     1: type=p 
+ lmin=9.999993e-006-dxlp_lvt                         lmax=2.00001e-05
+ wmin=1e-005-dxwp_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=2.134663e-08+ddlcp_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.196+dvthp_lvt     k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.014655313+dk2p_lvt   k3=-1.2549878
+ k3b=0.79294122            w0=0                      dvt0=2.5
+ dvt1=1                    dvt2=0.0012               dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=4.756553e-008
+ dvtp1=3.3913851           lpe0=1.9366257e-007       lpeb=2.5e-009
+ xj=1.1e-007               ngate=1.3715e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0003
+ voff=-0.14081379+dvoffp_lvt                         nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.2375+deta0p_lvt    etab=-0.22                u0=0.017700335+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           ua=2.4992422e-009         ub=3.5779305e-019
+ uc=-2.1448581e-011+ducp_lvt                         pub=0+dpubp_lvt
+ lub=0+dlubp_lvt           pua=0+dpuap_lvt           lua=0+dluap_lvt
+ vsat=88638+dvsatp_lvt     a0=5.7269429+da0p_lvt     kvsat=1
+ ags=1.244406+dagsp_lvt    a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=0.0092283888+dketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11422+dpclmp_lvt
+ pdiblc1=0                 pdiblc2=0.0038307602      pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.19821009           kt1l=0                    kt2=-0.05053046
+ ute=-1                    ua1=2.9310296e-009        ub1=-1.4940392e-018
+ uc1=1.35e-011+duc1p_lvt   prt=0                     at=150000
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wk2=0+dwk2p_lvt           weta0=0+dweta0p_lvt       wu0=0+dwu0p_lvt
+ wags=0+dwagsp_lvt         pketa=0+dpketap_lvt       lketa=0+dlketap_lvt
+ wketa=0+dwketap_lvt       lk2=0+dlk2p_lvt           pk2=0+dpk2p_lvt
+ lu0=0+dlu0p_lvt           pu0=0+dpu0p_lvt           lags=0+dlagsp_lvt
+ pags=0+dpagsp_lvt         la0=0+dla0p_lvt           wa0=0+dwa0p_lvt
+ pa0=0+dpa0p_lvt           lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt
+ pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt
+ pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt
+ lvsat=0+dlvsatp_lvt       wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt
+ lpclm=0+dlpclmp_lvt       wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt
+ lvoff=0+dlvoffp_lvt       wvoff=0+dwvoffp_lvt       pvoff=0+dpvoffp_lvt
+ lcit=0+dlcitp_lvt         wcit=0+dwcitp_lvt         pcit=0+dpcitp_lvt
+ lat=0+dlatp_lvt           wat=0+dwatp_lvt           pat=0+dpatp_lvt
+ lkt1=0+dlkt1p_lvt         wkt1=0+dwkt1p_lvt         pkt1=0+dpkt1p_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_lvt            noib=noibp_lvt
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     2: type=p 
+ lmin=9.999933e-007-dxlp_lvt                         lmax=9.999993e-006-dxlp_lvt
+ wmin=1e-005-dxwp_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=2.134663e-08+ddlcp_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.196+dvthp_lvt     k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.014440749+dk2p_lvt   lk2=2.1341405e-009+dlk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00028948444         lcit=1.0459192e-010+dlcitp_lvt
+ voff=-0.14448518+dvoffp_lvt                         lvoff=3.6517133e-008+dlvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.2375+deta0p_lvt
+ etab=-0.22                u0=0.0179201+du0p_lvt     ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-2.1858721e-009+dlu0p_lvt                       ua=2.5211134e-009
+ pua=0+dpuap_lvt           lua=-2.1753942e-16+dluap_lvt
+ ub=3.5634845e-019         pub=0+dpubp_lvt           lub=1.4368575e-26+dlubp_lvt
+ uc=-2.0652658e-011+ducp_lvt                         luc=-7.9165688e-018
+ vsat=88638+dvsatp_lvt     a0=5.8779195+da0p_lvt     kvsat=1
+ la0=-1.5016736e-006+dla0p_lvt                       ags=1.2064066+dagsp_lvt
+ lags=3.7795679e-007+dlagsp_lvt                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.013582582+dketap_lvt                         lketa=-4.3308548e-008+dlketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11422+dpclmp_lvt
+ pdiblc1=0                 pdiblc2=0.0037242779      lpdiblc2=1.0591155e-009
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.96                pditsd=0.8613
+ pditsl=350000             rsh=15.5                  rsw=110+drdswp_lvt
+ rdw=110+drdswp_lvt        prwg=0                    prwb=0
+ wr=1                      alpha0=6.33e-009          alpha1=0.017727
+ beta0=14.154              agidl=1e-008              bgidl=3e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.013008
+ bigbacc=0.0062797         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0065469
+ bigc=0.000931576          cigc=0                    aigsd=0.0049844
+ bigsd=0.000394153         cigsd=0.039059            nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_lvt
+ cgdo=cgop_lvt             cgbo=0                    cgdl=cglp_lvt
+ cgsl=cglp_lvt             clc=1e-007                cle=0.6
+ cf=cfp_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=6.8311               noff=3.1615
+ voffcv=-0.16125           kt1=-0.19410758           lkt1=-4.0805209e-008+dlkt1p_lvt
+ kt1l=0                    kt2=-0.049708602          lkt2=-8.1745269e-009
+ ute=-1                    ua1=2.9245385e-009        lua1=6.4563443e-017
+ ub1=-1.3820907e-018       lub1=-1.113484e-024       uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             wk2=0+dwk2p_lvt
+ weta0=0+dweta0p_lvt       wu0=0+dwu0p_lvt           wags=0+dwagsp_lvt
+ pketa=0+dpketap_lvt       wketa=0+dwketap_lvt       pk2=0+dpk2p_lvt
+ pu0=0+dpu0p_lvt           pags=0+dpagsp_lvt         wa0=0+dwa0p_lvt
+ pa0=0+dpa0p_lvt           lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt
+ pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt
+ pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt
+ lvsat=0+dlvsatp_lvt       wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt
+ lpclm=0+dlpclmp_lvt       wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt
+ wvoff=0+dwvoffp_lvt       pvoff=0+dpvoffp_lvt       wcit=0+dwcitp_lvt
+ pcit=0+dpcitp_lvt         lat=0+dlatp_lvt           wat=0+dwatp_lvt
+ pat=0+dpatp_lvt           wkt1=0+dwkt1p_lvt         pkt1=0+dpkt1p_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_lvt            noib=noibp_lvt
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     3: type=p 
+ lmin=2.39995e-007-dxlp_lvt                          lmax=9.999933e-007-dxlp_lvt
+ wmin=1e-005-dxwp_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=5.0965e-03             wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=5.0965e-03
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=1.25625e-09+ddlcp_lvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+dvthp_lvt     k1=0.12944                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.33e-8
+ k2=0.015052427+dk2p_lvt   lk2=1.5552489e-009+dlk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00026867906        lcit=6.3283787e-010+dlcitp_lvt
+ voff=-0.10662092+dvoffp_lvt                         lvoff=6.8238952e-010+dlvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.2375+deta0p_lvt
+ etab=-0.22                u0=0.01649673+du0p_lvt    ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-8.3879529e-010+dlu0p_lvt                       ua=2.5573579e-009
+ pua=0+dpuap_lvt           lua=-2.5184118e-16+dluap_lvt
+ ub=2.683863e-019          pub=0+dpubp_lvt           lub=9.7615951e-26+dlubp_lvt
+ uc=-4.7205895e-011+ducp_lvt                         luc=1.7213415e-017
+ vsat=88638+dvsatp_lvt     a0=4.7205348+da0p_lvt     kvsat=1
+ la0=-4.0632475e-007+dla0p_lvt                       ags=0.60344514+dagsp_lvt
+ lags=9.4859955e-007+dlagsp_lvt                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.012144968+dketap_lvt                        lketa=-1.8959995e-008+dlketap_lvt
+ dwg=0                     dwb=0                     pclm=0.10385767+dpclmp_lvt
+ lpclm=9.8069093e-009+dlpclmp_lvt                    pdiblc1=0
+ pdiblc2=0.0048698799      lpdiblc2=-2.5082236e-011  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.22724817           lkt1=-9.4409558e-009+dlkt1p_lvt
+ kt1l=0                    kt2=-0.058968557          lkt2=5.8909467e-010
+ ute=-1                    ua1=2.3998367e-009        lua1=5.6114125e-016
+ ub1=-9.7934183e-019       lub1=-1.4946456e-024      uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=155020.36              lat=-0.0047512692+dlatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wk2=0+dwk2p_lvt           weta0=0+dweta0p_lvt       wu0=0+dwu0p_lvt
+ wags=0+dwagsp_lvt         pketa=0+dpketap_lvt       wketa=0+dwketap_lvt
+ pk2=0+dpk2p_lvt           pu0=0+dpu0p_lvt           pags=0+dpagsp_lvt
+ wa0=0+dwa0p_lvt           pa0=0+dpa0p_lvt           lvth0=0+dlvthp_lvt
+ wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt
+ peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt       wvsat=0+dwvsatp_lvt
+ pvsat=0+dpvsatp_lvt       wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt
+ wvoff=0+dwvoffp_lvt       pvoff=0+dpvoffp_lvt       wcit=0+dwcitp_lvt
+ pcit=0+dpcitp_lvt         wat=0+dwatp_lvt           pat=0+dpatp_lvt
+ wkt1=0+dwkt1p_lvt         pkt1=0+dpkt1p_lvt         saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0127             pku0we=1.1e-17
+ wku0we=-4.5e-10           lku0we=-0.3e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_lvt            noib=noibp_lvt            noic=noicp_lvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     4: type=p 
+ lmin=9.99969e-008-dxlp_lvt                          lmax=2.39995e-007-dxlp_lvt
+ wmin=1e-005-dxwp_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=1.25625e-09+ddlcp_lvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+dvthp_lvt     k1=0.12944                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.33e-8
+ k2=0.020837232+dk2p_lvt   lk2=3.0683011e-010+dlk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0010732882          lcit=3.432279e-010+dlcitp_lvt
+ voff=-0.090282677+dvoffp_lvt                        lvoff=-2.8435657e-009+dlvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.2375+deta0p_lvt
+ etab=-0.22                u0=0.013175596+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-1.2206117e-010+dlu0p_lvt                       ua=1.6141353e-009
+ pua=0+dpuap_lvt           lua=-4.8284323e-17+dluap_lvt
+ ub=6.6748756e-019         pub=0+dpubp_lvt           lub=1.1485908e-26+dlubp_lvt
+ uc=3.3650438e-011+ducp_lvt                          luc=-2.361906e-019
+ vsat=88638+dvsatp_lvt     a0=4.0239646+da0p_lvt     kvsat=1
+ la0=-2.5599793e-007+dla0p_lvt                       ags=4.4079802+dagsp_lvt
+ lags=1.2754284e-007+dlagsp_lvt                      a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.16125682+dketap_lvt                         lketa=1.3219834e-008+dlketap_lvt
+ dwg=0                     dwb=0                     pclm=-0.011359358+dpclmp_lvt
+ lpclm=3.4671896e-008+dlpclmp_lvt                    pdiblc1=0
+ pdiblc2=-0.0019194443     lpdiblc2=1.4401218e-009   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.26344664           lkt1=-1.6289637e-009+dlkt1p_lvt
+ kt1l=0                    kt2=-0.060060597          lkt2=8.2476773e-010
+ ute=-1                    ua1=6.5511741e-009        lua1=-3.3475889e-016
+ ub1=-1.0939103e-017       lub1=6.547704e-025        uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=189130.23              lat=-0.01211252+dlatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wk2=0+dwk2p_lvt           weta0=0+dweta0p_lvt       wu0=0+dwu0p_lvt
+ wags=0+dwagsp_lvt         pketa=0+dpketap_lvt       wketa=0+dwketap_lvt
+ pk2=0+dpk2p_lvt           pu0=0+dpu0p_lvt           pags=0+dpagsp_lvt
+ wa0=0+dwa0p_lvt           pa0=0+dpa0p_lvt           lvth0=0+dlvthp_lvt
+ wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt
+ peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt       wvsat=0+dwvsatp_lvt
+ pvsat=0+dpvsatp_lvt       wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt
+ wvoff=0+dwvoffp_lvt       pvoff=0+dpvoffp_lvt       wcit=0+dwcitp_lvt
+ pcit=0+dpcitp_lvt         wat=0+dwatp_lvt           pat=0+dpatp_lvt
+ wkt1=0+dwkt1p_lvt         pkt1=0+dpkt1p_lvt         saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0127             pku0we=1.1e-17
+ wku0we=-4.5e-10           lku0we=-0.3e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_lvt            noib=noibp_lvt            noic=noicp_lvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     5: type=p 
+ lmin=6e-08                lmax=9.99969e-008-dxlp_lvt
+ wmin=1e-005-dxwp_lvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=1.25625e-09+ddlcp_lvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+dvthp_lvt     k1=0.12944                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.33e-8
+ k2=0.019687608+dk2p_lvt   lk2=4.0107626e-010+dlk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00016502731+0.00461006*ff_flag_lvt+0.00184402*sf_flag_lvt-0.00184402*fs_flag_lvt
+ lcit=4.4474501e-010+dlcitp_lvt-3.77932e-10*ff_flag_lvt-1.51173e-10*sf_flag_lvt+1.51173e-10*fs_flag_lvt
+ voff=-0.074057745+dvoffp_lvt                        lvoff=-4.1736856e-009+dlvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.23750228+deta0p_lvt-0.00576257*ss_flag_lvt
+ leta0=-1.8684815e-013+dleta0p_lvt+4.72415e-10*ss_flag_lvt
+ etab=-0.40744873          letab=1.5367047e-008      u0=0.013427797+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-1.4273668e-010+dlu0p_lvt
+ ua=1.1145985e-009         pua=0+dpuap_lvt           lua=-7.3322957e-18+dluap_lvt
+ ub=1.2862636e-018         pub=0+dpubp_lvt           lub=-3.924135e-26+dlubp_lvt
+ uc=6.3894311e-011+ducp_lvt                          luc=-2.7155833e-018
+ vsat=97830.149+dvsatp_lvt kvsat=1                   lvsat=-0.00075357239+dlvsatp_lvt
+ a0=-5.2577529+da0p_lvt    la0=5.0491727e-007+dla0p_lvt
+ ags=12.014+dagsp_lvt-0.806759*ff_flag_lvt           lags=-4.9599865e-007+dlagsp_lvt+6.61381e-08*ff_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.037242837+dketap_lvt
+ lketa=3.0531678e-009+dlketap_lvt                    dwg=0
+ dwb=0                     pclm=0.57077219+dpclmp_lvt-0.0115251*ff_flag_lvt-0.00922011*sf_flag_lvt+0.00922011*fs_flag_lvt
+ lpclm=-1.3051248e-008+dlpclmp_lvt+9.4483e-10*ff_flag_lvt+7.55864e-10*sf_flag_lvt-7.55864e-10*fs_flag_lvt
+ pdiblc1=0                 pdiblc2=0.017470255       lpdiblc2=-1.4944572e-010
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.96                pditsd=0.8613
+ pditsl=350000             rsh=15.5                  rsw=110+drdswp_lvt
+ rdw=110+drdswp_lvt        prwg=0                    prwb=0
+ wr=1                      alpha0=6.33e-009          alpha1=0.017727
+ beta0=14.154              agidl=1e-008              bgidl=3e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.013008
+ bigbacc=0.0062797         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0065469
+ bigc=0.000931576          cigc=0                    aigsd=0.0049844
+ bigsd=0.000394153         cigsd=0.039059            nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_lvt
+ cgdo=cgop_lvt             cgbo=0                    cgdl=cglp_lvt
+ cgsl=cglp_lvt             clc=1e-007                cle=0.6
+ cf=cfp_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=6.8311               noff=3.1615
+ voffcv=-0.16125           kt1=-0.24954942-0.0345754*ff_flag_lvt-0.0184402*sf_flag_lvt+0.0184402*fs_flag_lvt
+ lkt1=-2.768258e-009+dlkt1p_lvt+2.83449e-09*ff_flag_lvt+1.51173e-09*sf_flag_lvt-1.51173e-09*fs_flag_lvt
+ kt1l=0                    kt2=-0.05                 ute=-1
+ ua1=2.8986322e-009        lua1=-3.53235e-017        ub1=-2.9733102e-018
+ lub1=1.7347396e-027       uc1=1.35e-011+duc1p_lvt   prt=0
+ at=48962.171              lat=-0.00062154262+dlatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wk2=0+dwk2p_lvt           weta0=0+dweta0p_lvt+0.0*ss_flag_lvt
+ wu0=0+dwu0p_lvt           wags=0+dwagsp_lvt+0.0*ff_flag_lvt
+ pketa=0+dpketap_lvt       wketa=0+dwketap_lvt       pk2=0+dpk2p_lvt
+ pu0=0+dpu0p_lvt           pags=0+dpagsp_lvt+0.0*ff_flag_lvt
+ wa0=0+dwa0p_lvt           pa0=0+dpa0p_lvt           lvth0=0+dlvthp_lvt
+ wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt peta0=0+dpeta0p_lvt+0.0*ss_flag_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       wpclm=0+dwpclmp_lvt+0.0*ff_flag_lvt+0.0*sf_flag_lvt+0.0*fs_flag_lvt
+ ppclm=0+dppclmp_lvt+0.0*ff_flag_lvt+0.0*sf_flag_lvt+0.0*fs_flag_lvt
+ wvoff=0+dwvoffp_lvt       pvoff=0+dpvoffp_lvt       wcit=0+dwcitp_lvt+0.0*ff_flag_lvt+0.0*sf_flag_lvt+0.0*fs_flag_lvt
+ pcit=0+dpcitp_lvt+0.0*ff_flag_lvt+0.0*sf_flag_lvt+0.0*fs_flag_lvt
+ wat=0+dwatp_lvt           pat=0+dpatp_lvt           wkt1=0+dwkt1p_lvt+0.0*ff_flag_lvt+0.0*sf_flag_lvt+0.0*fs_flag_lvt
+ pkt1=0+dpkt1p_lvt+0.0*ff_flag_lvt+0.0*sf_flag_lvt+0.0*fs_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_lvt            noib=noibp_lvt
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     6: type=p 
+ lmin=9.999993e-006-dxlp_lvt                         lmax=2.00001e-05
+ wmin=1e-006-dxwp_lvt      wmax=1e-005-dxwp_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=2.134663e-08+ddlcp_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.196+dvthp_lvt     k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.014870348+dk2p_lvt   wk2=-2.15379e-009+dwk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0003                voff=-0.1403536+dvoffp_lvt
+ wvoff=-4.6093103e-009+dwvoffp_lvt                   nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.23608889+deta0p_lvt                          weta0=1.4133689e-008+dweta0p_lvt
+ etab=-0.22112889          wetab=1.1306951e-008      u0=0.017680401+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=1.9965645e-010+dwu0p_lvt
+ ua=2.5572557e-009         wua=-5.8106309e-016       ub=3.3420342e-019
+ pub=0+dpubp_lvt           lub=0+dlubp_lvt           pua=0+dpuap_lvt
+ lua=0+dluap_lvt           wub=2.362737e-025         uc=-2.2061323e-011+ducp_lvt
+ wuc=6.1372198e-018        vsat=88638+dvsatp_lvt     a0=5.7467079+da0p_lvt
+ kvsat=1                   wa0=-1.9796618e-007+dwa0p_lvt
+ ags=1.2477982+dagsp_lvt   wags=-3.3976076e-008+dwagsp_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=0.0086897269+dketap_lvt
+ wketa=5.3952375e-009+dwketap_lvt                    dwg=0
+ dwb=0                     pclm=0.11422+dpclmp_lvt   pdiblc1=0
+ pdiblc2=0.0039319564      wpdiblc2=-1.0135808e-009  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.19772819           wkt1=-4.8267192e-009+dwkt1p_lvt
+ kt1l=0                    kt2=-0.05005631           wkt2=-4.7490853e-009
+ ute=-1                    ua1=2.9422688e-009        wua1=-1.1257159e-016
+ ub1=-1.5406768e-018       wub1=4.6712251e-025       uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             pketa=0+dpketap_lvt
+ lketa=0+dlketap_lvt       lk2=0+dlk2p_lvt           pk2=0+dpk2p_lvt
+ lu0=0+dlu0p_lvt           pu0=0+dpu0p_lvt           lags=0+dlagsp_lvt
+ pags=0+dpagsp_lvt         la0=0+dla0p_lvt           pa0=0+dpa0p_lvt
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       lpclm=0+dlpclmp_lvt
+ wpclm=0+dwpclmp_lvt       ppclm=0+dppclmp_lvt       lvoff=0+dlvoffp_lvt
+ pvoff=0+dpvoffp_lvt       lcit=0+dlcitp_lvt         wcit=0+dwcitp_lvt
+ pcit=0+dpcitp_lvt         lat=0+dlatp_lvt           wat=0+dwatp_lvt
+ pat=0+dpatp_lvt           lkt1=0+dlkt1p_lvt         pkt1=0+dpkt1p_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_lvt            noib=noibp_lvt
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     7: type=p 
+ lmin=9.999933e-007-dxlp_lvt                         lmax=9.999993e-006-dxlp_lvt
+ wmin=1e-006-dxwp_lvt      wmax=1e-005-dxwp_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=2.134663e-08+ddlcp_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.196+dvthp_lvt     k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.014670566+dk2p_lvt   lk2=1.9871115e-009+dlk2p_lvt
+ wk2=-2.3018479e-009+dwk2p_lvt                       pk2=1.4726427e-015+dpk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00029067153         lcit=9.2784656e-011+dlcitp_lvt
+ wcit=-1.1889887e-011+dwcitp_lvt                     pcit=1.1826157e-016+dpcitp_lvt
+ voff=-0.1440645+dvoffp_lvt                          lvoff=3.6910176e-008+dlvoffp_lvt
+ wvoff=-4.2135163e-009+dwvoffp_lvt                   pvoff=-3.9367256e-015+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.23608889+deta0p_lvt
+ weta0=1.4133689e-008+dweta0p_lvt                    etab=-0.22112889
+ wetab=1.1306951e-008      u0=0.01789807+du0p_lvt    ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-2.165023e-009+dlu0p_lvt                        wu0=2.2065143e-010+dwu0p_lvt
+ pu0=-2.0882451e-016+dpu0p_lvt                       ua=2.5773859e-009
+ lua=-2.0022249e-16+dluap_lvt                        wua=-5.6362499e-016
+ pua=-1.7344633e-22+dpuap_lvt                        ub=3.3440934e-019
+ lub=-2.0481883e-27+dlubp_lvt                        wub=2.1974206e-025
+ pub=1.644303e-31+dpubp_lvt                          uc=-2.1175549e-011+ducp_lvt
+ luc=-8.8102615e-018       wuc=5.2372735e-018        puc=8.9512257e-024
+ vsat=88638+dvsatp_lvt     a0=5.9103376+da0p_lvt     kvsat=1
+ la0=-1.6275265e-006+dla0p_lvt                       wa0=-3.2469978e-007+dwa0p_lvt
+ pa0=1.2605431e-012+dpa0p_lvt                        ags=1.2072008+dagsp_lvt
+ lags=4.0379784e-007+dlagsp_lvt                      wags=-7.9541974e-009+dwagsp_lvt
+ pags=-2.5882402e-013+dpagsp_lvt                     a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.013131448+dketap_lvt                         lketa=-4.4179134e-008+dlketap_lvt
+ wketa=4.5185591e-009+dwketap_lvt                    pketa=8.7197939e-015+dpketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11421999+dpclmp_lvt
+ lpclm=1.1807266e-013+dlpclmp_lvt                    wpclm=1.1889887e-013+dwpclmp_lvt
+ ppclm=-1.1826157e-018+dppclmp_lvt                   pdiblc1=0
+ pdiblc2=0.0038882673      lpdiblc2=4.3454945e-010   wpdiblc2=-1.6425172e-009
+ ppdiblc2=6.2556531e-015   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.96
+ pditsd=0.8613             pditsl=350000             rsh=15.5
+ rsw=110+drdswp_lvt        rdw=110+drdswp_lvt        prwg=0
+ prwb=0                    wr=1                      alpha0=6.33e-009
+ alpha1=0.017727           beta0=14.154              agidl=1e-008
+ bgidl=3e+009              cgidl=0.225               egidl=0.8
+ aigbacc=0.013008          bigbacc=0.0062797         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0065469            bigc=0.000931576          cigc=0
+ aigsd=0.0049844           bigsd=0.000394153         cigsd=0.039059
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_lvt             cgdo=cgop_lvt             cgbo=0
+ cgdl=cglp_lvt             cgsl=cglp_lvt             clc=1e-007
+ cle=0.6                   cf=cfp_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=6.8311
+ noff=3.1615               voffcv=-0.16125           kt1=-0.19351421
+ lkt1=-4.1913937e-008+dlkt1p_lvt                     wkt1=-5.9432058e-009+dwkt1p_lvt
+ pkt1=1.1105022e-014+dpkt1p_lvt                      kt1l=0
+ kt2=-0.049208927          lkt2=-8.4284079e-009      wkt2=-5.0047428e-009
+ pkt2=2.5428716e-015       ute=-1                    ua1=2.9350449e-009
+ lua1=7.1851939e-017       wua1=-1.0523209e-016      pua1=-7.3001581e-023
+ ub1=-1.4302127e-018       lub1=-1.0987198e-024      wub1=4.8199001e-025
+ pub1=-1.4787809e-031      uc1=1.4305416e-011+duc1p_lvt
+ luc1=-8.0109937e-018      wuc1=-8.0670507e-018      puc1=8.0238113e-023
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_lvt
+ wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt
+ peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt       wvsat=0+dwvsatp_lvt
+ pvsat=0+dpvsatp_lvt       lat=0+dlatp_lvt           wat=0+dwatp_lvt
+ pat=0+dpatp_lvt           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0127             pku0we=1.1e-17            wku0we=-4.5e-10
+ lku0we=-0.3e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noiap_lvt
+ noib=noibp_lvt            noic=noicp_lvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     8: type=p 
+ lmin=2.39995e-007-dxlp_lvt                          lmax=9.999933e-007-dxlp_lvt
+ wmin=1e-006-dxwp_lvt      wmax=1e-005-dxwp_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=5.0965e-03             wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=5.0965e-03
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=1.25625e-09+ddlcp_lvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+dvthp_lvt     k1=0.12944                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.33e-8
+ k2=0.015125837+dk2p_lvt   lk2=1.5562428e-009+dlk2p_lvt
+ wk2=-7.3528308e-010+dwk2p_lvt                       pk2=-9.9542214e-018+dpk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00027493688        lcit=6.2807646e-010+dlcitp_lvt
+ wcit=6.26783e-011+dwcitp_lvt                        pcit=4.7690242e-017+dpcitp_lvt
+ voff=-0.10529981+dvoffp_lvt                         lvoff=2.2326988e-010+dlvoffp_lvt
+ wvoff=-1.3232185e-008+dwvoffp_lvt                   pvoff=4.5985423e-015+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.23608889+deta0p_lvt
+ weta0=1.4133689e-008+dweta0p_lvt                    etab=-0.22112889
+ wetab=1.1306951e-008      u0=0.01650593+du0p_lvt    ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-8.4750209e-010+dlu0p_lvt                       wu0=-9.2146299e-011+dwu0p_lvt
+ pu0=8.7207258e-017+dpu0p_lvt                        ua=2.644744e-009
+ lua=-2.6397026e-16+dluap_lvt                        wua=-8.7525984e-016
+ pua=1.214849e-22+dpuap_lvt                          ub=2.2255173e-019
+ lub=1.0381386e-25+dlubp_lvt                         wub=4.5907905e-025
+ pub=-6.2078228e-32+dpubp_lvt                        uc=-4.9732341e-011+ducp_lvt
+ luc=1.8215887e-017        wuc=2.5304884e-017        puc=-1.0040761e-023
+ vsat=88638+dvsatp_lvt     a0=4.5854854+da0p_lvt     kvsat=1
+ la0=-3.7368647e-007+dla0p_lvt                       wa0=1.3526545e-006+dwa0p_lvt
+ pa0=-3.2690502e-013+dpa0p_lvt                       ags=0.62405424+dagsp_lvt-0.0166732*ss_flag_lvt
+ lags=9.5568774e-007+dlagsp_lvt+1.57795e-08*ss_flag_lvt
+ wags=-2.0642073e-007+dwagsp_lvt+1.66999e-07*ss_flag_lvt
+ pags=-7.0995294e-014+dpagsp_lvt-1.58048e-13*ss_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.013793075+dketap_lvt
+ lketa=-1.8697765e-008+dlketap_lvt                   wketa=1.6507445e-008+dwketap_lvt
+ pketa=-2.6264882e-015+dpketap_lvt                   dwg=0
+ dwb=0                     pclm=0.10268802+dpclmp_lvt
+ lpclm=1.0913969e-008+dlpclmp_lvt                    wpclm=1.1715171e-008+dwpclmp_lvt
+ ppclm=-1.1088308e-014+dppclmp_lvt                   pdiblc1=0
+ pdiblc2=0.004215734       lpdiblc2=1.2463494e-010   wpdiblc2=6.5519253e-009
+ ppdiblc2=-1.4995673e-015  pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.96
+ pditsd=0.8613             pditsl=350000             rsh=15.5
+ rsw=110+drdswp_lvt        rdw=110+drdswp_lvt        prwg=0
+ prwb=0                    wr=1                      alpha0=6.33e-009
+ alpha1=0.017727           beta0=14.154              agidl=1e-008
+ bgidl=3e+009              cgidl=0.225               egidl=0.8
+ aigbacc=0.013008          bigbacc=0.0062797         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0065469            bigc=0.000931576          cigc=0
+ aigsd=0.0049844           bigsd=0.000394153         cigsd=0.039059
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_lvt             cgdo=cgop_lvt             cgbo=0
+ cgdl=cglp_lvt             cgsl=cglp_lvt             clc=1e-007
+ cle=0.6                   cf=cfp_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=6.8311
+ noff=3.1615               voffcv=-0.16125           kt1=-0.22800864
+ lkt1=-9.2684107e-009+dlkt1p_lvt                     wkt1=7.6168468e-009+dwkt1p_lvt
+ pkt1=-1.7282117e-015+dpkt1p_lvt                     kt1l=0
+ kt2=-0.058636862          lkt2=4.9418998e-010       wkt2=-3.3222552e-009
+ pkt2=9.5056531e-016       ute=-1                    ua1=2.4234228e-009
+ lua1=5.5605113e-016       wua1=-2.3623815e-016      pua1=5.0982555e-023
+ ub1=-1.011561e-018        lub1=-1.4949318e-024      wub1=3.2270725e-025
+ pub1=2.8671143e-033       uc1=3.9635521e-012+duc1p_lvt
+ luc1=1.7765467e-018       wuc1=9.5517062e-017       puc1=-1.7793892e-023
+ prt=0                     at=154741.17              lat=-0.0044870436+dlatp_lvt
+ wat=0.0027963686+dwatp_lvt                          pat=-2.6464832e-009+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ leta0=0+dleta0p_lvt       peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt
+ wvsat=0+dwvsatp_lvt       pvsat=0+dpvsatp_lvt       saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0127             pku0we=1.1e-17
+ wku0we=-4.5e-10           lku0we=-0.3e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_lvt            noib=noibp_lvt            noic=noicp_lvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     9: type=p 
+ lmin=9.99969e-008-dxlp_lvt                          lmax=2.39995e-007-dxlp_lvt
+ wmin=1e-006-dxwp_lvt      wmax=1e-005-dxwp_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=1.25625e-09+ddlcp_lvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+dvthp_lvt     k1=0.12944                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.33e-8
+ k2=0.021127501+dk2p_lvt   lk2=2.6102365e-010+dlk2p_lvt
+ wk2=-2.9073409e-009+dwk2p_lvt                       pk2=4.5879757e-016+dpk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00094368902         lcit=3.650848e-010+dlcitp_lvt
+ wcit=1.2980657e-009+dwcitp_lvt                      pcit=-2.1891872e-016+dpcitp_lvt
+ voff=-0.090711388+dvoffp_lvt                        lvoff=-2.9250576e-009+dlvoffp_lvt
+ wvoff=4.2939662e-009+dwvoffp_lvt                    pvoff=8.1622365e-016+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.23608889+deta0p_lvt
+ weta0=1.4133689e-008+dweta0p_lvt                    etab=-0.22112889
+ wetab=1.1306951e-008      u0=0.013109416+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-1.1450041e-010+dlu0p_lvt                       wu0=6.6285057e-010+dwu0p_lvt
+ pu0=-7.5728616e-017+dpu0p_lvt                       ua=1.6505414e-009
+ lua=-4.941139e-17+dluap_lvt                         wua=-3.6464314e-016
+ pua=1.128871e-23+dpuap_lvt                          ub=6.2358287e-019
+ lub=1.7267327e-26+dlubp_lvt                         wub=4.3974938e-025
+ pub=-5.7906692e-32+dpubp_lvt                        uc=3.5548571e-011+ducp_lvt
+ luc=-1.8858679e-019       wuc=-1.9011695e-017       puc=-4.7679978e-025
+ vsat=88638+dvsatp_lvt-276.608*ff_flag_lvt           kvsat=1
+ a0=4.0817486+da0p_lvt     la0=-2.6497503e-007+dla0p_lvt
+ wa0=-5.7876488e-007+dwa0p_lvt                       pa0=8.99146e-014+dpa0p_lvt
+ ags=4.2856317+dagsp_lvt+0.152135*ff_flag_lvt+0.0910205*ss_flag_lvt
+ lags=1.6548271e-007+dlagsp_lvt-3.28322e-08*ff_flag_lvt-7.46185e-09*ss_flag_lvt
+ wags=1.2254424e-006+dwagsp_lvt-1.52378e-06*ff_flag_lvt-9.11661e-07*ss_flag_lvt
+ pags=-3.8000568e-013+dpagsp_lvt+3.28847e-13*ff_flag_lvt+7.47379e-14*ss_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.16452+dketap_lvt  lketa=1.3830612e-008+dlketap_lvt
+ wketa=3.2683992e-008+dwketap_lvt                    pketa=-6.1175487e-015+dpketap_lvt
+ dwg=0                     dwb=0                     pclm=-0.012198486+dpclmp_lvt
+ lpclm=3.5707627e-008+dlpclmp_lvt                    wpclm=8.4047083e-009+dwpclmp_lvt
+ ppclm=-1.0373877e-014+dppclmp_lvt                   pdiblc1=0
+ pdiblc2=-0.0024892096     lpdiblc2=1.5716288e-009   wpdiblc2=5.7067696e-009
+ ppdiblc2=-1.3171742e-015  pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.96
+ pditsd=0.8613             pditsl=350000             rsh=15.5
+ rsw=110+drdswp_lvt        rdw=110+drdswp_lvt        prwg=0
+ prwb=0                    wr=1                      alpha0=6.33e-009
+ alpha1=0.017727           beta0=14.154              agidl=1e-008
+ bgidl=3e+009              cgidl=0.225               egidl=0.8
+ aigbacc=0.013008          bigbacc=0.0062797         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0065469            bigc=0.000931576          cigc=0
+ aigsd=0.0049844           bigsd=0.000394153         cigsd=0.039059
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp_lvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_lvt             cgdo=cgop_lvt             cgbo=0
+ cgdl=cglp_lvt             cgsl=cglp_lvt             clc=1e-007
+ cle=0.6                   cf=cfp_lvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=6.8311
+ noff=3.1615               voffcv=-0.16125           kt1=-0.26278052
+ lkt1=-1.7642908e-009+dlkt1p_lvt                     wkt1=-6.6718694e-009+dwkt1p_lvt
+ pkt1=1.3554361e-015+dpkt1p_lvt                      kt1l=0
+ kt2=-0.060926381          lkt2=9.8829105e-010       wkt2=8.6716974e-009
+ pkt2=-1.6378496e-015      ute=-1                    ua1=6.5412566e-009
+ lua1=-3.326186e-016       wua1=9.9333646e-017       pua1=-2.1437194e-023
+ ub1=-1.0993702e-017       lub1=6.5931411e-025       wub1=5.4687185e-025
+ pub1=-4.5509849e-032      uc1=1.2195546e-011+duc1p_lvt
+ wuc1=1.3065408e-017       prt=0                     at=190306.09
+ lat=-0.01216231+dlatp_lvt wat=-0.011777445+dwatp_lvt
+ pat=4.9869159e-010+dpatp_lvt                        jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03
+ tcjsw=2.50e-04            tpbswg=2.00e-03           tcjswg=1.30e-02
+ xtis=3                    xtid=3                    jtsswgs=2.555e-010
+ jtsswgd=2.555e-010        njtsswg=20.606963         xtsswgs=0.39
+ xtsswgd=0.39              tnjtsswg=0.636            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_lvt
+ wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt        lnfactor=0+dlnfactorp_lvt
+ wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt leta0=0+dleta0p_lvt
+ peta0=0+dpeta0p_lvt       lvsat=0+dlvsatp_lvt+5.96948e-05*ff_flag_lvt
+ wvsat=0+dwvsatp_lvt+0.00277051*ff_flag_lvt          pvsat=0+dpvsatp_lvt-5.97903e-10*ff_flag_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_lvt            noib=noibp_lvt
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     10: type=p 
+ lmin=6e-08                lmax=9.99969e-008-dxlp_lvt
+ wmin=1e-006-dxwp_lvt      wmax=1e-005-dxwp_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=1.25625e-09+ddlcp_lvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.196+dvthp_lvt     k1=0.12944                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0                  lkvth0=-4.33e-8
+ k2=0.019149407+dk2p_lvt   lk2=4.2318779e-010+dlk2p_lvt
+ wk2=5.3906181e-009+dwk2p_lvt                        pk2=-2.214691e-016+dpk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00020647166+0.00487027*ff_flag_lvt+0.00184402*sf_flag_lvt-0.00184402*fs_flag_lvt
+ lcit=4.5937498e-010+dlcitp_lvt-3.99264e-10*ff_flag_lvt-1.51172e-10*sf_flag_lvt+1.51172e-10*fs_flag_lvt
+ wcit=4.1510657e-010+dwcitp_lvt-2.60628e-09*ff_flag_lvt-4.2e-15*sf_flag_lvt+4.2e-15*fs_flag_lvt
+ pcit=-1.4653373e-016+dpcitp_lvt+2.13663e-16*ff_flag_lvt-3e-22*sf_flag_lvt+3e-22*fs_flag_lvt
+ voff=-0.075009725+dvoffp_lvt                        lvoff=-4.21228e-009+dlvoffp_lvt
+ wvoff=9.5350271e-009+dwvoffp_lvt                    pvoff=3.8656148e-016+dpvoffp_lvt
+ nfactor=0.52253992+dnfactorp_lvt                    eta0=0.23609143+deta0p_lvt-0.00511204*ss_flag_lvt-3.90318e-05*ff_flag_lvt
+ leta0=-2.0794123e-013+dleta0p_lvt+4.19084e-10*ss_flag_lvt+3.19982e-12*ff_flag_lvt
+ weta0=1.4131112e-008+dweta0p_lvt-6.5157e-09*ss_flag_lvt+3.90942e-10*ff_flag_lvt
+ peta0=2.1126829e-019+dpeta0p_lvt+5.34157e-16*ss_flag_lvt-3.20494e-17*ff_flag_lvt
+ etab=-0.40948418          letab=1.5441367e-008      wetab=2.0387044e-008
+ petab=-7.44386e-016       u0=0.013226177+du0p_lvt   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ lu0=-1.2407244e-010+dlu0p_lvt                       wu0=2.01943e-009+dwu0p_lvt
+ pu0=-1.8694099e-016+dpu0p_lvt                       ua=1.0811737e-009
+ lua=-2.734628e-18+dluap_lvt                         wua=3.3478294e-016
+ pua=-4.605024e-23+dpuap_lvt                         ub=1.3282782e-018
+ lub=-4.0503597e-26+dlubp_lvt                        wub=-4.2081853e-025
+ pub=1.2642665e-32+dpubp_lvt                         uc=6.9352185e-011+ducp_lvt
+ luc=-2.9598071e-018       wuc=-5.4666062e-017       puc=2.4461452e-024
+ vsat=97611.081+dvsatp_lvt+1037.03*ff_flag_lvt-390.318*ss_flag_lvt
+ kvsat=1                   lvsat=-0.00073561318+dlvsatp_lvt-4.79974e-05*ff_flag_lvt+3.19982e-05*ss_flag_lvt
+ wvsat=0.0021941872+dwvsatp_lvt-0.0103869*ff_flag_lvt+0.00390942*ss_flag_lvt
+ pvsat=-1.7987946e-010+dpvsatp_lvt+4.80741e-10*ff_flag_lvt-3.20494e-10*ss_flag_lvt
+ a0=-5.2983455+da0p_lvt    la0=5.0400509e-007+dla0p_lvt
+ wa0=4.0657561e-007+dwa0p_lvt                        pa0=9.136387e-015+dpa0p_lvt
+ ags=12.750419+dagsp_lvt-0.781892*ff_flag_lvt-0.195159*ss_flag_lvt
+ lags=-5.2846053e-007+dlagsp_lvt+4.37393e-08*ff_flag_lvt+1.59991e-08*ss_flag_lvt
+ wags=-7.3759708e-006+dwagsp_lvt-2.4907e-07*ff_flag_lvt+1.95471e-06*ss_flag_lvt
+ pags=3.2513818e-013+dpagsp_lvt+2.24346e-13*ff_flag_lvt-1.60247e-13*ss_flag_lvt
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.028314376+dketap_lvt
+ lketa=2.6644748e-009+dlketap_lvt                    wketa=-8.9427467e-008+dwketap_lvt
+ pketa=3.8931487e-015+dpketap_lvt                    dwg=0
+ dwb=0                     pclm=0.58345617+dpclmp_lvt-0.0111348*ff_flag_lvt-0.00260212*ss_flag_lvt-0.010261*sf_flag_lvt+0.010261*fs_flag_lvt
+ lpclm=-1.3124142e-008+dlpclmp_lvt+9.12832e-10*ff_flag_lvt+2.13322e-10*ss_flag_lvt+8.41192e-10*sf_flag_lvt-8.41192e-10*fs_flag_lvt
+ wpclm=-1.2704271e-007+dwpclmp_lvt-3.90939e-09*ff_flag_lvt+2.60628e-08*ss_flag_lvt+1.04251e-08*sf_flag_lvt-1.04251e-08*fs_flag_lvt
+ ppclm=7.3010221e-016+dppclmp_lvt+3.20496e-16*ff_flag_lvt-2.13663e-15*ss_flag_lvt-8.54651e-16*sf_flag_lvt+8.54651e-16*fs_flag_lvt
+ pdiblc1=0                 pdiblc2=0.018500369       lpdiblc2=-1.4909685e-010
+ wpdiblc2=-1.0317626e-008  ppdiblc2=-3.4942387e-018  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.96                pditsd=0.8613             pditsl=350000
+ rsh=15.5                  rsw=110+drdswp_lvt        rdw=110+drdswp_lvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=6.33e-009          alpha1=0.017727           beta0=14.154
+ agidl=1e-008              bgidl=3e+009              cgidl=0.225
+ egidl=0.8                 aigbacc=0.013008          bigbacc=0.0062797
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0065469            bigc=0.000931576
+ cigc=0                    aigsd=0.0049844           bigsd=0.000394153
+ cigsd=0.039059            nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp_lvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_lvt             cgdo=cgop_lvt
+ cgbo=0                    cgdl=cglp_lvt             cgsl=cglp_lvt
+ clc=1e-007                cle=0.6                   cf=cfp_lvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=6.8311               noff=3.1615               voffcv=-0.16125
+ kt1=-0.25061759-0.0358765*ff_flag_lvt-0.0184402*sf_flag_lvt+0.0184402*fs_flag_lvt
+ lkt1=-2.7614076e-009+dlkt1p_lvt+2.94115e-09*ff_flag_lvt+1.51172e-09*sf_flag_lvt-1.51172e-09*fs_flag_lvt
+ wkt1=1.0698829e-008+dwkt1p_lvt+1.30314e-08*ff_flag_lvt+4.2e-14*sf_flag_lvt-4.2e-14*fs_flag_lvt
+ pkt1=-6.8613704e-017+dpkt1p_lvt-1.06831e-15*ff_flag_lvt+3e-21*sf_flag_lvt-3e-21*fs_flag_lvt
+ kt1l=0                    kt2=-0.048220718          lkt2=-5.3319212e-011
+ wkt2=-1.7821287e-008      pkt2=5.3404523e-016       ute=-1
+ ua1=2.9297332e-009        lua1=-3.6545906e-017      wua1=-3.1150817e-016
+ pua1=1.2243618e-023       ub1=-2.977511e-018        lub1=2.1467478e-027
+ wub1=4.2075867e-026       pub1=-4.1266743e-033      uc1=1.4872525e-011+duc1p_lvt
+ luc1=-2.1945868e-019      wuc1=-1.3747206e-017      puc1=2.1980981e-024
+ prt=0                     at=49011.771              lat=-0.00057900105+dlatp_lvt
+ wat=-0.0004967923+dwatp_lvt                         pat=-4.2609636e-010+dpatp_lvt
+ jss=1.53e-07              jsd=1.53e-07              jsws=4.96e-13
+ jswd=4.96e-13             jswgs=4.96e-13            jswgd=4.96e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.68                  bvd=9.68                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_lvt               cjd=cjp_lvt               mjs=0.31
+ mjd=0.31                  pbsws=0.75                pbswd=0.75
+ cjsws=cjswp_lvt           cjswd=cjswp_lvt           mjsws=0.025
+ mjswd=0.025               pbswgs=0.49               pbswgd=0.49
+ cjswgs=cjswgp_lvt         cjswgd=cjswgp_lvt         mjswgs=0.97
+ mjswgd=0.97               tpb=1.55e-03              tcj=8.70e-04
+ tpbsw=5.00e-03            tcjsw=2.50e-04            tpbswg=2.00e-03
+ tcjswg=1.30e-02           xtis=3                    xtid=3
+ jtsswgs=2.555e-010        jtsswgd=2.555e-010        njtsswg=20.606963
+ xtsswgs=0.39              xtsswgd=0.39              tnjtsswg=0.636
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_lvt        wvth0=0+dwvthp_lvt        pvth0=0+dpvthp_lvt
+ lnfactor=0+dlnfactorp_lvt wnfactor=0+dwnfactorp_lvt pnfactor=0+dpnfactorp_lvt
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0127
+ pku0we=1.1e-17            wku0we=-4.5e-10           lku0we=-0.3e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_lvt            noib=noibp_lvt
+ noic=noicp_lvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     11: type=p 
+ lmin=9.999993e-006-dxlp_lvt                         lmax=2.00001e-05
+ wmin=6e-007-dxwp_lvt      wmax=1e-006-dxwp_lvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_lvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_lvt             toxm=2.2e-009
+ dtox=3.685e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_lvt
+ xw=1.6e-08+dxwp_lvt       dlc=2.134663e-08+ddlcp_lvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.196+dvthp_lvt     k1=0.12944
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.33e-8           k2=0.020897848+dk2p_lvt   wk2=-8.2777295e-009+dwk2p_lvt
+ k3=-1.2549878             k3b=0.79294122            w0=0
+ dvt0=2.5                  dvt1=1                    dvt2=0.0012
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=4.756553e-008       dvtp1=3.3913851           lpe0=1.9366257e-007
+ lpeb=2.5e-009             xj=1.1e-007               ngate=1.3715e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0003                voff=-0.14782425+dvoffp_lvt
+ wvoff=2.9808692e-009+dwvoffp_lvt                    nfactor=0.52253992+dnfactorp_lvt
+ eta0=0.25+deta0p_lvt      etab=-0.21                u0=0.01746098+du0p_lvt
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=4.2258861e-010+dwu0p_lvt
+ ua=1.9276597e-009         wua=5.8606423e-017        ub=9.1348432e-019
+ pub=0+dpubp_lvt           lub=0+dlubp_lvt           pua=0+dpuap_lvt
+ lua=0+dluap_lvt           wub=-3.5227569e-025       uc=-1.6020752e-011+ducp_lvt
+ vsat=88638+dvsatp_lvt     a0=5.1682396+da0p_lvt     kvsat=1
+ wa0=3.8975757e-007+dwa0p_lvt                        ags=1.2874333+dagsp_lvt
+ wags=-7.4245344e-008+dwagsp_lvt                     a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.02016+dketap_lvt   wketa=-6.25856e-009+dwketap_lvt
+ dwg=0                     dwb=0                     pclm=0.11422+dpclmp_lvt
+ pdiblc1=0                 pdiblc2=0.0044920283      wpdiblc2=-1.5826138e-009
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.96                pditsd=0.8613
+ pditsl=350000             rsh=15.5                  rsw=110+drdswp_lvt
+ rdw=110+drdswp_lvt        prwg=0                    prwb=0
+ wr=1                      alpha0=6.33e-009          alpha1=0.017727
+ beta0=14.154              agidl=1e-008              bgidl=3e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.013008
+ bigbacc=0.0062797         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0065469
+ bigc=0.000931576          cigc=0                    aigsd=0.0049844
+ bigsd=0.000394153         cigsd=0.039059            nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp_lvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_lvt
+ cgdo=cgop_lvt             cgbo=0                    cgdl=cglp_lvt
+ cgsl=cglp_lvt             clc=1e-007                cle=0.6
+ cf=cfp_lvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=6.8311               noff=3.1615
+ voffcv=-0.16125           kt1=-0.2154841            wkt1=1.3213291e-008+dwkt1p_lvt
+ kt1l=0                    kt2=-0.062902651          wkt2=8.3027974e-009
+ ute=-1                    ua1=3.2573451e-009        wua1=-4.3268913e-016
+ ub1=-1.7278938e-018       wub1=6.5733498e-025       uc1=1.35e-011+duc1p_lvt
+ prt=0                     at=150000                 jss=1.53e-07
+ jsd=1.53e-07              jsws=4.96e-13             jswd=4.96e-13
+ jswgs=4.96e-13            jswgd=4.96e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.68
+ bvd=9.68                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_lvt
+ cjd=cjp_lvt               mjs=0.31                  mjd=0.31
+ pbsws=0.75                pbswd=0.75                cjsws=cjswp_lvt
+ cjswd=cjswp_lvt           mjsws=0.025               mjswd=0.025
+ pbswgs=0.49               pbswgd=0.49               cjswgs=cjswgp_lvt
+ cjswgd=cjswgp_lvt         mjswgs=0.97               mjswgd=0.97
+ tpb=1.55e-03              tcj=8.70e-04              tpbsw=5.00e-03

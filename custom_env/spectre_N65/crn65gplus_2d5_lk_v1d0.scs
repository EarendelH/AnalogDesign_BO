+ pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ leta0=0+dleta0n_na25od33  weta0=0+dweta0n_na25od33  peta0=0+dpeta0n_na25od33
+ lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33
+ fnoimod=1                 noia=noian_na25od33       noib=noibn_na25od33
+ noic=noicn_na25od33       em=1.1200e+08             ef=1.00
+ tnoimod=0                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     4: type=n 
+ lmin=9.99999e-006-dxln_na25od33                     lmax=900.00001e-06
+ wmin=1.2e-006-dxwn_na25od33                         wmax=1e-005-dxwn_na25od33
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na25od33        toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+dxln_na25od33
+ xw=7e-09+dxwn_na25od33    dlc=0+ddlcn_na25od33      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.034198636+dvthn_na25od33                    k1=0.083826
+ k2=-0.0018230844          pk2=0                     lk2=0
+ wk2=-1.2511295e-09        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00079956499+dcitn_na25od33
+ wcit=-9.6507494e-010+dwcitn_na25od33                voff=-0.12477695
+ wvoff=-2.3700525e-010     nfactor=0.8+dnfactorn_na25od33
+ eta0=0.021777966+deta0n_na25od33                    weta0=-5.823734e-009+dweta0n_na25od33
+ etab=0.0010882964         u0=0.062945581+du0n_na25od33
+ wu0=-1.1078502e-009+dwu0n_na25od33                  ua=1.2235048e-009
+ ub=2.4999846e-018         uc=-5.7780526e-011        wuc=1.0126281e-016
+ vsat=78400+dvsatn_na25od33                          a0=3.4328817
+ pa0=0                     la0=0                     wa0=-2.4947833e-06
+ ags=1.0095994             wags=5.8805572e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.059213254         wketa=3.6129664e-008      dwg=0
+ dwb=0                     pclm=-0.0085221351        wpclm=1.8535101e-007
+ pdiblc1=0                 pdiblc2=0.00015035165     wpdiblc2=-1.8529439e-011
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25od33
+ cgdo=cgon_na25od33        cgbo=0                    cgdl=cgln_na25od33
+ cgsl=cgln_na25od33        clc=1e-007                cle=0.6
+ cf=cfn_na25od33           ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-2.9809198e-018       wub1=-1.9093557e-025      uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na25od33   wvth0=5.4902041e-09+dwvthn_na25od33
+ pvth0=0+dpvthn_na25od33   lu0=0+dlu0n_na25od33      pu0=0+dpu0n_na25od33
+ lcit=0+dlcitn_na25od33    pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ leta0=0+dleta0n_na25od33  peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33
+ wvsat=0+dwvsatn_na25od33  pvsat=0+dpvsatn_na25od33  fnoimod=1
+ noia=noian_na25od33       noib=noibn_na25od33       noic=noicn_na25od33
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     5: type=n 
+ lmin=1.99999e-006-dxln_na25od33                     lmax=9.99999e-006-dxln_na25od33
+ wmin=1.2e-006-dxwn_na25od33                         wmax=1e-005-dxwn_na25od33
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na25od33        toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+dxln_na25od33
+ xw=7e-09+dxwn_na25od33    dlc=0+ddlcn_na25od33      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.034333148+dvthn_na25od33                    k1=0.083826
+ k2=-0.0011532878          lk2=-6.672122e-09         wk2=-1.3796064e-09
+ pk2=1.2798169e-15         k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00099559933+dcitn_na25od33
+ lcit=-1.9527785e-009+dlcitn_na25od33                wcit=-1.2016884e-009+dwcitn_na25od33
+ pcit=2.3570036e-015+dpcitn_na25od33                 voff=-0.12535694
+ lvoff=5.777557e-009       wvoff=-5.6264021e-010     pvoff=3.2437834e-015
+ nfactor=0.8+dnfactorn_na25od33                      eta0=0.021777966+deta0n_na25od33
+ weta0=-5.823734e-009+dweta0n_na25od33               etab=0.0010882964
+ u0=0.062119625+du0n_na25od33                        lu0=8.2276866e-009+dlu0n_na25od33
+ wu0=6.471586e-011+dwu0n_na25od33                    pu0=-1.1680411e-014+dpu0n_na25od33
+ ua=1.0066817e-009         lua=2.1598628e-015        wua=1.7970992e-016
+ pua=-1.7901642e-021       ub=2.8343576e-18          lub=-3.3308258e-24
+ wub=-1.8079948e-25        pub=1.801017e-30          uc=-2.2362049e-011
+ luc=-3.5281798e-016       wuc=7.1527948e-017        puc=2.9620114e-022
+ vsat=78400+dvsatn_na25od33                          a0=4.08829
+ la0=-6.5287911e-06        wa0=-3.1092591e-06        pa0=6.1210439e-12
+ ags=0.49648423            lags=5.1113508e-006       wags=9.1673415e-007
+ pags=-3.2741006e-012      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.05319211+0.0003362798
+ lketa=-5.9979091e-008-3.3498176e-09                 wketa=4.1155197e-008-3.365152e-09
+ pketa=-5.0061403e-014+3.3521625e-14                 dwg=0
+ dwb=0                     pclm=-0.050216044         lpclm=4.1533012e-007
+ wpclm=2.3567555e-007      ppclm=-5.0130345e-013     pdiblc1=0
+ pdiblc2=0.00015787937     lpdiblc2=-7.4986694e-011  wpdiblc2=-2.7615395e-011
+ ppdiblc2=9.0508939e-017   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.064466e-018        lub1=8.3223805e-025       wub1=-2.3774844e-025
+ pub1=4.6632217e-031       uc1=-1.6310893e-10        luc1=7.8335461e-16
+ wuc1=8.8998662e-17        puc1=-8.8655223e-22       prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=1.339927e-09+dlvthn_na25od33
+ wvth0=6.8362649e-09+dwvthn_na25od33                 pvth0=-1.340865e-14+dpvthn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33
+ pvsat=0+dpvsatn_na25od33  fnoimod=1                 noia=noian_na25od33
+ noib=noibn_na25od33       noic=noicn_na25od33       em=1.1200e+08
+ ef=1.00                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na25od33
+ wmin=1.2e-006-dxwn_na25od33                         wmax=1e-005-dxwn_na25od33
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na25od33        toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+dxln_na25od33
+ xw=7e-09+dxwn_na25od33    dlc=0+ddlcn_na25od33      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.025395472+dvthn_na25od33                    k1=0.083826
+ k2=0.0007131239           lk2=-1.0332897e-08        wk2=8.48339e-10
+ pk2=-3.090054e-15         k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0+dcitn_na25od33      voff=-0.13409419
+ lvoff=2.2914876e-008      wvoff=7.7389381e-009      pvoff=-1.3039015e-014
+ nfactor=0.8+dnfactorn_na25od33                      eta0=0.021777966+deta0n_na25od33
+ weta0=-5.823734e-009+dweta0n_na25od33               etab=-0.0014451533
+ letab=4.9691335e-009      wetab=-9.2202907e-010     petab=1.808477e-015
+ u0=0.057010084+du0n_na25od33                        lu0=1.8249534e-08+dlu0n_na25od33
+ wu0=-5.2291659e-09+dwu0n_na25od33                   pu0=-1.2969584e-15+dpu0n_na25od33
+ ua=1.2361917e-009         lua=1.7096996e-015        wua=-2.5437827e-016
+ pua=-9.3873932e-022       ub=1.7194123e-18          lub=-1.1439695e-24
+ wub=6.9088787e-25         pub=9.12868e-32           uc=-1.9983058e-010
+ luc=-4.7294195e-018       wuc=3.4364521e-016        puc=-2.3753239e-022
+ vsat=78400+dvsatn_na25od33                          a0=1.6454133
+ la0=-1.7373106e-06        wa0=-3.1958999e-07        pa0=6.4936333e-13
+ ags=-9.9452213+4.1272639  lags=2.5591817e-005-8.0952154e-06
+ wags=1.3325745e-005-4.9816075e-06                   pags=-2.7613259e-011+9.770925e-12
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.083185601-0.033018111-0.00336284+0.0019912491
+ lketa=-1.1496065e-09+6.4761723e-08+3.9056361e-09-3.9056361e-09
+ wketa=2.9340101e-08+3.985286e-08+3.365194e-08-1.992643e-08
+ pketa=-2.6887095e-14-7.81674e-14-3.90837e-14+3.90837e-14
+ dwg=0                     dwb=0                     pclm=0.33215077
+ lpclm=-3.3464797e-007     wpclm=1.0788531e-008      ppclm=-6.0207799e-014
+ pdiblc1=0                 pdiblc2=0.00012335961     lpdiblc2=-7.2792913e-012
+ wpdiblc2=2.2458608e-010   ppdiblc2=-4.0416155e-016  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na25od33        cgdo=cgon_na25od33
+ cgbo=0                    cgdl=cgln_na25od33        cgsl=cgln_na25od33
+ clc=1e-007                cle=0.6                   cf=cfn_na25od33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.2672704            lkt1=-4.897936e-008       kt1l=0
+ kt2=-0.02963              ute=-1.48                 ua1=1.67e-009
+ ub1=-2.64016e-018         uc1=5.4782804e-11         luc1=3.5597952e-16
+ wuc1=-1.0889215e-16       puc1=-4.9840647e-22       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na25od33
+ cjd=cjn_na25od33          mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na25od33
+ cjswd=cjswn_na25od33      mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na25od33
+ cjswgd=cjswgn_na25od33    mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.6190431e-08+dlvthn_na25od33
+ wvth0=-9.9632151e-09+dwvthn_na25od33                pvth0=1.954185e-14+dpvthn_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33
+ pvsat=0+dpvsatn_na25od33  fnoimod=1                 noia=noian_na25od33
+ noib=noibn_na25od33       noic=noicn_na25od33       em=1.1200e+08
+ ef=1.00                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     7: type=n 
+ lmin=9.99999e-006-dxln_na25od33                     lmax=900.00001e-06
+ wmin=5e-07                wmax=1.2e-006-dxwn_na25od33
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na25od33        toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+dxln_na25od33
+ xw=7e-09+dxwn_na25od33    dlc=0+ddlcn_na25od33      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.031822857+dvthn_na25od33                    k1=0.083826
+ k2=0.0081064739           pk2=0                     lk2=0
+ wk2=-1.3236106e-08        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0+dcitn_na25od33      voff=-0.12783168
+ wvoff=3.4500609e-009      nfactor=0.8+dnfactorn_na25od33
+ eta0=0.028641812+deta0n_na25od33                    weta0=-1.4108396e-008+dweta0n_na25od33
+ etab=0.0010882964         u0=0.06106174+du0n_na25od33
+ wu0=1.1659461e-009+dwu0n_na25od33                   ua=1.2854346e-009
+ wua=-7.4749352e-017       ub=2.4999846e-018         uc=2.6115752e-011
+ vsat=78400+dvsatn_na25od33                          a0=1.4766944
+ pa0=0                     la0=0                     wa0=-1.3366518e-07
+ ags=1.6647716             wags=-2.027371e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.029279813         dwg=0                     dwb=0
+ pclm=0.14504125           pdiblc1=0                 pdiblc2=0.000135
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na25od33
+ cgdo=cgon_na25od33        cgbo=0                    cgdl=cgln_na25od33
+ cgsl=cgln_na25od33        clc=1e-007                cle=0.6
+ cf=cfn_na25od33           ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3.13911e-018         uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na25od33   wvth0=2.6226386e-09+dwvthn_na25od33
+ pvth0=0+dpvthn_na25od33   lu0=0+dlu0n_na25od33      pu0=0+dpu0n_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33
+ pvsat=0+dpvsatn_na25od33  fnoimod=1                 noia=noian_na25od33
+ noib=noibn_na25od33       noic=noicn_na25od33       em=1.1200e+08
+ ef=1.00                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     8: type=n 
+ lmin=1.99999e-006-dxln_na25od33                     lmax=9.99999e-006-dxln_na25od33
+ wmin=5e-07                wmax=1.2e-006-dxwn_na25od33
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na25od33        toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+dxln_na25od33
+ xw=7e-09+dxwn_na25od33    dlc=0+ddlcn_na25od33      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.029954273+dvthn_na25od33                    k1=0.083826
+ k2=0.0087146696           lk2=-6.0584809e-09        wk2=-1.329023e-08
+ pk2=5.391529e-16          k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0+dcitn_na25od33      voff=-0.12905814
+ lvoff=1.221718e-008       wvoff=3.9046996e-009      pvoff=-4.528842e-015
+ nfactor=0.8+dnfactorn_na25od33                      eta0=0.028641812+deta0n_na25od33
+ weta0=-1.4108396e-008+dweta0n_na25od33              etab=0.0010882964
+ u0=0.062004206+du0n_na25od33                        lu0=-9.3882913e-009+dlu0n_na25od33
+ wu0=2.040266e-010+dwu0n_na25od33                    pu0=9.5820743e-015+dpu0n_na25od33
+ ua=1.2896963e-009         lua=-4.2452701e-017       wua=-1.6188868e-016
+ pua=8.6803058e-022        ub=2.6703403e-18          lub=-1.6969828e-24
+ wub=1.7169379e-26         pub=-1.7103161e-31        uc=3.2781608e-011
+ luc=-6.6401324e-017       wuc=4.9695541e-018        puc=-4.9503766e-023
+ vsat=78400+dvsatn_na25od33                          a0=1.5933008
+ la0=-1.1615648e-06        wa0=-9.7807026e-08        pa0=-3.571982e-13
+ ags=1.5962099             lags=6.8297174e-007       wags=-4.1063467e-007
+ pags=2.0709529e-012       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.01641015-0.0042275175
+ lketa=-1.2819999e-007+4.2111993e-08                 wketa=-3.2406274e-009+2.1433514e-09
+ pketa=3.2281218e-014-2.135078e-14                   dwg=0
+ dwb=0                     pclm=0.14504125           pdiblc1=0
+ pdiblc2=0.000135          pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.2614407e-018       lub1=1.2185862e-024       uc1=-9.2925035e-11
+ puc1=-4.2701561e-23       wuc1=4.2867027e-18        luc1=8.4223986e-17
+ prt=0                     at=183960.37              lat=-0.19162228
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na25od33          cjd=cjn_na25od33          mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na25od33      cjswd=cjswn_na25od33      mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33    mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=-1.861371e-08+dlvthn_na25od33
+ wvth0=1.5509629e-09+dwvthn_na25od33                 pvth0=1.067539e-14+dpvthn_na25od33
+ lcit=0+dlcitn_na25od33    wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33
+ lnfactor=0+dlnfactorn_na25od33                      wnfactor=0+dwnfactorn_na25od33
+ pnfactor=0+dpnfactorn_na25od33                      leta0=0+dleta0n_na25od33
+ peta0=0+dpeta0n_na25od33  lvsat=0+dlvsatn_na25od33  wvsat=0+dwvsatn_na25od33
+ pvsat=0+dpvsatn_na25od33  fnoimod=1                 noia=noian_na25od33
+ noib=noibn_na25od33       noic=noicn_na25od33       em=1.1200e+08
+ ef=1.00                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na25od33
+ wmin=5e-07                wmax=1.2e-006-dxwn_na25od33
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na25od33                          permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_na25od33        toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+dxln_na25od33
+ xw=7e-09+dxwn_na25od33    dlc=0+ddlcn_na25od33      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.04049579+dvthn_na25od33                     k1=0.083826
+ k2=0.0094210721           lk2=-7.4439613e-09        wk2=-9.6621541e-09
+ pk2=-6.5770003e-15        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0+dcitn_na25od33      voff=-0.12106439
+ lvoff=-3.4618388e-009     wvoff=-7.9880317e-009     pvoff=1.879768e-014
+ nfactor=0.8+dnfactorn_na25od33                      eta0=0.028641812+deta0n_na25od33
+ leta0=-2.0005323e-016+dleta0n_na25od33              weta0=-1.4108396e-008+dweta0n_na25od33
+ peta0=2.4146429e-022+dpeta0n_na25od33               etab=-0.0045972791
+ letab=1.1151745e-008      wetab=2.8825868e-009      petab=-5.6539345e-015
+ u0=0.053938061+du0n_na25od33                        lu0=6.4326469e-09+dlu0n_na25od33
+ wu0=-1.5212336e-09+dwu0n_na25od33                   pu0=1.2966024e-14+dpu0n_na25od33
+ ua=1.6235236e-009         lua=-6.9722491e-016       wua=-7.2188788e-016
+ pua=1.9664186e-021        ub=1.4259873e-18          lub=7.43699e-25
+ wub=1.045052e-24          pub=-2.1871292e-30        uc=1.6131981e-010
+ luc=-3.1851744e-016       wuc=-9.2263315e-017       puc=1.4120976e-022
+ vsat=78400+dvsatn_na25od33-2103.008                 a0=1.8316083
+ la0=-1.6289837e-06        wa0=-5.4432737e-07        pa0=5.1861263e-13
+ ags=1.253264              lags=1.3556292e-006       wags=-1.9082677e-007
+ pags=1.6398195e-012       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.080802003+0.042275703-0.025032846
+ lketa=-1.9011631e-009-4.9099425e-08+4.9099425e-08   wketa=2.6463098e-008-2.1433782e-08+1.2691653e-08
+ pketa=-2.5979966e-014+2.4893408e-14-2.4893408e-14   dwg=0
+ dwb=0                     pclm=0.53198689           lpclm=-7.5895904e-007
+ wpclm=-2.3041366e-007     ppclm=4.5193566e-013      pdiblc1=0
+ pdiblc2=0.00030623536     lpdiblc2=-3.3586275e-010  wpdiblc2=3.8550414e-012
+ ppdiblc2=-7.5613168e-018  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na25od33        cgdo=cgon_na25od33        cgbo=0
+ cgdl=cgln_na25od33        cgsl=cgln_na25od33        clc=1e-007
+ cle=0.6                   cf=cfn_na25od33           ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=2.1111487e-11         puc1=9.9573634e-23        wuc1=-6.8250869e-17
+ luc1=-1.3944725e-16       prt=0                     at=128258.51
+ lat=-0.082368082          jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na25od33          cjd=cjn_na25od33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na25od33      cjswd=cjswn_na25od33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na25od33    cjswgd=cjswgn_na25od33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=2.06242e-09+dlvthn_na25od33                   wvth0=8.2628678e-09+dwvthn_na25od33
+ pvth0=-2.489341e-15+dpvthn_na25od33                 lcit=0+dlcitn_na25od33
+ wcit=0+dwcitn_na25od33    pcit=0+dpcitn_na25od33    lnfactor=0+dlnfactorn_na25od33
+ wnfactor=0+dwnfactorn_na25od33                      pnfactor=0+dpnfactorn_na25od33
+ lvsat=0+dlvsatn_na25od33+0.0041248398               wvsat=0+dwvsatn_na25od33+0.0025383306
+ pvsat=0+dpvsatn_na25od33-4.9786817e-09              fnoimod=1
+ noia=noian_na25od33       noib=noibn_na25od33       noic=noicn_na25od33
+ em=1.1200e+08             ef=1.00                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     } 
endsection mos_na25od33
 

section mos_na33
// *********************************************************************************************
//                                                                            
//                   *
//                                3.3V NATIVE NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt nch_na33_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=1.135e-007 xw= + 
+ 7e-09 + dxwn_na33 ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg / 
+ factor * (w / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) 
+ ps=4 * dmcg / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf 
+ + xw / factor) nrs=dmcg / factor / (w / nf + xw / factor) sa=4.6e-7 / factor sb=4.6e-7 
+ / factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parn1_na33 temp2=parn2_na33 fac1=0.010100 * temp1 * sigma 
+ + 0.999949 * temp2 * sigma fac2=0.010100 * temp1 * sigma - 0.999949 * temp2 * 
+ sigma lef=l * factor - 3.859e-8 wef=w / nf * factor + 7e-09 geo_fac=1 / sqrt(multi 
+ * nf * lef * wef * 1e12) vthmisn_na33=0.00190412 * geo_fac * fac1 * mismatchflag 
+ dlmisn_na33=0.00191205 * geo_fac * lef * fac2 * mismatchflag dwmisn_na33= - 0.00191205 
+ * geo_fac * wef * fac2 * mismatchflag toxmisn_na33=0.00191205 * geo_fac * toxn_na33 
+ * fac2 * mismatchflag tnoiax=1.903e04 / (l * 1e6) + 8.634e6 rnoiax= - 0.1171 / 
+ (l * 1e6) + 0.6655 
nch_na33_mac ( n1 n2 n3 n4 ) nch_na33 w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
 
model nch_na33 bsim4  { 
     1: type=n 
+ lmin=9.99999e-006-(dxln_na33+dlmisn_na33)           lmax=900.00001e-06
+ wmin=1e-005-(dxwn_na33+dwmisn_na33)                 wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=-0.0019481098          pk2=0
+ wk2=0                     lk2=0                     k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000703125+dcitn_na33
+ voff=-0.12480063          nfactor=0.8+dnfactorn_na33
+ eta0=0.021196+deta0n_na33 etab=0.0010882964         u0=0.062834873+du0n_na33
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-4.7661329e-011
+ vsat=78400+dvsatn_na33    a0=3.1835779              pa0=0
+ wa0=0                     la0=0                     ags=1.0683639
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.055602815         dwg=0
+ dwb=0                     pclm=0.01                 pdiblc1=0
+ pdiblc2=0.0001485         pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25871994
+ kt1l=0                    kt2=-0.018492824          ute=-1.48
+ ua1=1.67e-009             ub1=-3e-018               uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na33       wvth0=0+dwvthn_na33
+ pvth0=0+dpvthn_na33       lu0=0+dlu0n_na33          wu0=0+dwu0n_na33
+ pu0=0+dpu0n_na33          lcit=0+dlcitn_na33        wcit=0+dwcitn_na33
+ pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ leta0=0+dleta0n_na33      weta0=0+dweta0n_na33      peta0=0+dpeta0n_na33
+ lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33
+ fnoimod=1                 noia=noian_na33           rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na33           rnoib=0
+ noic=noicn_na33           em=1.12e+8             ef=1.0
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.99999e-006-(dxln_na33+dlmisn_na33)           lmax=9.99999e-006-(dxln_na33+dlmisn_na33)
+ wmin=1e-005-(dxwn_na33+dwmisn_na33)                 wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=-0.0012911519          pk2=0
+ wk2=0                     lk2=-6.5442298e-09        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00087551455+dcitn_na33
+ lcit=-1.717243e-009+dlcitn_na33                     voff=-0.12541317
+ lvoff=6.1017084e-009      nfactor=0.8+dnfactorn_na33
+ eta0=0.021196+deta0n_na33 etab=0.0010882964         u0=0.062126092+du0n_na33
+ lu0=7.0604626e-009+dlu0n_na33                       ua=1.0246402e-009
+ lua=1.9809716e-015        ub=2.8162903e-18          pub=0
+ wub=0                     lub=-3.1508501e-24        uc=-1.5214257e-011
+ luc=-3.2321858e-016       vsat=78400+dvsatn_na33    a0=3.7775816
+ pa0=0                     wa0=0                     la0=-5.9171147e-06
+ ags=0.58809352            lags=4.7841698e-006       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.049079469         lketa=-6.4981729e-008     dwg=0
+ dwb=0                     pclm=-0.026664974         lpclm=3.6523484e-007
+ pdiblc1=0                 pdiblc2=0.00015511976     lpdiblc2=-6.5942131e-011
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na33
+ cgdo=cgon_na33            cgbo=0                    cgdl=cgln_na33
+ cgsl=cgln_na33            clc=1e-007                cle=0.6
+ cf=cfn_na33               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25050115           lkt1=-8.1870746e-008
+ kt1l=0                    kt2=-0.015762253          lkt2=-2.7200338e-008
+ ute=-1.48                 ua1=1.67e-009             ub1=-3.0882242e-018
+ lub1=8.7883765e-025       uc1=-1.5421529e-010       luc1=6.9476141e-016
+ prt=0                     at=183960.37              lat=-0.19162228
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na33              cjd=cjn_na33              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na33          cjswd=cjswn_na33          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na33        cjswgd=cjswgn_na33        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=0+dlvthn_na33
+ wvth0=0+dwvthn_na33       pvth0=0+dpvthn_na33       wu0=0+dwu0n_na33
+ pu0=0+dpu0n_na33          wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ weta0=0+dweta0n_na33      peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33
+ wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33      fnoimod=1
+ noia=noian_na33           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na33           rnoib=0                   noic=noicn_na33
+ em=1.12e+8             ef=1.0                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na33+dlmisn_na33)
+ wmin=1e-005-(dxwn_na33+dwmisn_na33)                 wmax=900.00001e-06
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.026391097+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=0.00079789845          pk2=0
+ wk2=0                     lk2=-1.0641687e-08        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.13332084          lvoff=2.1611887e-008      nfactor=0.8+dnfactorn_na33
+ eta0=0.021196+deta0n_na33 etab=-0.0015372917        letab=5.1498547e-009
+ u0=0.056487534+du0n_na33  lu0=1.8119928e-08+dlu0n_na33
+ ua=1.2107717e-009         lua=1.6158914e-015        ub=1.7884528e-18
+ pub=0                     wub=0                     lub=-1.1348474e-24
+ uc=-1.654901e-010         luc=-2.8466042e-017       vsat=78400+dvsatn_na33
+ a0=1.6134766              pa0=0                     wa0=0
+ la0=-1.6724197e-06        ags=-8.613579+3.6294516   pags=0+0
+ wags=0-0                  lags=2.2832422e-005-7.1188064e-06
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080253643-0.029035613
+ pketa=0+0                 wketa=0-0                 lketa=-3.8364353e-09+5.6950451e-08
+ dwg=0                     dwb=0                     pclm=0.33322887
+ lpclm=-3.4066454e-007     pdiblc1=0                 pdiblc2=0.0001458025
+ lpdiblc2=-4.7667175e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=4.3901206e-011        luc1=3.0617374e-016       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.4237613e-08+dlvthn_na33
+ wvth0=0+dwvthn_na33       pvth0=0+dpvthn_na33       wu0=0+dwu0n_na33
+ pu0=0+dpu0n_na33          lcit=0+dlcitn_na33        wcit=0+dwcitn_na33
+ pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ leta0=0+dleta0n_na33      weta0=0+dweta0n_na33      peta0=0+dpeta0n_na33
+ lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33
+ fnoimod=1                 noia=noian_na33           rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn_na33           rnoib=0
+ noic=noicn_na33           em=1.12e+8             ef=1.0
+ tnoimod=1                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     4: type=n 
+ lmin=9.99999e-006-(dxln_na33+dlmisn_na33)           lmax=900.00001e-06
+ wmin=1.2e-006-(dxwn_na33+dwmisn_na33)               wmax=1e-005-(dxwn_na33+dwmisn_na33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.034198636+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=-0.0018230844          pk2=0
+ lk2=0                     wk2=-1.2511295e-09        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00079956499+dcitn_na33
+ wcit=-9.6507494e-010+dwcitn_na33                    voff=-0.12477695
+ wvoff=-2.3700525e-010     nfactor=0.8+dnfactorn_na33
+ eta0=0.021777966+deta0n_na33                        weta0=-5.823734e-009+dweta0n_na33
+ etab=0.0010882964         u0=0.062945581+du0n_na33  wu0=-1.1078502e-009+dwu0n_na33
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-5.7780526e-011
+ wuc=1.0126281e-016        vsat=78400+dvsatn_na33    a0=3.4328817
+ pa0=0                     la0=0                     wa0=-2.4947833e-06
+ ags=1.0095994             wags=5.8805572e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.059213254         wketa=3.6129664e-008      dwg=0
+ dwb=0                     pclm=-0.0085221351        wpclm=1.8535101e-007
+ pdiblc1=0                 pdiblc2=0.00015035165     wpdiblc2=-1.8529439e-011
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na33
+ cgdo=cgon_na33            cgbo=0                    cgdl=cgln_na33
+ cgsl=cgln_na33            clc=1e-007                cle=0.6
+ cf=cfn_na33               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-2.9809198e-018       wub1=-1.9093557e-025      uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na33       wvth0=5.4902041e-09+dwvthn_na33
+ pvth0=0+dpvthn_na33       lu0=0+dlu0n_na33          pu0=0+dpu0n_na33
+ lcit=0+dlcitn_na33        pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ leta0=0+dleta0n_na33      peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33
+ wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33      fnoimod=1
+ noia=noian_na33           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na33           rnoib=0                   noic=noicn_na33
+ em=1.12e+8             ef=1.0                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     5: type=n 
+ lmin=1.99999e-006-(dxln_na33+dlmisn_na33)           lmax=9.99999e-006-(dxln_na33+dlmisn_na33)
+ wmin=1.2e-006-(dxwn_na33+dwmisn_na33)               wmax=1e-005-(dxwn_na33+dwmisn_na33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.034333148+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=-0.0011532878          lk2=-6.672122e-09
+ wk2=-1.3796064e-09        pk2=1.2798169e-15         k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00099559933+dcitn_na33
+ lcit=-1.9527785e-009+dlcitn_na33                    wcit=-1.2016884e-009+dwcitn_na33
+ pcit=2.3570036e-015+dpcitn_na33                     voff=-0.12535694
+ lvoff=5.777557e-009       wvoff=-5.6264021e-010     pvoff=3.2437834e-015
+ nfactor=0.8+dnfactorn_na33                          eta0=0.021777966+deta0n_na33
+ weta0=-5.823734e-009+dweta0n_na33                   etab=0.0010882964
+ u0=0.062119625+du0n_na33  lu0=8.2276866e-009+dlu0n_na33
+ wu0=6.471586e-011+dwu0n_na33                        pu0=-1.1680411e-014+dpu0n_na33
+ ua=1.0066817e-009         lua=2.1598628e-015        wua=1.7970992e-016
+ pua=-1.7901642e-021       ub=2.8343576e-18          lub=-3.3308258e-24
+ wub=-1.8079948e-25        pub=1.801017e-30          uc=-2.2362049e-011
+ luc=-3.5281798e-016       wuc=7.1527948e-017        puc=2.9620114e-022
+ vsat=78400+dvsatn_na33    a0=4.08829                la0=-6.5287911e-06
+ wa0=-3.1092591e-06        pa0=6.1210439e-12         ags=0.49648423
+ lags=5.1113508e-006       wags=9.1673415e-007       pags=-3.2741006e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.05319211+0.0003362798
+ lketa=-5.9979091e-008-3.3498176e-09                 wketa=4.1155197e-008-3.365152e-09
+ pketa=-5.0061403e-014+3.3521625e-14                 dwg=0
+ dwb=0                     pclm=-0.050216044         lpclm=4.1533012e-007
+ wpclm=2.3567555e-007      ppclm=-5.0130345e-013     pdiblc1=0
+ pdiblc2=0.00015787937     lpdiblc2=-7.4986694e-011  wpdiblc2=-2.7615395e-011
+ ppdiblc2=9.0508939e-017   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.064466e-018        lub1=8.3223805e-025       wub1=-2.3774844e-025
+ pub1=4.6632217e-031       uc1=-1.6310893e-10        luc1=7.8335461e-16
+ wuc1=8.8998662e-17        puc1=-8.8655223e-22       prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=1.339927e-09+dlvthn_na33
+ wvth0=6.8362649e-09+dwvthn_na33                     pvth0=-1.340865e-14+dpvthn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na33
+ rnoib=0                   noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na33+dlmisn_na33)
+ wmin=1.2e-006-(dxwn_na33+dwmisn_na33)               wmax=1e-005-(dxwn_na33+dwmisn_na33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.025395472+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=0.0007131239           lk2=-1.0332897e-08
+ wk2=8.48339e-10           pk2=-3.090054e-15         k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.13409419          lvoff=2.2914876e-008      wvoff=7.7389381e-009
+ pvoff=-1.3039015e-014     nfactor=0.8+dnfactorn_na33
+ eta0=0.021777966+deta0n_na33                        weta0=-5.823734e-009+dweta0n_na33
+ etab=-0.0014451533        letab=4.9691335e-009      wetab=-9.2202907e-010
+ petab=1.808477e-015       u0=0.057010084+du0n_na33  lu0=1.8249534e-08+dlu0n_na33
+ wu0=-5.2291659e-09+dwu0n_na33                       pu0=-1.2969584e-15+dpu0n_na33
+ ua=1.2361917e-009         lua=1.7096996e-015        wua=-2.5437827e-016
+ pua=-9.3873932e-022       ub=1.7194123e-18          lub=-1.1439695e-24
+ wub=6.9088787e-25         pub=9.12868e-32           uc=-1.9983058e-010
+ luc=-4.7294195e-018       wuc=3.4364521e-016        puc=-2.3753239e-022
+ vsat=78400+dvsatn_na33    a0=1.6454133              la0=-1.7373106e-06
+ wa0=-3.1958999e-07        pa0=6.4936333e-13         ags=-9.9452213+4.1272639
+ lags=2.5591817e-005-8.0952154e-06                   wags=1.3325745e-005-4.9816075e-06
+ pags=-2.7613259e-011+9.770925e-12                   a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.083185601-0.033018111-0.00336284+0.0019912491
+ lketa=-1.1496065e-09+6.4761723e-08+3.9056361e-09-3.9056361e-09
+ wketa=2.9340101e-08+3.985286e-08+3.365194e-08-1.992643e-08
+ pketa=-2.6887095e-14-7.81674e-14-3.90837e-14+3.90837e-14
+ dwg=0                     dwb=0                     pclm=0.33215077
+ lpclm=-3.3464797e-007     wpclm=1.0788531e-008      ppclm=-6.0207799e-014
+ pdiblc1=0                 pdiblc2=0.00012335961     lpdiblc2=-7.2792913e-012
+ wpdiblc2=2.2458608e-010   ppdiblc2=-4.0416155e-016  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na33            cgdo=cgon_na33
+ cgbo=0                    cgdl=cgln_na33            cgsl=cgln_na33
+ clc=1e-007                cle=0.6                   cf=cfn_na33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.2672704            lkt1=-4.897936e-008       kt1l=0
+ kt2=-0.02963              ute=-1.48                 ua1=1.67e-009
+ ub1=-2.64016e-018         uc1=5.4782804e-11         luc1=3.5597952e-16
+ wuc1=-1.0889215e-16       puc1=-4.9840647e-22       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.6190431e-08+dlvthn_na33
+ wvth0=-9.9632151e-09+dwvthn_na33                    pvth0=1.954185e-14+dpvthn_na33
+ lcit=0+dlcitn_na33        wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na33
+ rnoib=0                   noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     7: type=n 
+ lmin=9.99999e-006-(dxln_na33+dlmisn_na33)           lmax=900.00001e-06
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na33+dwmisn_na33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.031822857+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=0.0081064739           pk2=0
+ lk2=0                     wk2=-1.3236106e-08        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.12783168          wvoff=3.4500609e-009      nfactor=0.8+dnfactorn_na33
+ eta0=0.028641812+deta0n_na33                        weta0=-1.4108396e-008+dweta0n_na33
+ etab=0.0010882964         u0=0.06106174+du0n_na33   wu0=1.1659461e-009+dwu0n_na33
+ ua=1.2854346e-009         wua=-7.4749352e-017       ub=2.4999846e-018
+ uc=2.6115752e-011         vsat=78400+dvsatn_na33    a0=1.4766944
+ pa0=0                     la0=0                     wa0=-1.3366518e-07
+ ags=1.6647716             wags=-2.027371e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.029279813         dwg=0                     dwb=0
+ pclm=0.14504125           pdiblc1=0                 pdiblc2=0.000135
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na33
+ cgdo=cgon_na33            cgbo=0                    cgdl=cgln_na33
+ cgsl=cgln_na33            clc=1e-007                cle=0.6
+ cf=cfn_na33               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3.13911e-018         uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na33              cjd=cjn_na33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na33          cjswd=cjswn_na33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na33        cjswgd=cjswgn_na33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na33       wvth0=2.6226386e-09+dwvthn_na33
+ pvth0=0+dpvthn_na33       lu0=0+dlu0n_na33          pu0=0+dpu0n_na33
+ lcit=0+dlcitn_na33        wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na33
+ rnoib=0                   noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     8: type=n 
+ lmin=1.99999e-006-(dxln_na33+dlmisn_na33)           lmax=9.99999e-006-(dxln_na33+dlmisn_na33)
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na33+dwmisn_na33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.029954273+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=0.0087146696           lk2=-6.0584809e-09
+ wk2=-1.329023e-08         pk2=5.391529e-16          k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.12905814          lvoff=1.221718e-008       wvoff=3.9046996e-009
+ pvoff=-4.528842e-015      nfactor=0.8+dnfactorn_na33
+ eta0=0.028641812+deta0n_na33                        weta0=-1.4108396e-008+dweta0n_na33
+ etab=0.0010882964         u0=0.062004206+du0n_na33  lu0=-9.3882913e-009+dlu0n_na33
+ wu0=2.040266e-010+dwu0n_na33                        pu0=9.5820743e-015+dpu0n_na33
+ ua=1.2896963e-009         lua=-4.2452701e-017       wua=-1.6188868e-016
+ pua=8.6803058e-022        ub=2.6703403e-18          lub=-1.6969828e-24
+ wub=1.7169379e-26         pub=-1.7103161e-31        uc=3.2781608e-011
+ luc=-6.6401324e-017       wuc=4.9695541e-018        puc=-4.9503766e-023
+ vsat=78400+dvsatn_na33    a0=1.5933008              la0=-1.1615648e-06
+ wa0=-9.7807026e-08        pa0=-3.571982e-13         ags=1.5962099
+ lags=6.8297174e-007       wags=-4.1063467e-007      pags=2.0709529e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.01641015-0.0042275175
+ lketa=-1.2819999e-007+4.2111993e-08                 wketa=-3.2406274e-009+2.1433514e-09
+ pketa=3.2281218e-014-2.135078e-14                   dwg=0
+ dwb=0                     pclm=0.14504125           pdiblc1=0
+ pdiblc2=0.000135          pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.2614407e-018       lub1=1.2185862e-024       uc1=-9.2925035e-11
+ puc1=-4.2701561e-23       wuc1=4.2867027e-18        luc1=8.4223986e-17
+ prt=0                     at=183960.37              lat=-0.19162228
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na33              cjd=cjn_na33              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na33          cjswd=cjswn_na33          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na33        cjswgd=cjswgn_na33        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=-1.861371e-08+dlvthn_na33
+ wvth0=1.5509629e-09+dwvthn_na33                     pvth0=1.067539e-14+dpvthn_na33
+ lcit=0+dlcitn_na33        wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn_na33
+ rnoib=0                   noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=1                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-(dxln_na33+dlmisn_na33)
+ wmin=5e-07                wmax=1.2e-006-(dxwn_na33+dwmisn_na33)
+ version=4.5               rgeomod=1                 ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=0                  igbmod=0
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_na33    permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn_na33+toxmisn_na33)                       toxm=5.6e-009
+ dtox=2.5232e-010          epsrox=3.9                wint=0
+ lint=0                    ll=0                      wl=0
+ lln=1                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-3.859e-8+(dxln_na33+dlmisn_na33)
+ xw=7e-09+(dxwn_na33+dwmisn_na33)                    dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.04049579+(dvthn_na33+vthmisn_na33)
+ k1=0.083826               k2=0.0094210721           lk2=-7.4439613e-09
+ wk2=-9.6621541e-09        pk2=-6.5770003e-15        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.12106439          lvoff=-3.4618388e-009     wvoff=-7.9880317e-009
+ pvoff=1.879768e-014       nfactor=0.8+dnfactorn_na33
+ eta0=0.028641812+deta0n_na33                        leta0=-2.0005323e-016+dleta0n_na33
+ weta0=-1.4108396e-008+dweta0n_na33                  peta0=2.4146429e-022+dpeta0n_na33
+ etab=-0.0045972791        letab=1.1151745e-008      wetab=2.8825868e-009
+ petab=-5.6539345e-015     u0=0.053938061+du0n_na33  lu0=6.4326469e-09+dlu0n_na33
+ wu0=-1.5212336e-09+dwu0n_na33                       pu0=1.2966024e-14+dpu0n_na33
+ ua=1.6235236e-009         lua=-6.9722491e-016       wua=-7.2188788e-016
+ pua=1.9664186e-021        ub=1.4259873e-18          lub=7.43699e-25
+ wub=1.045052e-24          pub=-2.1871292e-30        uc=1.6131981e-010
+ luc=-3.1851744e-016       wuc=-9.2263315e-017       puc=1.4120976e-022
+ vsat=78400+dvsatn_na33-2103.008                     a0=1.8316083
+ la0=-1.6289837e-06        wa0=-5.4432737e-07        pa0=5.1861263e-13
+ ags=1.253264              lags=1.3556292e-006       wags=-1.9082677e-007
+ pags=1.6398195e-012       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.080802003+0.042275703-0.025032846
+ lketa=-1.9011631e-009-4.9099425e-08+4.9099425e-08   wketa=2.6463098e-008-2.1433782e-08+1.2691653e-08
+ pketa=-2.5979966e-014+2.4893408e-14-2.4893408e-14   dwg=0
+ dwb=0                     pclm=0.53198689           lpclm=-7.5895904e-007
+ wpclm=-2.3041366e-007     ppclm=4.5193566e-013      pdiblc1=0
+ pdiblc2=0.00030623536     lpdiblc2=-3.3586275e-010  wpdiblc2=3.8550414e-012
+ ppdiblc2=-7.5613168e-018  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=2.1111487e-11         puc1=9.9573634e-23        wuc1=-6.8250869e-17
+ luc1=-1.3944725e-16       prt=0                     at=128258.51
+ lat=-0.082368082          jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na33              cjd=cjn_na33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na33          cjswd=cjswn_na33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na33        cjswgd=cjswgn_na33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=2.06242e-09+dlvthn_na33                       wvth0=8.2628678e-09+dwvthn_na33
+ pvth0=-2.489341e-15+dpvthn_na33                     lcit=0+dlcitn_na33
+ wcit=0+dwcitn_na33        pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ lvsat=0+dlvsatn_na33+0.0041248398                   wvsat=0+dwvsatn_na33+0.0025383306
+ pvsat=0+dpvsatn_na33-4.9786817e-09                  fnoimod=1
+ noia=noian_na33           rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn_na33           rnoib=0                   noic=noicn_na33
+ em=1.12e+8             ef=1.0                   tnoimod=1
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
     } 
ends nch_na33_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                3.3V NATIVE NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch_na33 bsim4  { 
     1: type=n 
+ lmin=9.99999e-006-dxln_na33                         lmax=900.00001e-06
+ wmin=1e-005-dxwn_na33     wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na33  k1=0.083826
+ k2=-0.0019481098          pk2=0                     wk2=0
+ lk2=0                     k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.000703125+dcitn_na33
+ voff=-0.12480063          nfactor=0.8+dnfactorn_na33
+ eta0=0.021196+deta0n_na33 etab=0.0010882964         u0=0.062834873+du0n_na33
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-4.7661329e-011
+ vsat=78400+dvsatn_na33    a0=3.1835779              pa0=0
+ wa0=0                     la0=0                     ags=1.0683639
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.055602815         dwg=0
+ dwb=0                     pclm=0.01                 pdiblc1=0
+ pdiblc2=0.0001485         pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25871994
+ kt1l=0                    kt2=-0.018492824          ute=-1.48
+ ua1=1.67e-009             ub1=-3e-018               uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na33       wvth0=0+dwvthn_na33
+ pvth0=0+dpvthn_na33       lu0=0+dlu0n_na33          wu0=0+dwu0n_na33
+ pu0=0+dpu0n_na33          lcit=0+dlcitn_na33        wcit=0+dwcitn_na33
+ pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ leta0=0+dleta0n_na33      weta0=0+dweta0n_na33      peta0=0+dpeta0n_na33
+ lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33
+ fnoimod=1                 noia=noian_na33           noib=noibn_na33
+ noic=noicn_na33           em=1.12e+8             ef=1.0
+ tnoimod=0                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     2: type=n 
+ lmin=1.99999e-006-dxln_na33                         lmax=9.99999e-006-dxln_na33
+ wmin=1e-005-dxwn_na33     wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.03365+dvthn_na33  k1=0.083826
+ k2=-0.0012911519          pk2=0                     wk2=0
+ lk2=-6.5442298e-09        k3=2.6118349              k3b=-4.9758566
+ w0=0                      dvt0=0.064799587          dvt1=0.02075738
+ dvt2=0.30031818           dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.03344              minv=-0.5
+ voffl=0                   dvtp0=8.4008771e-009      dvtp1=3.5
+ lpe0=2.8116619e-009       lpeb=1.51e-010            xj=1.1e-007
+ ngate=5.9092e+020         ndep=5.11e+017            nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.00087551455+dcitn_na33
+ lcit=-1.717243e-009+dlcitn_na33                     voff=-0.12541317
+ lvoff=6.1017084e-009      nfactor=0.8+dnfactorn_na33
+ eta0=0.021196+deta0n_na33 etab=0.0010882964         u0=0.062126092+du0n_na33
+ lu0=7.0604626e-009+dlu0n_na33                       ua=1.0246402e-009
+ lua=1.9809716e-015        ub=2.8162903e-18          pub=0
+ wub=0                     lub=-3.1508501e-24        uc=-1.5214257e-011
+ luc=-3.2321858e-016       vsat=78400+dvsatn_na33    a0=3.7775816
+ pa0=0                     wa0=0                     la0=-5.9171147e-06
+ ags=0.58809352            lags=4.7841698e-006       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.049079469         lketa=-6.4981729e-008     dwg=0
+ dwb=0                     pclm=-0.026664974         lpclm=3.6523484e-007
+ pdiblc1=0                 pdiblc2=0.00015511976     lpdiblc2=-6.5942131e-011
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na33
+ cgdo=cgon_na33            cgbo=0                    cgdl=cgln_na33
+ cgsl=cgln_na33            clc=1e-007                cle=0.6
+ cf=cfn_na33               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25050115           lkt1=-8.1870746e-008
+ kt1l=0                    kt2=-0.015762253          lkt2=-2.7200338e-008
+ ute=-1.48                 ua1=1.67e-009             ub1=-3.0882242e-018
+ lub1=8.7883765e-025       uc1=-1.5421529e-010       luc1=6.9476141e-016
+ prt=0                     at=183960.37              lat=-0.19162228
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na33              cjd=cjn_na33              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na33          cjswd=cjswn_na33          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na33        cjswgd=cjswgn_na33        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=0+dlvthn_na33
+ wvth0=0+dwvthn_na33       pvth0=0+dpvthn_na33       wu0=0+dwu0n_na33
+ pu0=0+dpu0n_na33          wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ weta0=0+dweta0n_na33      peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33
+ wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33      fnoimod=1
+ noia=noian_na33           noib=noibn_na33           noic=noicn_na33
+ em=1.12e+8             ef=1.0                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     3: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na33
+ wmin=1e-005-dxwn_na33     wmax=900.00001e-06        version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.026391097+dvthn_na33
+ k1=0.083826               k2=0.00079789845          pk2=0
+ wk2=0                     lk2=-1.0641687e-08        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.13332084          lvoff=2.1611887e-008      nfactor=0.8+dnfactorn_na33
+ eta0=0.021196+deta0n_na33 etab=-0.0015372917        letab=5.1498547e-009
+ u0=0.056487534+du0n_na33  lu0=1.8119928e-08+dlu0n_na33
+ ua=1.2107717e-009         lua=1.6158914e-015        ub=1.7884528e-18
+ pub=0                     wub=0                     lub=-1.1348474e-24
+ uc=-1.654901e-010         luc=-2.8466042e-017       vsat=78400+dvsatn_na33
+ a0=1.6134766              pa0=0                     wa0=0
+ la0=-1.6724197e-06        ags=-8.613579+3.6294516   pags=0+0
+ wags=0-0                  lags=2.2832422e-005-7.1188064e-06
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.080253643-0.029035613
+ pketa=0+0                 wketa=0-0                 lketa=-3.8364353e-09+5.6950451e-08
+ dwg=0                     dwb=0                     pclm=0.33322887
+ lpclm=-3.4066454e-007     pdiblc1=0                 pdiblc2=0.0001458025
+ lpdiblc2=-4.7667175e-011  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=4.3901206e-011        luc1=3.0617374e-016       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.4237613e-08+dlvthn_na33
+ wvth0=0+dwvthn_na33       pvth0=0+dpvthn_na33       wu0=0+dwu0n_na33
+ pu0=0+dpu0n_na33          lcit=0+dlcitn_na33        wcit=0+dwcitn_na33
+ pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ leta0=0+dleta0n_na33      weta0=0+dweta0n_na33      peta0=0+dpeta0n_na33
+ lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33
+ fnoimod=1                 noia=noian_na33           noib=noibn_na33
+ noic=noicn_na33           em=1.12e+8             ef=1.0
+ tnoimod=0                 kvth0we=0                 k2we=0
+ ku0we=0                   wec=0                     web=0
+ scref=1e-6                wpemod=1                  ud=0
+ minr=1e-3
 
 
     4: type=n 
+ lmin=9.99999e-006-dxln_na33                         lmax=900.00001e-06
+ wmin=1.2e-006-dxwn_na33   wmax=1e-005-dxwn_na33     version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.034198636+dvthn_na33
+ k1=0.083826               k2=-0.0018230844          pk2=0
+ lk2=0                     wk2=-1.2511295e-09        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00079956499+dcitn_na33
+ wcit=-9.6507494e-010+dwcitn_na33                    voff=-0.12477695
+ wvoff=-2.3700525e-010     nfactor=0.8+dnfactorn_na33
+ eta0=0.021777966+deta0n_na33                        weta0=-5.823734e-009+dweta0n_na33
+ etab=0.0010882964         u0=0.062945581+du0n_na33  wu0=-1.1078502e-009+dwu0n_na33
+ ua=1.2235048e-009         ub=2.4999846e-018         uc=-5.7780526e-011
+ wuc=1.0126281e-016        vsat=78400+dvsatn_na33    a0=3.4328817
+ pa0=0                     la0=0                     wa0=-2.4947833e-06
+ ags=1.0095994             wags=5.8805572e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.059213254         wketa=3.6129664e-008      dwg=0
+ dwb=0                     pclm=-0.0085221351        wpclm=1.8535101e-007
+ pdiblc1=0                 pdiblc2=0.00015035165     wpdiblc2=-1.8529439e-011
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na33
+ cgdo=cgon_na33            cgbo=0                    cgdl=cgln_na33
+ cgsl=cgln_na33            clc=1e-007                cle=0.6
+ cf=cfn_na33               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-2.9809198e-018       wub1=-1.9093557e-025      uc1=-8.447e-011
+ prt=0                     at=164723.91              jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=0+dlvthn_na33       wvth0=5.4902041e-09+dwvthn_na33
+ pvth0=0+dpvthn_na33       lu0=0+dlu0n_na33          pu0=0+dpu0n_na33
+ lcit=0+dlcitn_na33        pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ leta0=0+dleta0n_na33      peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33
+ wvsat=0+dwvsatn_na33      pvsat=0+dpvsatn_na33      fnoimod=1
+ noia=noian_na33           noib=noibn_na33           noic=noicn_na33
+ em=1.12e+8             ef=1.0                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
 
     5: type=n 
+ lmin=1.99999e-006-dxln_na33                         lmax=9.99999e-006-dxln_na33
+ wmin=1.2e-006-dxwn_na33   wmax=1e-005-dxwn_na33     version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.034333148+dvthn_na33
+ k1=0.083826               k2=-0.0011532878          lk2=-6.672122e-09
+ wk2=-1.3796064e-09        pk2=1.2798169e-15         k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00099559933+dcitn_na33
+ lcit=-1.9527785e-009+dlcitn_na33                    wcit=-1.2016884e-009+dwcitn_na33
+ pcit=2.3570036e-015+dpcitn_na33                     voff=-0.12535694
+ lvoff=5.777557e-009       wvoff=-5.6264021e-010     pvoff=3.2437834e-015
+ nfactor=0.8+dnfactorn_na33                          eta0=0.021777966+deta0n_na33
+ weta0=-5.823734e-009+dweta0n_na33                   etab=0.0010882964
+ u0=0.062119625+du0n_na33  lu0=8.2276866e-009+dlu0n_na33
+ wu0=6.471586e-011+dwu0n_na33                        pu0=-1.1680411e-014+dpu0n_na33
+ ua=1.0066817e-009         lua=2.1598628e-015        wua=1.7970992e-016
+ pua=-1.7901642e-021       ub=2.8343576e-18          lub=-3.3308258e-24
+ wub=-1.8079948e-25        pub=1.801017e-30          uc=-2.2362049e-011
+ luc=-3.5281798e-016       wuc=7.1527948e-017        puc=2.9620114e-022
+ vsat=78400+dvsatn_na33    a0=4.08829                la0=-6.5287911e-06
+ wa0=-3.1092591e-06        pa0=6.1210439e-12         ags=0.49648423
+ lags=5.1113508e-006       wags=9.1673415e-007       pags=-3.2741006e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.05319211+0.0003362798
+ lketa=-5.9979091e-008-3.3498176e-09                 wketa=4.1155197e-008-3.365152e-09
+ pketa=-5.0061403e-014+3.3521625e-14                 dwg=0
+ dwb=0                     pclm=-0.050216044         lpclm=4.1533012e-007
+ wpclm=2.3567555e-007      ppclm=-5.0130345e-013     pdiblc1=0
+ pdiblc2=0.00015787937     lpdiblc2=-7.4986694e-011  wpdiblc2=-2.7615395e-011
+ ppdiblc2=9.0508939e-017   pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.064466e-018        lub1=8.3223805e-025       wub1=-2.3774844e-025
+ pub1=4.6632217e-031       uc1=-1.6310893e-10        luc1=7.8335461e-16
+ wuc1=8.8998662e-17        puc1=-8.8655223e-22       prt=0
+ at=183960.37              lat=-0.19162228           jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=1.339927e-09+dlvthn_na33
+ wvth0=6.8362649e-09+dwvthn_na33                     pvth0=-1.340865e-14+dpvthn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ noib=noibn_na33           noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     6: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na33
+ wmin=1.2e-006-dxwn_na33   wmax=1e-005-dxwn_na33     version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.025395472+dvthn_na33
+ k1=0.083826               k2=0.0007131239           lk2=-1.0332897e-08
+ wk2=8.48339e-10           pk2=-3.090054e-15         k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.13409419          lvoff=2.2914876e-008      wvoff=7.7389381e-009
+ pvoff=-1.3039015e-014     nfactor=0.8+dnfactorn_na33
+ eta0=0.021777966+deta0n_na33                        weta0=-5.823734e-009+dweta0n_na33
+ etab=-0.0014451533        letab=4.9691335e-009      wetab=-9.2202907e-010
+ petab=1.808477e-015       u0=0.057010084+du0n_na33  lu0=1.8249534e-08+dlu0n_na33
+ wu0=-5.2291659e-09+dwu0n_na33                       pu0=-1.2969584e-15+dpu0n_na33
+ ua=1.2361917e-009         lua=1.7096996e-015        wua=-2.5437827e-016
+ pua=-9.3873932e-022       ub=1.7194123e-18          lub=-1.1439695e-24
+ wub=6.9088787e-25         pub=9.12868e-32           uc=-1.9983058e-010
+ luc=-4.7294195e-018       wuc=3.4364521e-016        puc=-2.3753239e-022
+ vsat=78400+dvsatn_na33    a0=1.6454133              la0=-1.7373106e-06
+ wa0=-3.1958999e-07        pa0=6.4936333e-13         ags=-9.9452213+4.1272639
+ lags=2.5591817e-005-8.0952154e-06                   wags=1.3325745e-005-4.9816075e-06
+ pags=-2.7613259e-011+9.770925e-12                   a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.083185601-0.033018111-0.00336284+0.0019912491
+ lketa=-1.1496065e-09+6.4761723e-08+3.9056361e-09-3.9056361e-09
+ wketa=2.9340101e-08+3.985286e-08+3.365194e-08-1.992643e-08
+ pketa=-2.6887095e-14-7.81674e-14-3.90837e-14+3.90837e-14
+ dwg=0                     dwb=0                     pclm=0.33215077
+ lpclm=-3.3464797e-007     wpclm=1.0788531e-008      ppclm=-6.0207799e-014
+ pdiblc1=0                 pdiblc2=0.00012335961     lpdiblc2=-7.2792913e-012
+ wpdiblc2=2.2458608e-010   ppdiblc2=-4.0416155e-016  pdiblcb=0
+ drout=0.56                pvag=1.5                  delta=0.0075
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=600
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=11                    rdsw=0                    rsw=173
+ rdw=173                   prwg=0                    prwb=0
+ wr=1                      alpha0=2.46634e-008       alpha1=0.068220587
+ beta0=18.128904           agidl=1e-008              bgidl=2.3e+009
+ cgidl=0.5                 egidl=0.8                 xrcrg1=12
+ xrcrg2=1                  cgso=cgon_na33            cgdo=cgon_na33
+ cgbo=0                    cgdl=cgln_na33            cgsl=cgln_na33
+ clc=1e-007                cle=0.6                   cf=cfn_na33
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=7.931                noff=2.5571               voffcv=-0.0283
+ kt1=-0.2672704            lkt1=-4.897936e-008       kt1l=0
+ kt2=-0.02963              ute=-1.48                 ua1=1.67e-009
+ ub1=-2.64016e-018         uc1=5.4782804e-11         luc1=3.5597952e-16
+ wuc1=-1.0889215e-16       puc1=-4.9840647e-22       prt=0
+ at=128258.51              lat=-0.082368082          jss=8.43e-7
+ jsd=8.43e-7               jsws=1.36e-12             jswd=1.36e-12
+ jswgs=1.36e-12            jswgd=1.36e-12            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=19
+ bvd=19                    xjbvs=1                   xjbvd=1
+ pbs=0.5                   pbd=0.5                   cjs=cjn_na33
+ cjd=cjn_na33              mjs=0.33                  mjd=0.33
+ pbsws=0.5                 pbswd=0.5                 cjsws=cjswn_na33
+ cjswd=cjswn_na33          mjsws=0.06                mjswd=0.06
+ pbswgs=0.8                pbswgd=0.8                cjswgs=cjswgn_na33
+ cjswgd=cjswgn_na33        mjswgs=0.52               mjswgd=0.52
+ tpb=1.1e-3                tcj=9.5e-4                tpbsw=1.2e-3
+ tcjsw=5e-4                tpbswg=5e-4               tcjswg=7e-4
+ xtis=3                    xtid=3                    dmcg=1.135e-007
+ dmci=3.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.0185u
+ rshg=15.953               gbmin=1e-012              rbpb=50
+ rbpd=50                   rbps=50                   rbdb=50
+ rbsb=50                   saref=4.6e-7              sbref=4.6e-7
+ wlod=1e-7                 kvth0=0.5e-08             lkvth0=8.74e-8
+ wkvth0=+1.96e-006         pkvth0=0e-14              llodvth=1
+ wlodvth=1                 stk2=0.04e-9              lodk2=1
+ lodeta0=1                 ku0=-5.1e-8               lku0=1e-7
+ wku0=3.8e-07              pku0=2.0e-15              llodku0=1
+ wlodku0=1                 kvsat=1                   steta0=1e-9
+ tku0=0.8                  lvth0=-1.6190431e-08+dlvthn_na33
+ wvth0=-9.9632151e-09+dwvthn_na33                    pvth0=1.954185e-14+dpvthn_na33
+ lcit=0+dlcitn_na33        wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ noib=noibn_na33           noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     7: type=n 
+ lmin=9.99999e-006-dxln_na33                         lmax=900.00001e-06
+ wmin=5e-07                wmax=1.2e-006-dxwn_na33   version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.031822857+dvthn_na33
+ k1=0.083826               k2=0.0081064739           pk2=0
+ lk2=0                     wk2=-1.3236106e-08        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.12783168          wvoff=3.4500609e-009      nfactor=0.8+dnfactorn_na33
+ eta0=0.028641812+deta0n_na33                        weta0=-1.4108396e-008+dweta0n_na33
+ etab=0.0010882964         u0=0.06106174+du0n_na33   wu0=1.1659461e-009+dwu0n_na33
+ ua=1.2854346e-009         wua=-7.4749352e-017       ub=2.4999846e-018
+ uc=2.6115752e-011         vsat=78400+dvsatn_na33    a0=1.4766944
+ pa0=0                     la0=0                     wa0=-1.3366518e-07
+ ags=1.6647716             wags=-2.027371e-007       a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.029279813         dwg=0                     dwb=0
+ pclm=0.14504125           pdiblc1=0                 pdiblc2=0.000135
+ pdiblcb=0                 drout=0.56                pvag=1.5
+ delta=0.0075              pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=600                pdits=0                   pditsd=0
+ pditsl=0                  rsh=11                    rdsw=0
+ rsw=173                   rdw=173                   prwg=0
+ prwb=0                    wr=1                      alpha0=2.46634e-008
+ alpha1=0.068220587        beta0=18.128904           agidl=1e-008
+ bgidl=2.3e+009            cgidl=0.5                 egidl=0.8
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_na33
+ cgdo=cgon_na33            cgbo=0                    cgdl=cgln_na33
+ cgsl=cgln_na33            clc=1e-007                cle=0.6
+ cf=cfn_na33               ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=7.931                noff=2.5571
+ voffcv=-0.0283            kt1=-0.25871994           kt1l=0
+ kt2=-0.018492824          ute=-1.48                 ua1=1.67e-009
+ ub1=-3.13911e-018         uc1=-8.447e-011           prt=0
+ at=164723.91              jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na33              cjd=cjn_na33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na33          cjswd=cjswn_na33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na33        cjswgd=cjswgn_na33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=0+dlvthn_na33       wvth0=2.6226386e-09+dwvthn_na33
+ pvth0=0+dpvthn_na33       lu0=0+dlu0n_na33          pu0=0+dpu0n_na33
+ lcit=0+dlcitn_na33        wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ noib=noibn_na33           noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     8: type=n 
+ lmin=1.99999e-006-dxln_na33                         lmax=9.99999e-006-dxln_na33
+ wmin=5e-07                wmax=1.2e-006-dxwn_na33   version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.029954273+dvthn_na33
+ k1=0.083826               k2=0.0087146696           lk2=-6.0584809e-09
+ wk2=-1.329023e-08         pk2=5.391529e-16          k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.12905814          lvoff=1.221718e-008       wvoff=3.9046996e-009
+ pvoff=-4.528842e-015      nfactor=0.8+dnfactorn_na33
+ eta0=0.028641812+deta0n_na33                        weta0=-1.4108396e-008+dweta0n_na33
+ etab=0.0010882964         u0=0.062004206+du0n_na33  lu0=-9.3882913e-009+dlu0n_na33
+ wu0=2.040266e-010+dwu0n_na33                        pu0=9.5820743e-015+dpu0n_na33
+ ua=1.2896963e-009         lua=-4.2452701e-017       wua=-1.6188868e-016
+ pua=8.6803058e-022        ub=2.6703403e-18          lub=-1.6969828e-24
+ wub=1.7169379e-26         pub=-1.7103161e-31        uc=3.2781608e-011
+ luc=-6.6401324e-017       wuc=4.9695541e-018        puc=-4.9503766e-023
+ vsat=78400+dvsatn_na33    a0=1.5933008              la0=-1.1615648e-06
+ wa0=-9.7807026e-08        pa0=-3.571982e-13         ags=1.5962099
+ lags=6.8297174e-007       wags=-4.1063467e-007      pags=2.0709529e-012
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.01641015-0.0042275175
+ lketa=-1.2819999e-007+4.2111993e-08                 wketa=-3.2406274e-009+2.1433514e-09
+ pketa=3.2281218e-014-2.135078e-14                   dwg=0
+ dwb=0                     pclm=0.14504125           pdiblc1=0
+ pdiblc2=0.000135          pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.25050115
+ lkt1=-8.1870746e-008      kt1l=0                    kt2=-0.015762253
+ lkt2=-2.7200338e-008      ute=-1.48                 ua1=1.67e-009
+ ub1=-3.2614407e-018       lub1=1.2185862e-024       uc1=-9.2925035e-11
+ puc1=-4.2701561e-23       wuc1=4.2867027e-18        luc1=8.4223986e-17
+ prt=0                     at=183960.37              lat=-0.19162228
+ jss=8.43e-7               jsd=8.43e-7               jsws=1.36e-12
+ jswd=1.36e-12             jswgs=1.36e-12            jswgd=1.36e-12
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=19                    bvd=19                    xjbvs=1
+ xjbvd=1                   pbs=0.5                   pbd=0.5
+ cjs=cjn_na33              cjd=cjn_na33              mjs=0.33
+ mjd=0.33                  pbsws=0.5                 pbswd=0.5
+ cjsws=cjswn_na33          cjswd=cjswn_na33          mjsws=0.06
+ mjswd=0.06                pbswgs=0.8                pbswgd=0.8
+ cjswgs=cjswgn_na33        cjswgd=cjswgn_na33        mjswgs=0.52
+ mjswgd=0.52               tpb=1.1e-3                tcj=9.5e-4
+ tpbsw=1.2e-3              tcjsw=5e-4                tpbswg=5e-4
+ tcjswg=7e-4               xtis=3                    xtid=3
+ dmcg=1.135e-007           dmci=3.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.0185u              rshg=15.953               gbmin=1e-012
+ rbpb=50                   rbpd=50                   rbps=50
+ rbdb=50                   rbsb=50                   saref=4.6e-7
+ sbref=4.6e-7              wlod=1e-7                 kvth0=0.5e-08
+ lkvth0=8.74e-8            wkvth0=+1.96e-006         pkvth0=0e-14
+ llodvth=1                 wlodvth=1                 stk2=0.04e-9
+ lodk2=1                   lodeta0=1                 ku0=-5.1e-8
+ lku0=1e-7                 wku0=3.8e-07              pku0=2.0e-15
+ llodku0=1                 wlodku0=1                 kvsat=1
+ steta0=1e-9               tku0=0.8                  lvth0=-1.861371e-08+dlvthn_na33
+ wvth0=1.5509629e-09+dwvthn_na33                     pvth0=1.067539e-14+dpvthn_na33
+ lcit=0+dlcitn_na33        wcit=0+dwcitn_na33        pcit=0+dpcitn_na33
+ lnfactor=0+dlnfactorn_na33                          wnfactor=0+dwnfactorn_na33
+ pnfactor=0+dpnfactorn_na33                          leta0=0+dleta0n_na33
+ peta0=0+dpeta0n_na33      lvsat=0+dlvsatn_na33      wvsat=0+dwvsatn_na33
+ pvsat=0+dpvsatn_na33      fnoimod=1                 noia=noian_na33
+ noib=noibn_na33           noic=noicn_na33           em=1.12e+8
+ ef=1.0                   tnoimod=0                 kvth0we=0
+ k2we=0                    ku0we=0                   wec=0
+ web=0                     scref=1e-6                wpemod=1
+ ud=0                      minr=1e-3
 
 
     9: type=n 
+ lmin=1.2e-06              lmax=1.99999e-006-dxln_na33
+ wmin=5e-07                wmax=1.2e-006-dxwn_na33   version=4.5
+ rgeomod=1                 ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=0                  igbmod=0                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_na33
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=toxn_na33
+ toxm=5.6e-009             dtox=2.5232e-010          epsrox=3.9
+ wint=0                    lint=0                    ll=0
+ wl=0                      lln=1                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-3.859e-8+dxln_na33    xw=7e-09+dxwn_na33        dlc=0+ddlcn_na33
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.04049579+dvthn_na33
+ k1=0.083826               k2=0.0094210721           lk2=-7.4439613e-09
+ wk2=-9.6621541e-09        pk2=-6.5770003e-15        k3=2.6118349
+ k3b=-4.9758566            w0=0                      dvt0=0.064799587
+ dvt1=0.02075738           dvt2=0.30031818           dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.03344
+ minv=-0.5                 voffl=0                   dvtp0=8.4008771e-009
+ dvtp1=3.5                 lpe0=2.8116619e-009       lpeb=1.51e-010
+ xj=1.1e-007               ngate=5.9092e+020         ndep=5.11e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0+dcitn_na33
+ voff=-0.12106439          lvoff=-3.4618388e-009     wvoff=-7.9880317e-009
+ pvoff=1.879768e-014       nfactor=0.8+dnfactorn_na33
+ eta0=0.028641812+deta0n_na33                        leta0=-2.0005323e-016+dleta0n_na33
+ weta0=-1.4108396e-008+dweta0n_na33                  peta0=2.4146429e-022+dpeta0n_na33
+ etab=-0.0045972791        letab=1.1151745e-008      wetab=2.8825868e-009
+ petab=-5.6539345e-015     u0=0.053938061+du0n_na33  lu0=6.4326469e-09+dlu0n_na33
+ wu0=-1.5212336e-09+dwu0n_na33                       pu0=1.2966024e-14+dpu0n_na33
+ ua=1.6235236e-009         lua=-6.9722491e-016       wua=-7.2188788e-016
+ pua=1.9664186e-021        ub=1.4259873e-18          lub=7.43699e-25
+ wub=1.045052e-24          pub=-2.1871292e-30        uc=1.6131981e-010
+ luc=-3.1851744e-016       wuc=-9.2263315e-017       puc=1.4120976e-022
+ vsat=78400+dvsatn_na33-2103.008                     a0=1.8316083
+ la0=-1.6289837e-06        wa0=-5.4432737e-07        pa0=5.1861263e-13
+ ags=1.253264              lags=1.3556292e-006       wags=-1.9082677e-007
+ pags=1.6398195e-012       a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.080802003+0.042275703-0.025032846
+ lketa=-1.9011631e-009-4.9099425e-08+4.9099425e-08   wketa=2.6463098e-008-2.1433782e-08+1.2691653e-08
+ pketa=-2.5979966e-014+2.4893408e-14-2.4893408e-14   dwg=0
+ dwb=0                     pclm=0.53198689           lpclm=-7.5895904e-007
+ wpclm=-2.3041366e-007     ppclm=4.5193566e-013      pdiblc1=0
+ pdiblc2=0.00030623536     lpdiblc2=-3.3586275e-010  wpdiblc2=3.8550414e-012
+ ppdiblc2=-7.5613168e-018  pdiblcb=0                 drout=0.56
+ pvag=1.5                  delta=0.0075              pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=600                pdits=0
+ pditsd=0                  pditsl=0                  rsh=11
+ rdsw=0                    rsw=173                   rdw=173
+ prwg=0                    prwb=0                    wr=1
+ alpha0=2.46634e-008       alpha1=0.068220587        beta0=18.128904
+ agidl=1e-008              bgidl=2.3e+009            cgidl=0.5
+ egidl=0.8                 xrcrg1=12                 xrcrg2=1
+ cgso=cgon_na33            cgdo=cgon_na33            cgbo=0
+ cgdl=cgln_na33            cgsl=cgln_na33            clc=1e-007
+ cle=0.6                   cf=cfn_na33               ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=7.931
+ noff=2.5571               voffcv=-0.0283            kt1=-0.2672704
+ lkt1=-4.897936e-008       kt1l=0                    kt2=-0.02963
+ ute=-1.48                 ua1=1.67e-009             ub1=-2.64016e-018
+ uc1=2.1111487e-11         puc1=9.9573634e-23        wuc1=-6.8250869e-17
+ luc1=-1.3944725e-16       prt=0                     at=128258.51
+ lat=-0.082368082          jss=8.43e-7               jsd=8.43e-7
+ jsws=1.36e-12             jswd=1.36e-12             jswgs=1.36e-12
+ jswgd=1.36e-12            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=19                    bvd=19
+ xjbvs=1                   xjbvd=1                   pbs=0.5
+ pbd=0.5                   cjs=cjn_na33              cjd=cjn_na33
+ mjs=0.33                  mjd=0.33                  pbsws=0.5
+ pbswd=0.5                 cjsws=cjswn_na33          cjswd=cjswn_na33
+ mjsws=0.06                mjswd=0.06                pbswgs=0.8
+ pbswgd=0.8                cjswgs=cjswgn_na33        cjswgd=cjswgn_na33
+ mjswgs=0.52               mjswgd=0.52               tpb=1.1e-3
+ tcj=9.5e-4                tpbsw=1.2e-3              tcjsw=5e-4
+ tpbswg=5e-4               tcjswg=7e-4               xtis=3
+ xtid=3                    dmcg=1.135e-007           dmci=3.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.0185u              rshg=15.953
+ gbmin=1e-012              rbpb=50                   rbpd=50
+ rbps=50                   rbdb=50                   rbsb=50
+ saref=4.6e-7              sbref=4.6e-7              wlod=1e-7
+ kvth0=0.5e-08             lkvth0=8.74e-8            wkvth0=+1.96e-006
+ pkvth0=0e-14              llodvth=1                 wlodvth=1
+ stk2=0.04e-9              lodk2=1                   lodeta0=1
+ ku0=-5.1e-8               lku0=1e-7                 wku0=3.8e-07
+ pku0=2.0e-15              llodku0=1                 wlodku0=1
+ kvsat=1                   steta0=1e-9               tku0=0.8
+ lvth0=2.06242e-09+dlvthn_na33                       wvth0=8.2628678e-09+dwvthn_na33
+ pvth0=-2.489341e-15+dpvthn_na33                     lcit=0+dlcitn_na33
+ wcit=0+dwcitn_na33        pcit=0+dpcitn_na33        lnfactor=0+dlnfactorn_na33
+ wnfactor=0+dwnfactorn_na33                          pnfactor=0+dpnfactorn_na33
+ lvsat=0+dlvsatn_na33+0.0041248398                   wvsat=0+dwvsatn_na33+0.0025383306
+ pvsat=0+dpvsatn_na33-4.9786817e-09                  fnoimod=1
+ noia=noian_na33           noib=noibn_na33           noic=noicn_na33
+ em=1.12e+8             ef=1.0                   tnoimod=0
+ kvth0we=0                 k2we=0                    ku0we=0
+ wec=0                     web=0                     scref=1e-6
+ wpemod=1                  ud=0                      minr=1e-3
 
     } 
endsection mos_na33

//  *************************     COMMON STATISTICAL LIBRARY      ***************************

section stat_bip_dio
parameters random1_bip_dio=0
parameters par1_bip_dio=random1_bip_dio

statistics {
    process {
        vary random1_bip_dio dist=gauss std=1/3
        }
    }
endsection stat_bip_dio
 

section stat_mom
parameters random1_mom=0
parameters par1_mom=random1_mom

statistics {
    process {
        vary random1_mom dist=gauss std=1/1
        }
    }
endsection stat_mom
 

section stat_mim
parameters random1_mim=0
parameters par1_mim=random1_mim

statistics {
    process {
        vary random1_mim dist=gauss std=1/3
        }
    }
endsection stat_mim
 
//  *************************     LIBRARY OF STATISTICAL CASE     ***************************
 
 

section mc_bip
parameters a1_bip=par1_bip_dio * 3.0000e+000 * 3 / 3
parameters par_bjtp1=0
parameters par_bjtp2=0

parameters bfa=1.0000e+000 + ( - 5.0000e-002) * a1_bip
parameters isa=1.0000e+000 + ( - 1.0000e-001) * a1_bip
parameters nfa=1.0000e+000 + ( - 8.3333e-004) * a1_bip
parameters rba=1.0000e+000 + (6.6667e-002) * a1_bip
parameters rea=1.0000e+000 + (6.6667e-002) * a1_bip
parameters rca=1.0000e+000 + (6.6667e-002) * a1_bip
parameters rbma=1.0000e+000 + (6.6667e-002) * a1_bip
parameters cjea=1.0000e+000 + (2.3333e-002) * a1_bip
parameters cjca=1.0000e+000 + (2.3333e-002) * a1_bip
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=bip
endsection mc_bip
 
 
//  ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_bip
parameters bfa=1
parameters isa=1
parameters nfa=1
parameters rba=1
parameters rea=1
parameters rca=1
parameters rbma=1
parameters cjea=1
parameters cjca=1
parameters par_bjtp1=0
parameters par_bjtp2=0
include "crn65gplus_2d5_lk_v1d0.scs" section=bip
endsection tt_bip
 
//  ****************************  LIBRARY OF SS CORNER CASE  ******************************

section ss_bip
parameters bfa=0.85
parameters isa=0.7
parameters nfa=0.9975
parameters rba=1.2
parameters rea=1.2
parameters rca=1.2
parameters rbma=1.2
parameters cjea=1.07
parameters cjca=1.07
parameters par_bjtp1=0
parameters par_bjtp2=0
include "crn65gplus_2d5_lk_v1d0.scs" section=bip
endsection ss_bip
 
//  ****************************  LIBRARY OF FF CORNER CASE  ******************************

section ff_bip
parameters bfa=1.15
parameters isa=1.3
parameters nfa=1.0025
parameters rba=0.8
parameters rea=0.8
parameters rca=0.8
parameters rbma=0.8
parameters cjea=0.93
parameters cjca=0.93
parameters par_bjtp1=0
parameters par_bjtp2=0
include "crn65gplus_2d5_lk_v1d0.scs" section=bip
endsection ff_bip
 
//  *****************************************************************************************
//                                                                              
//             *
//                    MODELS OF VERTICAL P+/NW/SUB PNP BIPOLAR                  
//             *
//                                                                              
//             *
//  *****************************************************************************************

section bip
// 
// 
model pnp10 bjt type=pnp 
+ is=6.0825e-018*isa        bf=0.87183*bfa            nf=1.005*nfa
+ vaf=486.5                 ikf=0.0050905             ise=1.457e-018*isa
+ ne=1.1407                 br=0.0040146              nr=1.005
+ var=70.573                ikr=0.00163               isc=8.967e-018*isa
+ nc=1.22                   rb=54.201*rba             irb=0.001
+ rbm=0.1*rbma              re=4.3335*rea             rc=5.1294*rca
+ nkf=0.40006               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.0040824            tbr1=-1.4934e-006
+ tikf1=-0.005221           tikr1=-1e-010             tis1=5.6
+ tnc1=-1e-010              tne1=1e-010               tnf1=9.5467e-006
+ tnr1=6.7358e-005          trb1=0.002517             trc1=0.001419
+ tre1=0.00025              tvaf1=1e-010              tvar1=-1e-010
+ cje=1.090e-13*cjea        vje=0.7                   mje=0.31
+ cjc=8.347e-14*cjca        vjc=0.5                   mjc=0.325
+ fc=0                      ctc=2.16e-3               cte=8.5e-04
+ tvjc=2.60e-3              tvje=1.55e-03             rbmod=spice
+ minr=1e-3
// 
// 
model pnp5 bjt type=pnp 
+ is=1.6733e-018*isa        bf=0.98495*bfa            nf=1.005*nfa
+ vaf=482.25                ikf=0.0015955             ise=2.8356e-019*isa
+ ne=1.0928                 br=0.0015223              nr=1.0076
+ var=48.583                ikr=0.00163               isc=1.4147e-018*isa
+ nc=1.0584                 rb=70.997*rba             irb=0.001
+ rbm=0.1*rbma              re=7.7*rea                rc=10.112*rca
+ nkf=0.32141               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.0044281            tbr1=-0.00031521
+ tikf1=-0.005221           tikr1=4.2e-011            tis1=5.6
+ tnf1=2.475e-005           tnr1=0.0001476            trb1=0.002517
+ trc1=0.001419             tre1=0.00025              tvaf1=8e-011
+ tvar1=3.8e-011            cje=2.788e-14*cjea        vje=0.7
+ mje=0.31                  cjc=4.975e-14*cjca        vjc=0.5
+ mjc=0.325                 fc=0                      ctc=2.16e-3
+ cte=8.5e-04               tvjc=2.60e-3              tvje=1.55e-03
+ rbmod=spice               minr=1e-3
// 
// 
model pnp2 bjt type=pnp 
+ is=3.5395e-019*isa        bf=1.5745*bfa             nf=1.005*nfa
+ vaf=970.52                ikf=0.00015944            ise=4.1982e-019*isa
+ ne=1.124                  br=0.00044414             nr=0.9938
+ var=39.38                 ikr=0.0031406             isc=4.8435e-019*isa
+ nc=1.2603                 rb=147.17*rba             irb=0.001
+ rbm=0.1*rbma              re=4.9646*rea             rc=3.5882*rca
+ nkf=0.25479               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.0054499            tbr1=-9.684e-005
+ tikf1=-0.0051231          tikr1=4.2e-011            tis1=5.6
+ tnf1=2.475e-005           tnr1=0.0001476            trb1=0.00042689
+ trc1=0.001419             tre1=0.00025              tvaf1=8e-011
+ tvar1=3.8e-011            cje=4.768e-15*cjea        vje=0.7
+ mje=0.31                  cjc=3.285e-14*cjca        vjc=0.5
+ mjc=0.325                 fc=0                      ctc=2.16e-3
+ cte=8.5e-04               tvjc=2.60e-3              tvje=1.55e-03+0.748e-2*(1/sqrt(10e-6*10e-6*1e12))*par_bjtp2
+ rbmod=spice               minr=1e-3
//  ***BIP MISMATCH MODEL*************
subckt pnp10_mis ( c b e ) 
parameters ismis=1 + 0.413e-2 * (1 / sqrt(10e-6 * 10e-6 * 1e12)) * par_bjtp1 bfmis=1 
+ + 0.748e-2 * (1 / sqrt(10e-6 * 10e-6 * 1e12)) * par_bjtp2 
qin ( c b e ) pnp10
model pnp10 bjt type=pnp 
+ is=6.0825e-018*isa*ismis  bf=0.87183*bfa*bfmis      nf=1.005*nfa
+ vaf=486.5                 ikf=0.0050905             ise=1.457e-018*isa*ismis
+ ne=1.1407                 br=0.0040146              nr=1.005
+ var=70.573                ikr=0.00163               isc=8.967e-018*isa*ismis
+ nc=1.22                   rb=54.201*rba             irb=0.001
+ rbm=0.1*rbma              re=4.3335*rea             rc=5.1294*rca
+ nkf=0.40006               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.0040824            tbr1=-1.4934e-006
+ tikf1=-0.005221           tikr1=-1e-010             tis1=5.6
+ tnc1=-1e-010              tne1=1e-010               tnf1=9.5467e-006
+ tnr1=6.7358e-005          trb1=0.002517             trc1=0.001419
+ tre1=0.00025              tvaf1=1e-010              tvar1=-1e-010
+ cje=1.090e-13*cjea        vje=0.7                   mje=0.31
+ cjc=8.347e-14*cjca        vjc=0.5                   mjc=0.325
+ fc=0                      ctc=2.16e-3               cte=8.5e-04
+ tvjc=2.60e-3              tvje=1.55e-03             rbmod=spice
+ minr=1e-3
// 
// 
ends pnp10_mis
// 
// 
subckt pnp5_mis ( c b e ) 
parameters ismis=1 + 0.413e-2 * (1 / sqrt(5e-6 * 5e-6 * 1e12)) * par_bjtp1 bfmis=1 
+ + 0.748e-2 * (1 / sqrt(5e-6 * 5e-6 * 1e12)) * par_bjtp2 
qin ( c b e ) pnp5
model pnp5 bjt type=pnp 
+ is=1.6733e-018*isa*ismis  bf=0.98495*bfa*bfmis      nf=1.005*nfa
+ vaf=482.25                ikf=0.0015955             ise=2.8356e-019*isa*ismis
+ ne=1.0928                 br=0.0015223              nr=1.0076
+ var=48.583                ikr=0.00163               isc=1.4147e-018*isa*ismis
+ nc=1.0584                 rb=70.997*rba             irb=0.001
+ rbm=0.1*rbma              re=7.7*rea                rc=10.112*rca
+ nkf=0.32141               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.0044281            tbr1=-0.00031521
+ tikf1=-0.005221           tikr1=4.2e-011            tis1=5.6
+ tnf1=2.475e-005           tnr1=0.0001476            trb1=0.002517
+ trc1=0.001419             tre1=0.00025              tvaf1=8e-011
+ tvar1=3.8e-011            cje=2.788e-14*cjea        vje=0.7
+ mje=0.31                  cjc=4.975e-14*cjca        vjc=0.5
+ mjc=0.325                 fc=0                      ctc=2.16e-3
+ cte=8.5e-04               tvjc=2.60e-3              tvje=1.55e-03
+ rbmod=spice               minr=1e-3
// 
// 
ends pnp5_mis
subckt pnp2_mis ( c b e ) 
parameters ismis=1 + 0.413e-2 * (1 / sqrt(2e-6 * 2e-6 * 1e12)) * par_bjtp1 bfmis=1 
+ + 0.748e-2 * (1 / sqrt(2e-6 * 2e-6 * 1e12)) * par_bjtp2 
qin ( c b e ) pnp2
model pnp2 bjt type=pnp 
+ is=3.5395e-019*isa*ismis  bf=1.5745*bfa*bfmis       nf=1.005*nfa
+ vaf=970.52                ikf=0.00015944            ise=4.1982e-019*isa*ismis
+ ne=1.124                  br=0.00044414             nr=0.9938
+ var=39.38                 ikr=0.0031406             isc=4.8435e-019*isa*ismis
+ nc=1.2603                 rb=147.17*rba             irb=0.001
+ rbm=0.1*rbma              re=4.9646*rea             rc=3.5882*rca
+ nkf=0.25479               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=1
+ tlevc=1                   tbf1=0.0054499            tbr1=-9.684e-005
+ tikf1=-0.0051231          tikr1=4.2e-011            tis1=5.6
+ tnf1=2.475e-005           tnr1=0.0001476            trb1=0.00042689
+ trc1=0.001419             tre1=0.00025              tvaf1=8e-011
+ tvar1=3.8e-011            cje=4.768e-15*cjea        vje=0.7
+ mje=0.31                  cjc=3.285e-14*cjca        vjc=0.5
+ mjc=0.325                 fc=0                      ctc=2.16e-3
+ cte=8.5e-04               tvjc=2.60e-3              tvje=1.55e-03
+ rbmod=spice               minr=1e-3
// 
// 
ends pnp2_mis
 
endsection bip
 

section mc_bip_npn
parameters a1_bip_npn=par1_bip_dio * 3.0000e+000 * 3 / 3
parameters par_bjtn1=0
parameters par_bjtn2=0

parameters bfb=1.0000e+000 + ( - 5.0000e-002) * a1_bip_npn
parameters isb=1.0000e+000 + ( - 1.0000e-001) * a1_bip_npn
parameters nfb=1.0000e+000 + ( - 8.3333e-004) * a1_bip_npn
parameters rbb=1.0000e+000 + (6.6667e-002) * a1_bip_npn
parameters reb=1.0000e+000 + (6.6667e-002) * a1_bip_npn
parameters rcb=1.0000e+000 + (6.6667e-002) * a1_bip_npn
parameters rbmb=1.0000e+000 + (6.6667e-002) * a1_bip_npn
parameters cjeb=1.0000e+000 + (2.3333e-002) * a1_bip_npn
parameters cjcb=1.0000e+000 + (2.3333e-002) * a1_bip_npn
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=bip_npn
endsection mc_bip_npn
 
 
 
//  ****************************    LIBRARY OF TYPICAL CASE    ******************************

section tt_bip_npn
parameters bfb=1
parameters isb=1
parameters nfb=1
parameters rbb=1
parameters reb=1
parameters rcb=1
parameters rbmb=1
parameters cjeb=1
parameters cjcb=1
parameters par_bjtn1=0
parameters par_bjtn2=0
include "crn65gplus_2d5_lk_v1d0.scs" section=bip_npn
endsection tt_bip_npn
 
//  ****************************  LIBRARY OF SS CORNER CASE  ******************************

section ss_bip_npn
parameters bfb=0.85
parameters isb=0.7
parameters nfb=0.9975
parameters rbb=1.2
parameters reb=1.2
parameters rcb=1.2
parameters rbmb=1.2
parameters cjeb=1.07
parameters cjcb=1.07
parameters par_bjtn1=0
parameters par_bjtn2=0
include "crn65gplus_2d5_lk_v1d0.scs" section=bip_npn
endsection ss_bip_npn
 
//  ****************************  LIBRARY OF FF CORNER CASE  ******************************

section ff_bip_npn
parameters bfb=1.15
parameters isb=1.3
parameters nfb=1.0025
parameters rbb=0.8
parameters reb=0.8
parameters rcb=0.8
parameters rbmb=0.8
parameters cjeb=0.93
parameters cjcb=0.93
parameters par_bjtn1=0
parameters par_bjtn2=0
include "crn65gplus_2d5_lk_v1d0.scs" section=bip_npn
endsection ff_bip_npn
 
//  *****************************************************************************************
//                                                                              
//             *
//                    MODELS OF VERTICAL N+/PW/DNW NPN BIPOLAR                  
//             *
//                                                                              
//             *
//  *****************************************************************************************

section bip_npn
// 
// 
model npn10 bjt type=npn 
+ is=1.1552e-017*isb        bf=5.6172*bfb             nf=1.005*nfb
+ vaf=63.845                ikf=0.46482               ise=5.4092e-017*isb
+ ne=1.4114                 br=0.36812                nr=1
+ var=52.175                ikr=0.30733               isc=6.569e-018*isb
+ nc=2.0069                 rb=37.787*rbb             irb=0.001
+ rbm=0.1*rbmb              re=8.4989*reb             rc=8.9439*rcb
+ nkf=3.0039                tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=0
+ tlevc=1                   tbf1=0.000847             tbf2=1.7e-005
+ tbr1=0.0009464            tikf1=-0.0025404          tne1=0.0016695
+ trb1=0.0006472            trc1=0.000705             tre1=0.00054
+ cje=1.296e-13*cjeb        vje=0.7                   mje=0.32
+ cjc=2.684e-13*cjcb        vjc=0.7                   mjc=0.335
+ fc=0                      ctc=1.04e-03              cte=8.0e-04
+ tvjc=1.75e-03             tvje=1.6e-03              rbmod=spice
+ minr=1e-3
// 
// 
model npn5 bjt type=npn 
+ is=3.2177e-018*isb        bf=5.7024*bfb             nf=1.005*nfb
+ vaf=94.055                ikf=0.076312              ise=1.7852e-017*isb
+ ne=1.366                  br=0.19727                nr=1.0049
+ var=39.117                ikr=0.0396                isc=3.3802e-018*isb
+ nc=1.2769                 rb=136.78*rbb             irb=0.001
+ rbm=0.1*rbmb              re=7.0265*reb             rc=5.1386*rcb
+ nkf=1.3203                tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=0
+ tlevc=1                   tbf1=0.0010138            tbf2=1.6e-005
+ tbr1=0.00090125           tikf1=-0.0023709          tne1=0.0013049
+ tnf1=1e-010               trb1=0.0070414            trc1=0.00162
+ tre1=0.0063848            tvaf1=1e-010              tvar1=-1e-010
+ cje=3.303e-14*cjeb        vje=0.7                   mje=0.32
+ cjc=1.445e-13*cjcb        vjc=0.7                   mjc=0.335
+ fc=0                      ctc=1.04e-03              cte=8.0e-04
+ tvjc=1.75e-03             tvje=1.6e-03              rbmod=spice
+ minr=1e-3
// 
// 
model npn2 bjt type=npn 
+ is=6.49e-019*isb          bf=6.4954*bfb             nf=1.005*nfb
+ vaf=88.332                ikf=0.0035194             ise=9.0243e-019*isb
+ ne=1.1853                 br=0.11643                nr=1.0084
+ var=50.466                ikr=0.0086                isc=7.1479e-019*isb
+ nc=0.95086                rb=294.32*rbb             irb=0.001
+ rbm=0.1*rbmb              re=3.0158*reb             rc=13.31*rcb
+ nkf=0.40942               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=0
+ tlevc=1                   tbf1=0.0012384            tbf2=1.295e-005
+ tbr1=0.00086441           tikf1=-0.0059187          tikr1=-1e-010
+ tnc1=-1.8e-011            tne1=0.00053818           tnf1=1e-010
+ tnr1=1e-010               trb1=0.0026285            trc1=0.0001
+ tre1=0.0001               tvaf1=-1e-010             tvar1=-1e-010
+ cje=5.592e-15*cjeb        vje=0.7                   mje=0.32
+ cjc=8.822e-14*cjcb        vjc=0.7                   mjc=0.335
+ fc=0                      ctc=1.04e-03              cte=8.0e-04
+ tvjc=1.75e-03             tvje=1.6e-03+1.176e-2*(1/sqrt(10e-6*10e-6*1e12))*par_bjtn2
+ rbmod=spice               minr=1e-3
//  **BIP_NPN MISMATCH MODEL**********
subckt npn10_mis ( c b e ) 
parameters ismis=1 + 0.2e-2 * (1 / sqrt(10e-6 * 10e-6 * 1e12)) * par_bjtn1 bfmis=1 
+ + 1.176e-2 * (1 / sqrt(10e-6 * 10e-6 * 1e12)) * par_bjtn2 
qin ( c b e ) npn10
model npn10 bjt type=npn 
+ is=1.1552e-017*isb*ismis  bf=5.6172*bfb*bfmis       nf=1.005*nfb
+ vaf=63.845                ikf=0.46482               ise=5.4092e-017*isb*ismis
+ ne=1.4114                 br=0.36812                nr=1
+ var=52.175                ikr=0.30733               isc=6.569e-018*isb*ismis
+ nc=2.0069                 rb=37.787*rbb             irb=0.001
+ rbm=0.1*rbmb              re=8.4989*reb             rc=8.9439*rcb
+ nkf=3.0039                tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=0
+ tlevc=1                   tbf1=0.000847             tbf2=1.7e-005
+ tbr1=0.0009464            tikf1=-0.0025404          tne1=0.0016695
+ trb1=0.0006472            trc1=0.000705             tre1=0.00054
+ cje=1.296e-13*cjeb        vje=0.7                   mje=0.32
+ cjc=2.684e-13*cjcb        vjc=0.7                   mjc=0.335
+ fc=0                      ctc=1.04e-03              cte=8.0e-04
+ tvjc=1.75e-03             tvje=1.6e-03              rbmod=spice
+ minr=1e-3
// 
// 
ends npn10_mis
// 
// 
subckt npn5_mis ( c b e ) 
parameters ismis=1 + 0.2e-2 * (1 / sqrt(5e-6 * 5e-6 * 1e12)) * par_bjtn1 bfmis=1 
+ + 1.176e-2 * (1 / sqrt(5e-6 * 5e-6 * 1e12)) * par_bjtn2 
qin ( c b e ) npn5
model npn5 bjt type=npn 
+ is=3.2177e-018*isb*ismis  bf=5.7024*bfb*bfmis       nf=1.005*nfb
+ vaf=94.055                ikf=0.076312              ise=1.7852e-017*isb*ismis
+ ne=1.366                  br=0.19727                nr=1.0049
+ var=39.117                ikr=0.0396                isc=3.3802e-018*isb*ismis
+ nc=1.2769                 rb=136.78*rbb             irb=0.001
+ rbm=0.1*rbmb              re=7.0265*reb             rc=5.1386*rcb
+ nkf=1.3203                tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=0
+ tlevc=1                   tbf1=0.0010138            tbf2=1.6e-005
+ tbr1=0.00090125           tikf1=-0.0023709          tne1=0.0013049
+ tnf1=1e-010               trb1=0.0070414            trc1=0.00162
+ tre1=0.0063848            tvaf1=1e-010              tvar1=-1e-010
+ cje=3.303e-14*cjeb        vje=0.7                   mje=0.32
+ cjc=1.445e-13*cjcb        vjc=0.7                   mjc=0.335
+ fc=0                      ctc=1.04e-03              cte=8.0e-04
+ tvjc=1.75e-03             tvje=1.6e-03              rbmod=spice
+ minr=1e-3
// 
// 
ends npn5_mis
// 
// 
subckt npn2_mis ( c b e ) 
parameters ismis=1 + 0.2e-2 * (1 / sqrt(2e-6 * 2e-6 * 1e12)) * par_bjtn1 bfmis=1 
+ + 1.176e-2 * (1 / sqrt(2e-6 * 2e-6 * 1e12)) * par_bjtn2 
qin ( c b e ) npn2
model npn2 bjt type=npn 
+ is=6.49e-019*isb*ismis    bf=6.4954*bfb*bfmis       nf=1.005*nfb
+ vaf=88.332                ikf=0.0035194             ise=9.0243e-019*isb*ismis
+ ne=1.1853                 br=0.11643                nr=1.0084
+ var=50.466                ikr=0.0086                isc=7.1479e-019*isb*ismis
+ nc=0.95086                rb=294.32*rbb             irb=0.001
+ rbm=0.1*rbmb              re=3.0158*reb             rc=13.31*rcb
+ nkf=0.40942               tnom=25                   xtb=0
+ xti=3                     eg=1.18                   tlev=0
+ tlevc=1                   tbf1=0.0012384            tbf2=1.295e-005
+ tbr1=0.00086441           tikf1=-0.0059187          tikr1=-1e-010
+ tnc1=-1.8e-011            tne1=0.00053818           tnf1=1e-010
+ tnr1=1e-010               trb1=0.0026285            trc1=0.0001
+ tre1=0.0001               tvaf1=-1e-010             tvar1=-1e-010
+ cje=5.592e-15*cjeb        vje=0.7                   mje=0.32
+ cjc=8.822e-14*cjcb        vjc=0.7                   mjc=0.335
+ fc=0                      ctc=1.04e-03              cte=8.0e-04
+ tvjc=1.75e-03             tvje=1.6e-03              rbmod=spice
+ minr=1e-3
// 
ends npn2_mis
endsection bip_npn
 
 
 
 

section mc_dio
parameters a1_dio=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d=1.0000e+000 + ( - 1.2247e-001) * a1_dio
parameters x_jsw_d=0.0000e+000 + ( - 4.0825e-001) * a1_dio
parameters n_d=1.0000e+000 + ( - 1.0206e-003) * a1_dio
parameters rs_d=1.0000e+000 + (8.1650e-002) * a1_dio
parameters cj_d=1.0000e+000 + (2.8577e-002) * a1_dio
parameters cjsw_d=1.0000e+000 + (2.8577e-002) * a1_dio
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio
endsection mc_dio
 
//  *************************************************************
//                                                              *
//           Standard-vt Junction DIODE MODELS                  *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio
parameters is_d=1
parameters x_jsw_d=0
parameters n_d=1
parameters rs_d=1
parameters cj_d=1
parameters cjsw_d=1
include "crn65gplus_2d5_lk_v1d0.scs" section=dio
endsection tt_dio
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio
parameters is_d=0.7
parameters x_jsw_d=-1
parameters n_d=0.9975
parameters rs_d=1.2
parameters cj_d=1.07
parameters cjsw_d=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio
endsection ss_dio
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio
parameters is_d=1.3
parameters x_jsw_d=1
parameters n_d=1.0025
parameters rs_d=0.8
parameters cj_d=0.93
parameters cjsw_d=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio
endsection ff_dio
 
 

section mc_dio_hvt
parameters a1_dio_hvt=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_hvt=1.0000e+000 + ( - 1.2247e-001) * a1_dio_hvt
parameters x_jsw_d_hvt=0.0000e+000 + ( - 4.0825e-001) * a1_dio_hvt
parameters n_d_hvt=1.0000e+000 + ( - 1.0206e-003) * a1_dio_hvt
parameters rs_d_hvt=1.0000e+000 + (8.1650e-002) * a1_dio_hvt
parameters cj_d_hvt=1.0000e+000 + (2.8577e-002) * a1_dio_hvt
parameters cjsw_d_hvt=1.0000e+000 + (2.8577e-002) * a1_dio_hvt
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_hvt
endsection mc_dio_hvt
 
//  *************************************************************
//                                                              *
//           High-vt Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_hvt
parameters is_d_hvt=1.0
parameters x_jsw_d_hvt=0
parameters n_d_hvt=1.000
parameters rs_d_hvt=1.0
parameters cj_d_hvt=1.00
parameters cjsw_d_hvt=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_hvt
endsection tt_dio_hvt
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_hvt
parameters is_d_hvt=0.7
parameters x_jsw_d_hvt=-1
parameters n_d_hvt=0.9975
parameters rs_d_hvt=1.2
parameters cj_d_hvt=1.07
parameters cjsw_d_hvt=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_hvt
endsection ss_dio_hvt
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_hvt
parameters is_d_hvt=1.3
parameters x_jsw_d_hvt=1
parameters n_d_hvt=1.0025
parameters rs_d_hvt=0.8
parameters cj_d_hvt=0.93
parameters cjsw_d_hvt=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_hvt
endsection ff_dio_hvt
 
 

section mc_dio_lvt
parameters a1_dio_lvt=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_lvt=1.0000e+000 + ( - 1.2247e-001) * a1_dio_lvt
parameters x_jsw_d_lvt=0.0000e+000 + ( - 4.0825e-001) * a1_dio_lvt
parameters n_d_lvt=1.0000e+000 + ( - 1.0206e-003) * a1_dio_lvt
parameters rs_d_lvt=1.0000e+000 + (8.1650e-002) * a1_dio_lvt
parameters cj_d_lvt=1.0000e+000 + (2.8577e-002) * a1_dio_lvt
parameters cjsw_d_lvt=1.0000e+000 + (2.8577e-002) * a1_dio_lvt
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_lvt
endsection mc_dio_lvt
 
 
//  *************************************************************
//                                                              *
//           Low-vt Junction DIODE MODELS                       *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_lvt
parameters is_d_lvt=1.0
parameters x_jsw_d_lvt=0
parameters n_d_lvt=1.000
parameters rs_d_lvt=1.0
parameters cj_d_lvt=1.00
parameters cjsw_d_lvt=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_lvt
endsection tt_dio_lvt
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_lvt
parameters is_d_lvt=0.7
parameters x_jsw_d_lvt=-1
parameters n_d_lvt=0.9975
parameters rs_d_lvt=1.2
parameters cj_d_lvt=1.07
parameters cjsw_d_lvt=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_lvt
endsection ss_dio_lvt
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_lvt
parameters is_d_lvt=1.3
parameters x_jsw_d_lvt=1
parameters n_d_lvt=1.0025
parameters rs_d_lvt=0.8
parameters cj_d_lvt=0.93
parameters cjsw_d_lvt=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_lvt
endsection ff_dio_lvt
 
 
 

section mc_dio_18
parameters a1_dio_18=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_18=1.0000e+000 + ( - 1.2247e-001) * a1_dio_18
parameters x_jsw_d_18=0.0000e+000 + ( - 4.0825e-001) * a1_dio_18
parameters n_d_18=1.0000e+000 + ( - 1.0206e-003) * a1_dio_18
parameters rs_d_18=1.0000e+000 + (8.1650e-002) * a1_dio_18
parameters cj_d_18=1.0000e+000 + (2.8577e-002) * a1_dio_18
parameters cjsw_d_18=1.0000e+000 + (2.8577e-002) * a1_dio_18
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_18
endsection mc_dio_18
 
//  *************************************************************
//                                                              *
//           1.8V IO Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_18
parameters is_d_18=1.0
parameters x_jsw_d_18=0
parameters n_d_18=1.000
parameters rs_d_18=1.0
parameters cj_d_18=1.00
parameters cjsw_d_18=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_18
endsection tt_dio_18
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_18
parameters is_d_18=0.7
parameters x_jsw_d_18=-1
parameters n_d_18=0.9975
parameters rs_d_18=1.2
parameters cj_d_18=1.07
parameters cjsw_d_18=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_18
endsection ss_dio_18
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_18
parameters is_d_18=1.3
parameters x_jsw_d_18=1
parameters n_d_18=1.0025
parameters rs_d_18=0.8
parameters cj_d_18=0.93
parameters cjsw_d_18=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_18
endsection ff_dio_18
 
 
 

section mc_dio_25
parameters a1_dio_25=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_25=1.0000e+000 + ( - 1.2247e-001) * a1_dio_25
parameters x_jsw_d_25=0.0000e+000 + ( - 4.0825e-001) * a1_dio_25
parameters n_d_25=1.0000e+000 + ( - 1.0206e-003) * a1_dio_25
parameters rs_d_25=1.0000e+000 + (8.1650e-002) * a1_dio_25
parameters cj_d_25=1.0000e+000 + (2.8577e-002) * a1_dio_25
parameters cjsw_d_25=1.0000e+000 + (2.8577e-002) * a1_dio_25
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25
endsection mc_dio_25
 
//  *************************************************************
//                                                              *
//           2.5V IO Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_25
parameters is_d_25=1.0
parameters x_jsw_d_25=0
parameters n_d_25=1.000
parameters rs_d_25=1.0
parameters cj_d_25=1.00
parameters cjsw_d_25=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25
endsection tt_dio_25
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_25
parameters is_d_25=0.7
parameters x_jsw_d_25=-1
parameters n_d_25=0.9975
parameters rs_d_25=1.2
parameters cj_d_25=1.07
parameters cjsw_d_25=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25
endsection ss_dio_25
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_25
parameters is_d_25=1.3
parameters x_jsw_d_25=1
parameters n_d_25=1.0025
parameters rs_d_25=0.8
parameters cj_d_25=0.93
parameters cjsw_d_25=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25
endsection ff_dio_25
 

section mc_dio_25ud18
parameters a1_dio_25ud18=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_25ud18=1.0000e+000 + ( - 1.2247e-001) * a1_dio_25ud18
parameters x_jsw_d_25ud18=0.0000e+000 + ( - 4.0825e-001) * a1_dio_25ud18
parameters n_d_25ud18=1.0000e+000 + ( - 1.0206e-003) * a1_dio_25ud18
parameters rs_d_25ud18=1.0000e+000 + (8.1650e-002) * a1_dio_25ud18
parameters cj_d_25ud18=1.0000e+000 + (2.8577e-002) * a1_dio_25ud18
parameters cjsw_d_25ud18=1.0000e+000 + (2.8577e-002) * a1_dio_25ud18
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25ud18
endsection mc_dio_25ud18
 
//  *************************************************************************
// 									  *
//           Under-drive 1.8V IO Junction DIODE MODELS                      *
// 									  *
//  *************************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_25ud18
parameters is_d_25ud18=1.0
parameters x_jsw_d_25ud18=0
parameters n_d_25ud18=1.000
parameters rs_d_25ud18=1.0
parameters cj_d_25ud18=1.00
parameters cjsw_d_25ud18=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25ud18
endsection tt_dio_25ud18
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_25ud18
parameters is_d_25ud18=0.7
parameters x_jsw_d_25ud18=-1
parameters n_d_25ud18=0.9975
parameters rs_d_25ud18=1.2
parameters cj_d_25ud18=1.07
parameters cjsw_d_25ud18=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25ud18
endsection ss_dio_25ud18
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_25ud18
parameters is_d_25ud18=1.3
parameters x_jsw_d_25ud18=1
parameters n_d_25ud18=1.0025
parameters rs_d_25ud18=0.8
parameters cj_d_25ud18=0.93
parameters cjsw_d_25ud18=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25ud18
endsection ff_dio_25ud18
 
 

section mc_dio_25od33
parameters a1_dio_25od33=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_25od33=1.0000e+000 + ( - 1.2247e-001) * a1_dio_25od33
parameters x_jsw_d_25od33=0.0000e+000 + ( - 4.0825e-001) * a1_dio_25od33
parameters n_d_25od33=1.0000e+000 + ( - 1.0206e-003) * a1_dio_25od33
parameters rs_d_25od33=1.0000e+000 + (8.1650e-002) * a1_dio_25od33
parameters cj_d_25od33=1.0000e+000 + (2.8577e-002) * a1_dio_25od33
parameters cjsw_d_25od33=1.0000e+000 + (2.8577e-002) * a1_dio_25od33
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25od33
endsection mc_dio_25od33
 
//  *************************************************************
//                                                              *
//           3.3V IO Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_25od33
parameters is_d_25od33=1.0
parameters x_jsw_d_25od33=0
parameters n_d_25od33=1.000
parameters rs_d_25od33=1.0
parameters cj_d_25od33=1.00
parameters cjsw_d_25od33=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25od33
endsection tt_dio_25od33
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_25od33
parameters is_d_25od33=0.7
parameters x_jsw_d_25od33=-1
parameters n_d_25od33=0.9975
parameters rs_d_25od33=1.2
parameters cj_d_25od33=1.07
parameters cjsw_d_25od33=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25od33
endsection ss_dio_25od33
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_25od33
parameters is_d_25od33=1.3
parameters x_jsw_d_25od33=1
parameters n_d_25od33=1.0025
parameters rs_d_25od33=0.8
parameters cj_d_25od33=0.93
parameters cjsw_d_25od33=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_25od33
endsection ff_dio_25od33
 
 
 

section mc_dio_33
parameters a1_dio_33=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_33=1.0000e+000 + ( - 1.2247e-001) * a1_dio_33
parameters x_jsw_d_33=0.0000e+000 + ( - 4.0825e-001) * a1_dio_33
parameters n_d_33=1.0000e+000 + ( - 1.0206e-003) * a1_dio_33
parameters rs_d_33=1.0000e+000 + (8.1650e-002) * a1_dio_33
parameters cj_d_33=1.0000e+000 + (2.8577e-002) * a1_dio_33
parameters cjsw_d_33=1.0000e+000 + (2.8577e-002) * a1_dio_33
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_33
endsection mc_dio_33
 
//  *************************************************************
//                                                              *
//           3.3V IO Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_33
parameters is_d_33=1.0
parameters x_jsw_d_33=0
parameters n_d_33=1.000
parameters rs_d_33=1.0
parameters cj_d_33=1.00
parameters cjsw_d_33=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_33
endsection tt_dio_33
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_33
parameters is_d_33=0.7
parameters x_jsw_d_33=-1
parameters n_d_33=0.9975
parameters rs_d_33=1.2
parameters cj_d_33=1.07
parameters cjsw_d_33=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_33
endsection ss_dio_33
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_33
parameters is_d_33=1.3
parameters x_jsw_d_33=1
parameters n_d_33=1.0025
parameters rs_d_33=0.8
parameters cj_d_33=0.93
parameters cjsw_d_33=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_33
endsection ff_dio_33
 
 
 

section mc_dio_na
parameters a1_dio_na=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_na=1.0000e+000 + ( - 1.2247e-001) * a1_dio_na
parameters x_jsw_d_na=0.0000e+000 + ( - 4.0825e-001) * a1_dio_na
parameters n_d_na=1.0000e+000 + ( - 1.0206e-003) * a1_dio_na
parameters rs_d_na=1.0000e+000 + (8.1650e-002) * a1_dio_na
parameters cj_d_na=1.0000e+000 + (2.8577e-002) * a1_dio_na
parameters cjsw_d_na=1.0000e+000 + (2.8577e-002) * a1_dio_na
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na
endsection mc_dio_na
 
//  *************************************************************
//                                                              *
//           Native Junction DIODE MODELS                       *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_na
parameters is_d_na=1.0
parameters x_jsw_d_na=0
parameters n_d_na=1.000
parameters rs_d_na=1.0
parameters cj_d_na=1.00
parameters cjsw_d_na=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na
endsection tt_dio_na
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_na
parameters is_d_na=0.7
parameters x_jsw_d_na=-1
parameters n_d_na=0.9975
parameters rs_d_na=1.2
parameters cj_d_na=1.07
parameters cjsw_d_na=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na
endsection ss_dio_na
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_na
parameters is_d_na=1.3
parameters x_jsw_d_na=1
parameters n_d_na=1.0025
parameters rs_d_na=0.8
parameters cj_d_na=0.93
parameters cjsw_d_na=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na
endsection ff_dio_na
 

section mc_dio_na25
parameters a1_dio_na25=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_na25=1.0000e+000 + ( - 1.2247e-001) * a1_dio_na25
parameters x_jsw_d_na25=0.0000e+000 + ( - 4.0825e-001) * a1_dio_na25
parameters n_d_na25=1.0000e+000 + ( - 1.0206e-003) * a1_dio_na25
parameters rs_d_na25=1.0000e+000 + (8.1650e-002) * a1_dio_na25
parameters cj_d_na25=1.0000e+000 + (2.8577e-002) * a1_dio_na25
parameters cjsw_d_na25=1.0000e+000 + (2.8577e-002) * a1_dio_na25
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25
endsection mc_dio_na25
 
 
//  *************************************************************
//                                                              *
//           Native 2.5V IO Junction DIODE MODELS               *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_na25
parameters is_d_na25=1.0
parameters x_jsw_d_na25=0
parameters n_d_na25=1.000
parameters rs_d_na25=1.0
parameters cj_d_na25=1.00
parameters cjsw_d_na25=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25
endsection tt_dio_na25
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_na25
parameters is_d_na25=0.7
parameters x_jsw_d_na25=-1
parameters n_d_na25=0.9975
parameters rs_d_na25=1.2
parameters cj_d_na25=1.07
parameters cjsw_d_na25=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25
endsection ss_dio_na25
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_na25
parameters is_d_na25=1.3
parameters x_jsw_d_na25=1
parameters n_d_na25=1.0025
parameters rs_d_na25=0.8
parameters cj_d_na25=0.93
parameters cjsw_d_na25=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25
endsection ff_dio_na25
 

section mc_dio_na25od33
parameters a1_dio_na25od33=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_na25od33=1.0000e+000 + ( - 1.2247e-001) * a1_dio_na25od33
parameters x_jsw_d_na25od33=0.0000e+000 + ( - 4.0825e-001) * a1_dio_na25od33
parameters n_d_na25od33=1.0000e+000 + ( - 1.0206e-003) * a1_dio_na25od33
parameters rs_d_na25od33=1.0000e+000 + (8.1650e-002) * a1_dio_na25od33
parameters cj_d_na25od33=1.0000e+000 + (2.8577e-002) * a1_dio_na25od33
parameters cjsw_d_na25od33=1.0000e+000 + (2.8577e-002) * a1_dio_na25od33
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25od33
endsection mc_dio_na25od33
 
 
//  *************************************************************
//                                                              *
//           Native over-drive 3.3V IO Junction DIODE MODELS    *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_na25od33
parameters is_d_na25od33=1.0
parameters x_jsw_d_na25od33=0
parameters n_d_na25od33=1.000
parameters rs_d_na25od33=1.0
parameters cj_d_na25od33=1.00
parameters cjsw_d_na25od33=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25od33
endsection tt_dio_na25od33
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_na25od33
parameters is_d_na25od33=0.7
parameters x_jsw_d_na25od33=-1
parameters n_d_na25od33=0.9975
parameters rs_d_na25od33=1.2
parameters cj_d_na25od33=1.07
parameters cjsw_d_na25od33=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25od33
endsection ss_dio_na25od33
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_na25od33
parameters is_d_na25od33=1.3
parameters x_jsw_d_na25od33=1
parameters n_d_na25od33=1.0025
parameters rs_d_na25od33=0.8
parameters cj_d_na25od33=0.93
parameters cjsw_d_na25od33=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na25od33
endsection ff_dio_na25od33
 

section mc_dio_na33
parameters a1_dio_na33=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_na33=1.0000e+000 + ( - 1.2247e-001) * a1_dio_na33
parameters x_jsw_d_na33=0.0000e+000 + ( - 4.0825e-001) * a1_dio_na33
parameters n_d_na33=1.0000e+000 + ( - 1.0206e-003) * a1_dio_na33
parameters rs_d_na33=1.0000e+000 + (8.1650e-002) * a1_dio_na33
parameters cj_d_na33=1.0000e+000 + (2.8577e-002) * a1_dio_na33
parameters cjsw_d_na33=1.0000e+000 + (2.8577e-002) * a1_dio_na33
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na33
endsection mc_dio_na33
 
 
//  *************************************************************
// 							      *
//         Native 3.3V IO Junction DIODE MODELS                 *
// 							      *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_na33
parameters is_d_na33=1.0
parameters x_jsw_d_na33=0
parameters n_d_na33=1.000
parameters rs_d_na33=1.0
parameters cj_d_na33=1.00
parameters cjsw_d_na33=1.00
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na33
endsection tt_dio_na33
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_na33
parameters is_d_na33=0.7
parameters x_jsw_d_na33=-1
parameters n_d_na33=0.9975
parameters rs_d_na33=1.2
parameters cj_d_na33=1.07
parameters cjsw_d_na33=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na33
endsection ss_dio_na33
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_na33
parameters is_d_na33=1.3
parameters x_jsw_d_na33=1
parameters n_d_na33=1.0025
parameters rs_d_na33=0.8
parameters cj_d_na33=0.93
parameters cjsw_d_na33=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_na33
endsection ff_dio_na33
 

section mc_dio_dnw
parameters a1_dio_dnw=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_dnw=1.0000e+000 + ( - 1.2247e-001) * a1_dio_dnw
parameters x_jsw_d_dnw=0.0000e+000 + ( - 4.0825e-001) * a1_dio_dnw
parameters n_d_dnw=1.0000e+000 + ( - 1.0206e-003) * a1_dio_dnw
parameters rs_d_dnw=1.0000e+000 + (8.1650e-002) * a1_dio_dnw
parameters cj_d_dnw=1.0000e+000 + (2.8577e-002) * a1_dio_dnw
parameters cjsw_d_dnw=1.0000e+000 + (2.8577e-002) * a1_dio_dnw
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_dnw
endsection mc_dio_dnw
 
//  *************************************************************
//                                                              *
//           DNW Junction DIODE MODELS                          *
//                                                              *
//  *************************************************************
//  *************     CORNER_LIB OF TYPICAL MODEL     ***************

section tt_dio_dnw
parameters is_d_dnw=1
parameters x_jsw_d_dnw=0
parameters n_d_dnw=1
parameters rs_d_dnw=1
parameters cj_d_dnw=1
parameters cjsw_d_dnw=1
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_dnw
endsection tt_dio_dnw
 
//  *************     CORNER_LIB OF SLOW MODEL     ***************

section ss_dio_dnw
parameters is_d_dnw=0.7
parameters x_jsw_d_dnw=-1
parameters n_d_dnw=0.9975
parameters rs_d_dnw=1.2
parameters cj_d_dnw=1.07
parameters cjsw_d_dnw=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_dnw
endsection ss_dio_dnw
 
//  *************     CORNER_LIB OF FAST MODEL     ***************

section ff_dio_dnw
parameters is_d_dnw=1.3
parameters x_jsw_d_dnw=1
parameters n_d_dnw=1.0025
parameters rs_d_dnw=0.8
parameters cj_d_dnw=0.93
parameters cjsw_d_dnw=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_dnw
endsection ff_dio_dnw
 
 
 

section mc_dio_esd
parameters a1_dio_esd=par1_bip_dio * 2.4495e+000 * 3 / 3
parameters is_d_esd=1.0000e+000 + ( - 1.2247e-001) * a1_dio_esd
parameters x_jsw_d_esd=0.0000e+000 + ( - 4.0825e-001) * a1_dio_esd
parameters n_d_esd=1.0000e+000 + ( - 1.0206e-003) * a1_dio_esd
parameters rs_d_esd=1.0000e+000 + (8.1650e-002) * a1_dio_esd
parameters cj_d_esd=1.0000e+000 + (2.8577e-002) * a1_dio_esd
parameters cjsw_d_esd=1.0000e+000 + (2.8577e-002) * a1_dio_esd
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_esd
endsection mc_dio_esd
 
 
 
 
//  *************** CORNER_LIB OF TYPICAL MODEL ****************************

section tt_dio_esd
parameters is_d_esd=1
parameters x_jsw_d_esd=0
parameters n_d_esd=1
parameters rs_d_esd=1
parameters cj_d_esd=1
parameters cjsw_d_esd=1
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_esd
endsection tt_dio_esd
//  ***************** CORNER_LIB OF SLOW MODEL *****************************

section ss_dio_esd
parameters is_d_esd=0.7
parameters x_jsw_d_esd=-1
parameters n_d_esd=0.9975
parameters rs_d_esd=1.2
parameters cj_d_esd=1.07
parameters cjsw_d_esd=1.07
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_esd
endsection ss_dio_esd
//  ***************** CORNER_LIB OF FAST MODEL *****************************

section ff_dio_esd
parameters is_d_esd=1.3
parameters x_jsw_d_esd=1
parameters n_d_esd=1.0025
parameters rs_d_esd=0.8
parameters cj_d_esd=0.93
parameters cjsw_d_esd=0.93
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_esd
endsection ff_dio_esd
//  ************************************************************************
// 
 
//  *************************************************************
//                                                              *
//           Standard-vt Junction DIODE MODELS                  *
//                                                              *
//  *************************************************************

section dio
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
model ndio diode 
+ level=1                   is=1.35e-07*is_d          rs=1.0e-10*rs_d
+ n=1.02*n_d                bv=9.03                   ibv=0.03
+ isw=2.5e-13*pow(2,x_jsw_d)                          cj=0.00127*cj_d
+ pj=7.2e-4                 mj=0.32                   fc=0
+ cjsw=6.4e-11*cjsw_d       area=3.08e-8              mjsw=0.05
+ tlevc=1                   cta=8.0e-04               ctp=4.00e-04
+ trs=2.5e-3                tbv1=-1*-0.80e-03         tlev=1
+ xti=3                     eg=1.17                   vjsw=1.12
+ vj=0.7                    pta=1.6e-3                tnom=25
+ ptp=1e-03                 ns=1.02*n_d               nz=1.02*n_d
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
model pdio diode 
+ level=1                   is=1.73e-07*is_d          rs=1.0e-10*rs_d
+ n=1.02*n_d                bv=9.59                   ibv=0.03
+ isw=1.86e-13*pow(2,x_jsw_d)                         cj=1.06e-03*cj_d
+ pj=7.2e-4                 mj=0.31                   fc=0
+ cjsw=6.4e-11*cjsw_d       area=3.08e-8              mjsw=0.063
+ tlevc=1                   cta=8.5e-04               ctp=2.0e-04
+ trs=2.5e-3                tbv1=-1*-7.9e-04          tlev=1
+ xti=3                     eg=1.17                   vjsw=0.96
+ vj=0.7                    pta=1.55e-3               tnom=25
+ ptp=1.5e-03               ns=1.02*n_d               nz=1.02*n_d
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
model nwdio diode 
+ is=2.49e-6*is_d           isw=8.22e-13*pow(2,x_jsw_d)
+ rs=1.0e-10*rs_d           n=1.005*n_d               cj=1.388e-04*cj_d
+ cjsw=7.49e-10*cjsw_d      bv=11.8                   area=3.1161e-8
+ pj=7.24e-4                mj=0.325                  mjsw=0.31
+ vj=0.5                    vjsw=0.5                  trs=2.5e-3
+ tbv1=-1*-9.000e-04        cta=2.16e-3               ctp=1.3e-03
+ pta=2.60e-3               ptp=1.6e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.005*n_d              nz=1.005*n_d
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio
 
//  *************************************************************
//                                                              *
//           High-vt Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************

section dio_hvt
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_hvt diode 
+ is=1.203e-07*is_d_hvt     isw=1.666e-13*pow(2,x_jsw_d_hvt)
+ rs=1.0e-10*rs_d_hvt       n=1.005*n_d_hvt           cj=1.3297e-03*cj_d_hvt
+ cjsw=6.69e-11*cjsw_d_hvt  bv=8.92                   area=3.08e-8
+ pj=7.2e-4                 mj=0.34                   mjsw=0.06
+ vj=0.7                    vjsw=0.9                  trs=2.5e-3
+ tbv1=-1*-8.77e-04         cta=8.00e-04              ctp=3.0e-04
+ pta=1.55e-03              ptp=1.0e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.005*n_d_hvt          nz=1.005*n_d_hvt
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
// 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
 
model pdio_hvt diode 
+ is=1.45e-07*is_d_hvt      isw=1.57e-13*pow(2,x_jsw_d_hvt)
+ rs=1.0e-10*rs_d_hvt       n=1.005*n_d_hvt           cj=1.080e-03*cj_d_hvt
+ cjsw=6.4e-11*cjsw_d_hvt   bv=9.52                   area=3.08e-8
+ pj=7.2e-4                 mj=0.315                  mjsw=0.039
+ vj=0.7                    vjsw=0.49                 trs=2.5e-3
+ tbv1=-1*-9.3e-04          cta=9.50e-04              ctp=2.80e-04
+ pta=1.68e-03              ptp=2.10e-03              ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.005*n_d_hvt          nz=1.005*n_d_hvt
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_hvt
 
//  *************************************************************
//                                                              *
//           Low-vt Junction DIODE MODELS                       *
//                                                              *
//  *************************************************************

section dio_lvt
 
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_lvt diode 
+ is=1.368e-7*is_d_lvt      isw=1.828e-13*pow(2,x_jsw_d_lvt)
+ rs=1.0e-10*rs_d_lvt       n=1.007*n_d_lvt           cj=1.207e-03*cj_d_lvt
+ cjsw=6.4e-11*cjsw_d_lvt   bv=9.05                   area=3.08e-8
+ pj=7.2e-4                 mj=0.31                   mjsw=0.08
+ vj=0.73                   vjsw=1                    trs=2.5e-3
+ tbv1=-1*-8.00e-04         cta=0.00075               ctp=0.0009
+ pta=1.6e-03               ptp=1.0e-04               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.007*n_d_lvt          nz=1.007*n_d_lvt
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
// 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
 
model pdio_lvt diode 
+ is=1.53e-07*is_d_lvt      isw=4.96e-13*pow(2,x_jsw_d_lvt)
+ rs=1.0e-10*rs_d_lvt       n=1.005*n_d_lvt           cj=1.02e-03*cj_d_lvt
+ cjsw=6.4e-11*cjsw_d_lvt   bv=9.68                   area=3.08e-8
+ pj=7.2e-4                 mj=0.31                   mjsw=0.025
+ vj=0.7                    vjsw=0.75                 trs=2.5e-3
+ tbv1=-1*-8.0e-04          cta=8.7e-04               ctp=2.5e-04
+ pta=1.55e-03              ptp=5e-03                 ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.005*n_d_lvt          nz=1.005*n_d_lvt
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
endsection dio_lvt
 
 
//  *************************************************************
//                                                              *
//           1.8V IO Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************

section dio_18
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_18 diode 
+ is=1.32e-7*is_d_18        isw=6.273e-13*pow(2,x_jsw_d_18)
+ rs=1.0e-10*rs_d_18        n=1.02*n_d_18             cj=1.161e-03*cj_d_18
+ cjsw=1.16e-10*cjsw_d_18   bv=9.2                    area=3.92e-8
+ pj=8.4e-4                 mj=0.31                   mjsw=0.105
+ vj=0.7                    vjsw=0.48                 trs=2.5e-3
+ tbv1=-1*-9.3e-04          cta=8.5e-04               ctp=3e-04
+ pta=1.55e-03              ptp=1e-03                 ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_18            nz=1.02*n_d_18
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
 
model pdio_18 diode 
+ is=1.38e-7*is_d_18        isw=4.11e-13*pow(2,x_jsw_d_18)
+ rs=1.0e-10*rs_d_18        n=1.02*n_d_18             cj=1.12e-03*cj_d_18
+ cjsw=9.0e-11*cjsw_d_18    bv=9.0                    area=3.92e-8
+ pj=8.4e-4                 mj=0.32                   mjsw=0.085
+ vj=0.7                    vjsw=0.5                  trs=2.5e-3
+ tbv1=-1*-9.0e-04          cta=8.50e-04              ctp=3.00e-04
+ pta=1.55e-03              ptp=1.00e-03              ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_18            nz=1.02*n_d_18
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_18
 
//  *************************************************************
//                                                              *
//           2.5V IO Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************

section dio_25
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_25 diode 
+ is=1.32e-7*is_d_25        isw=6.273e-13*pow(2,x_jsw_d_25)
+ rs=1.0e-10*rs_d_25        n=1.02*n_d_25             cj=1.161e-03*cj_d_25
+ cjsw=1.16e-10*cjsw_d_25   bv=9.2                    area=3.92e-8
+ pj=8.4e-4                 mj=0.31                   mjsw=0.105
+ vj=0.7                    vjsw=0.48                 trs=2.5e-3
+ tbv1=-1*-9.3e-04          cta=8.5e-04               ctp=3e-04
+ pta=1.55e-03              ptp=1e-03                 ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_25            nz=1.02*n_d_25
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
 
model pdio_25 diode 
+ is=1.38e-7*is_d_25        isw=4.11e-13*pow(2,x_jsw_d_25)
+ rs=1.0e-10*rs_d_25        n=1.02*n_d_25             cj=1.12e-03*cj_d_25
+ cjsw=9.0e-11*cjsw_d_25    bv=9.0                    area=3.92e-8
+ pj=8.4e-4                 mj=0.32                   mjsw=0.085
+ vj=0.7                    vjsw=0.5                  trs=2.5e-3
+ tbv1=-1*-9.0e-04          cta=8.50e-04              ctp=3.00e-04
+ pta=1.55e-03              ptp=1.00e-03              ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_25            nz=1.02*n_d_25
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_25
 
//  *************************************************************************
// 									  *
//           Under-drive 1.8V IO Junction DIODE MODELS                      *
// 									  *
//  *************************************************************************

section dio_25ud18
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_25ud18 diode 
+ is=1.32e-7*is_d_25ud18    isw=6.273e-13*pow(2,x_jsw_d_25ud18)
+ rs=1.0e-10*rs_d_25ud18    n=1.02*n_d_25ud18         cj=1.161e-03*cj_d_25ud18
+ cjsw=1.16e-10*cjsw_d_25ud18                         bv=9.2
+ area=3.92e-8              pj=8.4e-4                 mj=0.31
+ mjsw=0.105                vj=0.7                    vjsw=0.48
+ trs=2.5e-3                tbv1=-1*-9.3e-04          cta=8.5e-04
+ ctp=3e-04                 pta=1.55e-03              ptp=1e-03
+ ibv=0.03                  tnom=25                   fc=0
+ tlev=1                    tlevc=1                   xti=3
+ eg=1.17                   level=1                   ns=1.02*n_d_25ud18
+ nz=1.02*n_d_25ud18        imax=1e40                 minr=1e-10
+ allow_scaling=1
 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
 
model pdio_25ud18 diode 
+ is=1.38e-7*is_d_25ud18    isw=4.11e-13*pow(2,x_jsw_d_25ud18)
+ rs=1.0e-10*rs_d_25ud18    n=1.02*n_d_25ud18         cj=1.12e-03*cj_d_25ud18
+ cjsw=9.0e-11*cjsw_d_25ud18                          bv=9.0
+ area=3.92e-8              pj=8.4e-4                 mj=0.32
+ mjsw=0.085                vj=0.7                    vjsw=0.5
+ trs=2.5e-3                tbv1=-1*-9.0e-04          cta=8.50e-04
+ ctp=3.00e-04              pta=1.55e-03              ptp=1.00e-03
+ ibv=0.03                  tnom=25                   fc=0
+ tlev=1                    tlevc=1                   xti=3
+ eg=1.17                   level=1                   ns=1.02*n_d_25ud18
+ nz=1.02*n_d_25ud18        imax=1e40                 minr=1e-10
+ allow_scaling=1
 
endsection dio_25ud18
 
//  *************************************************************
//                                                              *
//      Over-drive 3.3V IO Junction DIODE MODELS                *
//                                                              *
//  *************************************************************

section dio_25od33
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_25od33 diode 
+ is=1.32e-7*is_d_25od33    isw=6.273e-13*pow(2,x_jsw_d_25od33)
+ rs=1.0e-10*rs_d_25od33    n=1.02*n_d_25od33         cj=1.161e-03*cj_d_25od33
+ cjsw=1.16e-10*cjsw_d_25od33                         bv=9.2
+ area=3.92e-8              pj=8.4e-4                 mj=0.31
+ mjsw=0.105                vj=0.7                    vjsw=0.48
+ trs=2.5e-3                tbv1=-1*-9.3e-04          cta=8.5e-04
+ ctp=3e-04                 pta=1.55e-03              ptp=1e-03
+ ibv=0.03                  tnom=25                   fc=0
+ tlev=1                    tlevc=1                   xti=3
+ eg=1.17                   level=1                   ns=1.02*n_d_25od33
+ nz=1.02*n_d_25od33        imax=1e40                 minr=1e-10
+ allow_scaling=1
 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
 
model pdio_25od33 diode 
+ is=1.38e-7*is_d_25od33    isw=4.11e-13*pow(2,x_jsw_d_25od33)
+ rs=1.0e-10*rs_d_25od33    n=1.02*n_d_25od33         cj=1.12e-03*cj_d_25od33
+ cjsw=9.0e-11*cjsw_d_25od33                          bv=9.0
+ area=3.92e-8              pj=8.4e-4                 mj=0.32
+ mjsw=0.085                vj=0.7                    vjsw=0.5
+ trs=2.5e-3                tbv1=-1*-9.0e-04          cta=8.50e-04
+ ctp=3.00e-04              pta=1.55e-03              ptp=1.00e-03
+ ibv=0.03                  tnom=25                   fc=0
+ tlev=1                    tlevc=1                   xti=3
+ eg=1.17                   level=1                   ns=1.02*n_d_25od33
+ nz=1.02*n_d_25od33        imax=1e40                 minr=1e-10
+ allow_scaling=1
 
endsection dio_25od33
 
//  *************************************************************
//                                                              *
//           3.3V IO Junction DIODE MODELS                      *
//                                                              *
//  *************************************************************

section dio_33
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_33 diode 
+ is=1.32e-7*is_d_33        isw=6.273e-13*pow(2,x_jsw_d_33)
+ rs=1.0e-10*rs_d_33        n=1.02*n_d_33             cj=1.161e-03*cj_d_33
+ cjsw=1.16e-10*cjsw_d_33   bv=9.2                    area=3.92e-8
+ pj=8.4e-4                 mj=0.31                   mjsw=0.105
+ vj=0.7                    vjsw=0.48                 trs=2.5e-3
+ tbv1=-1*-9.3e-04          cta=8.5e-04               ctp=3e-04
+ pta=1.55e-03              ptp=1e-03                 ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_33            nz=1.02*n_d_33
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
//  *************************************************************
//                       MODEL OF P+/NW DIODE                   *
//                                                              *
//  *************************************************************
 
model pdio_33 diode 
+ is=1.38e-7*is_d_33        isw=4.11e-13*pow(2,x_jsw_d_33)
+ rs=1.0e-10*rs_d_33        n=1.02*n_d_33             cj=1.12e-03*cj_d_33
+ cjsw=9.0e-11*cjsw_d_33    bv=9.0                    area=3.92e-8
+ pj=8.4e-4                 mj=0.32                   mjsw=0.085
+ vj=0.7                    vjsw=0.5                  trs=2.5e-3
+ tbv1=-1*-9.0e-04          cta=8.50e-04              ctp=3.00e-04
+ pta=1.55e-03              ptp=1.00e-03              ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_33            nz=1.02*n_d_33
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_33
//  *************************************************************
//                                                              *
//           Native Junction DIODE MODELS                       *
//                                                              *
//  *************************************************************

section dio_na
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_na diode 
+ is=2.25e-6*is_d_na        isw=2.22e-12*pow(2,x_jsw_d_na)
+ rs=1.0e-10*rs_d_na        n=1.005*n_d_na            cj=1.62e-04*cj_d_na
+ cjsw=1.27e-10*cjsw_d_na   bv=19.0                   area=3.08e-8
+ pj=7.2e-4                 mj=0.31                   mjsw=0.01
+ vj=0.4                    vjsw=0.4                  trs=2.5e-3
+ tbv1=-1*-6.550e-04        cta=2.550e-3              ctp=3e-04
+ pta=2.2e-3                ptp=1.0e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.005*n_d_na           nz=1.005*n_d_na
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_na
 
//  *************************************************************
//                                                              *
//           Native 2.5V IO Junction DIODE MODELS               *
//                                                              *
//  *************************************************************

section dio_na25
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_na25 diode 
+ is=8.43e-7*is_d_na25      isw=1.36e-12*pow(2,x_jsw_d_na25)
+ rs=1.0e-10*rs_d_na25      n=1.02*n_d_na25           cj=1.4516e-04*cj_d_na25
+ cjsw=1.69e-10*cjsw_d_na25 bv=19                     area=3.08e-8
+ pj=7.2e-4                 mj=0.33                   mjsw=0.06
+ vj=0.5                    vjsw=0.5                  trs=1.3e-3
+ tbv1=-1*-7.00e-04         cta=9.5e-04               ctp=5e-04
+ pta=1.1e-03               ptp=1.2e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_na25          nz=1.02*n_d_na25
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_na25
 
//  *************************************************************
//                                                              *
//           Native over-drive 3.3V IO Junction DIODE MODELS    *
//                                                              *
//  *************************************************************

section dio_na25od33
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_na25od33 diode 
+ is=8.43e-7*is_d_na25od33  isw=1.36e-12*pow(2,x_jsw_d_na25od33)
+ rs=1.0e-10*rs_d_na25od33  n=1.02*n_d_na25od33       cj=1.4516e-04*cj_d_na25od33
+ cjsw=1.69e-10*cjsw_d_na25od33                       bv=19
+ area=3.08e-8              pj=7.2e-4                 mj=0.33
+ mjsw=0.06                 vj=0.5                    vjsw=0.5
+ trs=1.3e-3                tbv1=-1*-7.00e-04         cta=9.5e-04
+ ctp=5e-04                 pta=1.1e-03               ptp=1.2e-03
+ ibv=0.03                  tnom=25                   fc=0
+ tlev=1                    tlevc=1                   xti=3
+ eg=1.17                   level=1                   ns=1.02*n_d_na25od33
+ nz=1.02*n_d_na25od33      imax=1e40                 minr=1e-10
+ allow_scaling=1
 
endsection dio_na25od33
 
//  *************************************************************
// 							      *
//         Native 3.3V IO Junction DIODE MODELS                 *
// 							      *
//  *************************************************************

section dio_na33
// 
//  *************************************************************
//                       MODEL OF N+/PW DIODE                   *
//                                                              *
//  *************************************************************
 
model ndio_na33 diode 
+ is=8.43e-7*is_d_na33      isw=1.36e-12*pow(2,x_jsw_d_na33)
+ rs=1.0e-10*rs_d_na33      n=1.02*n_d_na33           cj=1.4516e-04*cj_d_na33
+ cjsw=1.69e-10*cjsw_d_na33 bv=19                     area=3.08e-8
+ pj=7.2e-4                 mj=0.33                   mjsw=0.06
+ vj=0.5                    vjsw=0.5                  trs=1.3e-3
+ tbv1=-1*-7.00e-04         cta=9.5e-04               ctp=5e-04
+ pta=1.1e-03               ptp=1.2e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.02*n_d_na33          nz=1.02*n_d_na33
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_na33
 
//  *************************************************************
//                                                              *
//           DNW Junction DIODE MODELS                          *
//                                                              *
//  *************************************************************

section dio_dnw
 
//  *************************************************************
//                      MODEL OF DNW/PSUB DIODE                 *
//                                                              *
//  *************************************************************
 
model dnwpsub diode 
+ is=2.44e-6*is_d_dnw       isw=5.88e-12*pow(2,x_jsw_d_dnw)
+ rs=1.0e-10*rs_d_dnw       n=1.005*n_d_dnw           cj=1.15e-04*cj_d_dnw
+ cjsw=1.39e-9*cjsw_d_dnw   bv=11.8                   area=3.1161e-8
+ pj=7.24e-4                mj=0.315                  mjsw=0.265
+ vj=0.56                   vjsw=0.45                 trs=2.5e-3
+ tbv1=-1*-8.500e-04        cta=2.20e-3               ctp=1.29e-03
+ pta=2.95e-3               ptp=1.7e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.005*n_d_dnw          nz=1.005*n_d_dnw
+ imax=1e40                 minr=1e-10                allow_scaling=1
//  *************************************************************
//                      MODEL OF PW/DNW DIODE                   *
//                                                              *
//  *************************************************************
 
model pwdnw diode 
+ level=1                   is=1.36e-07*is_d_dnw      rs=1.0e-10*rs_d_dnw
+ n=1.005*n_d_dnw           bv=12.2                   ibv=0.03
+ isw=2.07e-13*pow(2,x_jsw_d_dnw)                     cj=7.519e-04*cj_d_dnw
+ pj=6.824e-4               mj=0.335                  fc=0
+ cjsw=6.68e-10*cjsw_d_dnw  area=2.820436e-8          mjsw=0.32
+ tlevc=1                   cta=1.04e-03              ctp=1.28e-03
+ trs=2.5e-3                tbv1=-1*-8.50e-04         tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=1.75e-03              tnom=25
+ ptp=1.6e-03               ns=1.005*n_d_dnw          nz=1.005*n_d_dnw
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
endsection dio_dnw
 
 
//  *************************************************************
//                                                              *
//                    ESD Junction DIODE MODELS                 *
//                                                              *
//  *************************************************************
// 

section dio_esd
// 
//  *************************************************************
//                       MODEL OF ESD DIODE                     *
//                                                              *
//  *************************************************************
 
model ndio_esd diode 
+ level=1                   is=1.129e-07*is_d_esd     rs=1e-10*rs_d_esd
+ n=1.007*n_d_esd           bv=5.4                    ibv=0.03
+ isw=9.388e-13*pow(2,x_jsw_d_esd)                    cj=2.452e-03*cj_d_esd
+ pj=7.24e-4                mj=0.31                   fc=0
+ cjsw=1.55e-10*cjsw_d_esd  area=3.1161e-8            mjsw=0.1254
+ tlevc=1                   cta=7.5e-04               ctp=5.1e-04
+ trs=2.5e-3                tbv1=-1*-5e-05            tlev=1
+ xti=3                     eg=1.17                   vjsw=0.5
+ vj=0.7                    pta=1.55e-03              tnom=25
+ ptp=1.5e-03               ns=1.007*n_d_esd          nz=1.007*n_d_esd
+ imax=1e40                 minr=1e-10                allow_scaling=1
 
 
endsection dio_esd
 
 
//  *************************     COMMON STATISTICAL LIBRARY      ***************************

section stat_res
parameters random1_res=0
parameters random2_res=0
parameters random3_res=0
parameters random4_res=0
parameters par1_res=random1_res
parameters par2_res=random2_res
parameters par3_res=random3_res
parameters par4_res=random4_res
parameters par_res=0

statistics {
    process {
        vary random1_res dist=gauss std=1/3
        vary random2_res dist=gauss std=1/3
        vary random3_res dist=gauss std=1/3
        vary random4_res dist=gauss std=1/3
        }
    }
endsection stat_res
 
//  *************************     LIBRARY OF STATISTICAL CASE     ***************************
 
 

section mc_res
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_res
parameters a1_res_sal=par1_res * 3.4218e+000 * 3 / 3.1
parameters a2_res_sal=par2_res * 5.3952e-001 * 3 / 3.1
parameters a1_res_rpo=par3_res * 3.4503e+000 * 3 / 3.2
parameters a1_res_nw=par4_res * 1.4142e+000 * 3 / 3.1
parameters r_rppolyl=1.4819e+001 + (1.2933e+000) * a1_res_sal + ( - 7.8263e-001) 
+ * a2_res_sal
parameters r_rppolys=1.4819e+001 + (1.6155e+000) * a1_res_sal + ( - 1.0572e+000) 
+ * a2_res_sal
parameters dxw_rppolys=0.0000e+000 + (3.8481e-009) * a1_res_sal + (5.0350e-009) 
+ * a2_res_sal
parameters r_rnpolyl=1.5397e+001 + (1.3437e+000) * a1_res_sal + ( - 8.1313e-001) 
+ * a2_res_sal
parameters r_rnpolys=1.5397e+001 + (1.6548e+000) * a1_res_sal + ( - 1.1669e+000) 
+ * a2_res_sal
parameters dxw_rnpolys=0.0000e+000 + (4.0201e-009) * a1_res_sal + (5.7371e-009) 
+ * a2_res_sal
parameters r_rnodl=1.5246e+001 + (1.3306e+000) * a1_res_sal + ( - 8.0517e-001) * 
+ a2_res_sal
parameters r_rnods=1.5246e+001 + (1.3700e+000) * a1_res_sal + ( - 1.1568e+000) * 
+ a2_res_sal
parameters dxw_rnods=0.0000e+000 + (9.1059e-009) * a1_res_sal + (1.3135e-008) * 
+ a2_res_sal
parameters r_rpodl=1.4552e+001 + (1.2700e+000) * a1_res_sal + ( - 7.6853e-001) * 
+ a2_res_sal
parameters r_rpods=1.4552e+001 + (1.3277e+000) * a1_res_sal + ( - 1.1945e+000) * 
+ a2_res_sal
parameters dxw_rpods=0.0000e+000 + (9.7399e-009) * a1_res_sal + (1.5176e-008) * 
+ a2_res_sal
parameters r_rnodwo=1.0414e+002 + (5.4219e+000) * a1_res_rpo
parameters rend_rnodwo=5.3200e-006 + (7.6937e-007) * a1_res_rpo
parameters dxw_rnodwo=0.0000e+000 + (1.2276e-008) * a1_res_rpo
parameters r_rpodwo=2.5735e+002 + (1.1524e+001) * a1_res_rpo
parameters rend_rpodwo=4.9800e-006 + (1.0136e-006) * a1_res_rpo
parameters dxw_rpodwo=0.0000e+000 + (2.7691e-008) * a1_res_rpo
parameters r_rnpolywo=1.2445e+002 + (6.2924e+000) * a1_res_rpo
parameters rend_rnpolywo=4.2700e-006 + (6.1752e-007) * a1_res_rpo
parameters dxw_rnpolywo=0.0000e+000 + (1.7268e-008) * a1_res_rpo
parameters r_rppolywo=7.5621e+002 + (3.8236e+001) * a1_res_rpo
parameters rend_rppolywo=6.3400e-007 + (9.1688e-008) * a1_res_rpo
parameters dxw_rppolywo=0.0000e+000 + (1.8886e-008) * a1_res_rpo
parameters dxl_rnodwo=0.0000e+000
parameters dxl_rpodwo=0.0000e+000
parameters dxl_rnpolywo=0.0000e+000
parameters dxl_rppolywo=0.0000e+000
parameters r_rnwod=3.1600e+002 + (4.4689e+001) * a1_res_nw
parameters r_rnwsti=6.0500e+002 + (8.5560e+001) * a1_res_nw


parameters r_rm1l=0.0868
parameters r_rm1s=0.16
parameters r_rm1w=0.137
parameters r_rm2l=0.0778
parameters r_rm2s=0.1399
parameters r_rm2w=0.119
parameters r_rm3l=0.0778
parameters r_rm3s=0.1399
parameters r_rm3w=0.119
parameters r_rm4l=0.0778
parameters r_rm4s=0.1399
parameters r_rm4w=0.119
parameters r_rm5l=0.0778
parameters r_rm5s=0.1399
parameters r_rm5w=0.119
parameters r_rm6l=0.0778
parameters r_rm6s=0.1399
parameters r_rm6w=0.119
parameters r_rm7l=0.0778
parameters r_rm7s=0.1399
parameters r_rm7w=0.119
parameters r_rm8l=0.0215
parameters r_rm8s=0.0218
parameters r_rm8w=0.0227
parameters r_rm9l=0.0215
parameters r_rm9s=0.0218
parameters r_rm9w=0.0227
parameters r_rm10=0.021
parameters r_rmxl=0.0778
parameters r_rmxs=0.1399
parameters r_rmxw=0.119
parameters r_rmzl=0.0215
parameters r_rmzs=0.0218
parameters r_rmzw=0.0227 
 
parameters b1_rnpolywo=-1.75e-23
parameters b1_rppolywo=-1.75e-23
parameters a1_rnpolywo=4.75e-23
parameters a1_rppolywo=4.25e-23
parameters c1_rnpolywo=7.5e-23
parameters c1_rppolywo=7.5e-23
parameters kf_rnpolywo=a1_rnpolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rnpolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rnpolywo
parameters kf_rppolywo=a1_rppolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolywo
 
include "crn65gplus_2d5_lk_v1d0.scs" section=res
endsection mc_res
 
 
 

section tt_res
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_res
parameters par_res=0
parameters r_rnodwo=104.1410518
parameters rend_rnodwo=5.32e-06
parameters dxw_rnodwo=0
parameters dxl_rnodwo=0.0u
parameters r_rpodwo=257.3520919
parameters rend_rpodwo=4.98e-06
parameters dxw_rpodwo=0
parameters dxl_rpodwo=0.0u
parameters r_rnpolywo=124.4470272
parameters rend_rnpolywo=4.27e-06
parameters dxw_rnpolywo=0
parameters dxl_rnpolywo=0.0u
parameters r_rppolywo=756.206475
parameters rend_rppolywo=6.34e-07
parameters dxw_rppolywo=0
parameters dxl_rppolywo=0.0u
parameters r_rppolyl=14.81890631
parameters r_rppolys=14.81890631
parameters dxw_rppolys=0
parameters r_rnpolyl=15.39650316
parameters r_rnpolys=15.39650316
parameters dxw_rnpolys=0
parameters r_rnodl=15.24567155
parameters r_rnods=15.24567155
parameters dxw_rnods=0
parameters r_rpodl=14.552007
parameters r_rpods=14.552007
parameters dxw_rpods=0
parameters r_rnwod=316
parameters r_rnwsti=605
parameters r_rm1l=0.0868
parameters r_rm1s=0.16
parameters r_rm1w=0.137
parameters r_rm2l=0.0778
parameters r_rm2s=0.1399
parameters r_rm2w=0.119
parameters r_rm3l=0.0778
parameters r_rm3s=0.1399
parameters r_rm3w=0.119
parameters r_rm4l=0.0778
parameters r_rm4s=0.1399
parameters r_rm4w=0.119
parameters r_rm5l=0.0778
parameters r_rm5s=0.1399
parameters r_rm5w=0.119
parameters r_rm6l=0.0778
parameters r_rm6s=0.1399
parameters r_rm6w=0.119
parameters r_rm7l=0.0778
parameters r_rm7s=0.1399
parameters r_rm7w=0.119
parameters r_rm8l=0.0215
parameters r_rm8s=0.0218
parameters r_rm8w=0.0227
parameters r_rm9l=0.0215
parameters r_rm9s=0.0218
parameters r_rm9w=0.0227
parameters r_rm10=0.021
parameters r_rmxl=0.0778
parameters r_rmxs=0.1399
parameters r_rmxw=0.119
parameters r_rmzl=0.0215
parameters r_rmzs=0.0218
parameters r_rmzw=0.0227

parameters b1_rnpolywo=-1.75e-23
parameters b1_rppolywo=-1.75e-23
parameters a1_rnpolywo=4.75e-23
parameters a1_rppolywo=4.25e-23
parameters c1_rnpolywo=7.5e-23
parameters c1_rppolywo=7.5e-23
parameters kf_rnpolywo=a1_rnpolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rnpolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rnpolywo
parameters kf_rppolywo=a1_rppolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolywo

include "crn65gplus_2d5_lk_v1d0.scs" section=res
endsection tt_res
 

section ss_res
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_res
parameters par_res=0
parameters r_rnodwo=104.1410518 * 1.18
parameters rend_rnodwo=5.32e-06 * 1.50
parameters dxw_rnodwo=0 + 0.030u
parameters dxl_rnodwo=0.0u + 0.0u
parameters r_rpodwo=257.3520919 * 1.16
parameters rend_rpodwo=4.98e-06 * 1.60
parameters dxw_rpodwo=0 + 0.061u
parameters dxl_rpodwo=0.0u + 0.0u
parameters r_rnpolywo=124.4470272 * 1.18
parameters rend_rnpolywo=4.27e-06 * 1.50
parameters dxw_rnpolywo=0 + 0.040u
parameters dxl_rnpolywo=0.0u + 0.0u
parameters r_rppolywo=756.206475 * 1.18
parameters rend_rppolywo=6.34e-07 * 1.50
parameters dxw_rppolywo=0 + 0.043u
parameters dxl_rppolywo=0.0u + 0.0u
parameters r_rppolyl=14.81890631 * 1.30
parameters r_rppolys=14.81890631 * 1.38
parameters dxw_rppolys=0 + 0.006u
parameters r_rnpolyl=15.39650316 * 1.30
parameters r_rnpolys=15.39650316 * 1.38
parameters dxw_rnpolys=0 + 0.0058u
parameters r_rnodl=15.24567155 * 1.30
parameters r_rnods=15.24567155 * 1.33
parameters dxw_rnods=0 + 0.013u
parameters r_rpodl=14.552007 * 1.30
parameters r_rpods=14.552007 * 1.34
parameters dxw_rpods=0 + 0.0128u
parameters r_rnwod=316 * 1.20
parameters r_rnwsti=605 * 1.20
parameters r_rm1l=0.0868 * 1.2707
parameters r_rm1s=0.16 * 1.3188
parameters r_rm1w=0.137 * 1.2489
parameters r_rm2l=0.0778 * 1.2506
parameters r_rm2s=0.1399 * 1.2966
parameters r_rm2w=0.119 * 1.2244
parameters r_rm3l=0.0778 * 1.2506
parameters r_rm3s=0.1399 * 1.2966
parameters r_rm3w=0.119 * 1.2244
parameters r_rm4l=0.0778 * 1.2506
parameters r_rm4s=0.1399 * 1.2966
parameters r_rm4w=0.119 * 1.2244
parameters r_rm5l=0.0778 * 1.2506
parameters r_rm5s=0.1399 * 1.2966
parameters r_rm5w=0.119 * 1.2244
parameters r_rm6l=0.0778 * 1.2506
parameters r_rm6s=0.1399 * 1.2966
parameters r_rm6w=0.119 * 1.2244
parameters r_rm7l=0.0778 * 1.2506
parameters r_rm7s=0.1399 * 1.2966
parameters r_rm7w=0.119 * 1.2244
parameters r_rm8l=0.0215 * 1.20
parameters r_rm8s=0.0218 * 1.1972
parameters r_rm8w=0.0227 * 1.1322
parameters r_rm9l=0.0215 * 1.20
parameters r_rm9s=0.0218 * 1.1972
parameters r_rm9w=0.0227 * 1.1322
parameters r_rm10=0.021 * 1.162
parameters r_rmxl=0.0778 * 1.2506
parameters r_rmxs=0.1399 * 1.2966
parameters r_rmxw=0.119 * 1.2244
parameters r_rmzl=0.0215 * 1.20
parameters r_rmzs=0.0218 * 1.1972
parameters r_rmzw=0.0227 * 1.1322

parameters b1_rnpolywo=-1.75e-23
parameters b1_rppolywo=-1.75e-23
parameters a1_rnpolywo=4.75e-23
parameters a1_rppolywo=4.25e-23
parameters c1_rnpolywo=7.5e-23
parameters c1_rppolywo=7.5e-23
parameters kf_rnpolywo=a1_rnpolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rnpolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rnpolywo
parameters kf_rppolywo=a1_rppolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolywo

include "crn65gplus_2d5_lk_v1d0.scs" section=res
endsection ss_res
 

section ff_res
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_res
parameters par_res=0
parameters r_rnodwo=104.1410518 * 0.82
parameters rend_rnodwo=5.32e-06 * 0.50
parameters dxw_rnodwo=0 - 0.054u
parameters dxl_rnodwo=0.0u + 0.0u
parameters r_rpodwo=257.3520919 * 0.85
parameters rend_rpodwo=4.98e-06 * 0.20
parameters dxw_rpodwo=0 - 0.128u
parameters dxl_rpodwo=0.0u + 0.0u
parameters r_rnpolywo=124.4470272 * 0.83
parameters rend_rnpolywo=4.27e-06 * 0.50
parameters dxw_rnpolywo=0 - 0.078u
parameters dxl_rnpolywo=0.0u + 0.0u
parameters r_rppolywo=756.206475 * 0.83
parameters rend_rppolywo=6.34e-07 * 0.50
parameters dxw_rppolywo=0 - 0.086u
parameters dxl_rppolywo=0.0u + 0.0u
parameters r_rppolyl=14.81890631 * 0.70
parameters r_rppolys=14.81890631 * 0.63
parameters dxw_rppolys=0 - 0.0197u
parameters r_rnpolyl=15.39650316 * 0.70
parameters r_rnpolys=15.39650316 * 0.64
parameters dxw_rnpolys=0 - 0.021u
parameters r_rnodl=15.24567155 * 0.70
parameters r_rnods=15.24567155 * 0.71
parameters dxw_rnods=0 - 0.04769u
parameters r_rpodl=14.552007 * 0.70
parameters r_rpods=14.552007 * 0.71
parameters dxw_rpods=0 - 0.052u
parameters r_rnwod=316 * 0.80
parameters r_rnwsti=605 * 0.80
parameters r_rm1l=0.0868 * 0.8065
parameters r_rm1s=0.16 * 0.7838
parameters r_rm1w=0.137 * 0.8182
parameters r_rm2l=0.0778 * 0.8162
parameters r_rm2s=0.1399 * 0.7927
parameters r_rm2w=0.119 * 0.8303
parameters r_rm3l=0.0778 * 0.8162
parameters r_rm3s=0.1399 * 0.7927
parameters r_rm3w=0.119 * 0.8303
parameters r_rm4l=0.0778 * 0.8162
parameters r_rm4s=0.1399 * 0.7927
parameters r_rm4w=0.119 * 0.8303
parameters r_rm5l=0.0778 * 0.8162
parameters r_rm5s=0.1399 * 0.7927
parameters r_rm5w=0.119 * 0.8303
parameters r_rm6l=0.0778 * 0.8162
parameters r_rm6s=0.1399 * 0.7927
parameters r_rm6w=0.119 * 0.8303
parameters r_rm7l=0.0778 * 0.8162
parameters r_rm7s=0.1399 * 0.7927
parameters r_rm7w=0.119 * 0.8303
parameters r_rm8l=0.0215 * 0.8419
parameters r_rm8s=0.0218 * 0.8440
parameters r_rm8w=0.0227 * 0.8855
parameters r_rm9l=0.0215 * 0.8419
parameters r_rm9s=0.0218 * 0.8440
parameters r_rm9w=0.0227 * 0.8855
parameters r_rm10=0.021 * 0.843
parameters r_rmxl=0.0778 * 0.8162
parameters r_rmxs=0.1399 * 0.7927
parameters r_rmxw=0.119 * 0.8303
parameters r_rmzl=0.0215 * 0.8419
parameters r_rmzs=0.0218 * 0.8440
parameters r_rmzw=0.0227 * 0.8855

parameters b1_rnpolywo=-1.75e-23
parameters b1_rppolywo=-1.75e-23
parameters a1_rnpolywo=4.75e-23
parameters a1_rppolywo=4.25e-23
parameters c1_rnpolywo=7.5e-23
parameters c1_rppolywo=7.5e-23
parameters kf_rnpolywo=a1_rnpolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rnpolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rnpolywo
parameters kf_rppolywo=a1_rppolywo * (abs(rnoiseflag_res) + rnoiseflag_res) + b1_rppolywo 
+ * (abs(rnoiseflag_res) - rnoiseflag_res) + c1_rppolywo

include "crn65gplus_2d5_lk_v1d0.scs" section=res
endsection ff_res
 

section res
 
//  *********************************     N+OD w/o silicide resistor     ***********************************
subckt rnodwo ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.002461 * geo_fac * par_res * mismatchflag rsh=r_rnodwo 
+ * (1 + factmis) rend0=rend_rnodwo * (1 + factmis) dw=0.003u + dxw_rnodwo dl=0 
+ + dxl_rnodwo pvcp1=0.1115 pvcp2=1.17e-05 pvcp3=1.583 ptcp1=1.58e-03 ptcp2=4.18e-07 
+ pvce1=1.134 pvce2=-230.8184 pvce3=-1.3458 ptce1=2.51e-03 ptce2=-1.38e-06 tface=1.0 
+ + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * 
+ (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rp ( 3 4 ) bsource r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp * (1 
+ + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rnodwo
 
//  *********************************     P+OD w/o silicide resistor     ***********************************
subckt rpodwo ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.0041 * geo_fac * par_res * mismatchflag rsh=r_rpodwo 
+ * (1 + factmis) rend0=rend_rpodwo * (1 + factmis) dw=0.0001u + dxw_rpodwo dl=0 
+ + dxl_rpodwo pvcp1=-0.0137 pvcp2=-5.50e-06 pvcp3=0.9113 ptcp1=1.33e-03 ptcp2=5.71e-07 
+ pvce1=0.0768 pvce2=-1.34e+03 pvce3=-0.4978 ptce1=3.54e-04 ptce2=1.59e-06 tface=1.0 
+ + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 + ptcp1 * 
+ (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rp ( 3 4 ) bsource r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp * (1 
+ + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3)))
rend2 ( 4 n2 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rpodwo
 
//  *********************************     N+POLY w/o silicide resistor     ***********************************
subckt rnpolywo ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.033 * geo_fac * par_res * mismatchflag rsh=r_rnpolywo 
+ * (1 + factmis) rend0=rend_rnpolywo * (1 + factmis) dw=0.0691u + dxw_rnpolywo 
+ dl=0 + dxl_rnpolywo pvcp1=-5.8869 pvcp2=-0.000066371 pvcp3=-3.9236 ptcp1=1.75e-04 
+ ptcp2=2.52e-07 pvce1=1.7575 pvce2=-4383.7 pvce3=-1.4398 ptce1=2.52e-03 ptce2=9.92e-06 
+ tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 
+ + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rp ( 3 4 ) bsource r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp * (1 
+ + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3))) l=l-dl w=mf*(w-dw) kf=kf_rnpolywo af=2 fexp=0.86 wdexp=1 ldexp=1
rend2 ( 4 n2 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rnpolywo
 
//  *********************************     P+POLY w/o silicide resistor     ***********************************
subckt rppolywo ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.007 * geo_fac * par_res * mismatchflag rsh=r_rppolywo 
+ * (1 + factmis) rend0=rend_rppolywo * (1 + factmis) dw=0.0583u + dxw_rppolywo 
+ dl=0 + dxl_rppolywo pvcp1=0.0588 pvcp2=-0.000005457 pvcp3=2.6393 ptcp1=-3.44e-04 
+ ptcp2=7.32e-07 pvce1=2.1812 pvce2=-369.5605 pvce3=-2.7756 ptce1=-2.83e-03 ptce2=5.84e-06 
+ tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 
+ + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n1 3 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,3)) + pvce3) - tanh(pvce3)))
rp ( 3 4 ) bsource r=rsh / mf * (l * factor - dl) / (w * factor - dw) * tfacp * (1 
+ + pvcp1 * (tanh(pvcp2 * abs(v(3,4) / (l * factor - dl)) + pvcp3) - tanh(pvcp3))) l=l-dl w=mf*(w-dw) kf=kf_rppolywo af=2 fexp=0.9 wdexp=1 ldexp=1 
rend2 ( 4 n2 ) bsource r=rend0 / mf / w / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(4,n2)) + pvce3) - tanh(pvce3)))
ends rppolywo
 
//  *********************************     P+POLY silicide resistor (W>=2.0um)   
//   ***********************************
subckt rppolyl ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.0113 * geo_fac * par_res * mismatchflag rsh=r_rppolyl 
+ * (1 + factmis) dw=-0.01549u pvc1=3.53e-07 pvc2=7.56e-12 ptc1=0.00230054 ptc2=-3.32e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rppolyl
 
//  *********************************     P+POLY silicide resistor (W<2.0um)    
//  ***********************************
subckt rppolys ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.0113 * geo_fac * par_res * mismatchflag rsh=r_rppolys 
+ * (1 + factmis) dw= - 0.01549u + dxw_rppolys pvc1=4.28e-08 pvc2=7.04e-13 ptc1=0.002614034 
+ ptc2=-5.37e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
+ 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rppolys
 
//  *********************************     N+POLY silicide resistor (W>=2.0um)   
//   ***********************************
subckt rnpolyl ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.00776 * geo_fac * par_res * mismatchflag rsh=r_rnpolyl 
+ * (1 + factmis) dw=-0.01204u pvc1=3.39e-09 pvc2=6.01e-14 ptc1=0.002092435 ptc2=-4.21e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rnpolyl
 
//  *********************************     N+POLY silicide resistor (W<2.0um)    
//  ***********************************
subckt rnpolys ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.00776 * geo_fac * par_res * mismatchflag rsh=r_rnpolys 
+ * (1 + factmis) dw= - 0.01204u + dxw_rnpolys pvc1=4.04e-08 pvc2=5.83e-13 ptc1=0.002431439 
+ ptc2=-6.10e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
+ 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rnpolys
 
//  *********************************     N+OD silicide resistor (W>=2.0um)     
// ***********************************
subckt rnodl ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.01039 * geo_fac * par_res * mismatchflag rsh=r_rnodl 
+ * (1 + factmis) dw=-0.02258u pvc1=4.20e-08 pvc2=6.36e-13 ptc1=0.002026898 ptc2=-3.42e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rnodl
 
//  *********************************     N+OD silicide resistor (W<2.0um)     ***********************************
subckt rnods ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.01039 * geo_fac * par_res * mismatchflag rsh=r_rnods 
+ * (1 + factmis) dw= - 0.02258u + dxw_rnods pvc1=2.72e-08 pvc2=5.53e-14 ptc1=0.00230755 
+ ptc2=-4.78e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
+ 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rnods
 
//  *********************************     P+OD silicide resistor (W>=2.0um)     
// ***********************************
subckt rpodl ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.01449 * geo_fac * par_res * mismatchflag rsh=r_rpodl 
+ * (1 + factmis) dw=-0.03068u pvc1=-1.23e-09 pvc2=4.05e-13 ptc1=0.002190805 ptc2=-2.37e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rpodl
 
//  *********************************     P+OD silicide resistor (W<2.0um)     ***********************************
subckt rpods ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * l * factor 
+ * w * factor * 1e12) factmis=0.01449 * geo_fac * par_res * mismatchflag rsh=r_rpods 
+ * (1 + factmis) dw= - 0.03068u + dxw_rpods pvc1=2.39e-08 pvc2=-3.99e-14 ptc1=0.002261914 
+ ptc2=-4.41e-07 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
+ 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rpods
 
//  *********************************     N-Well under OD resistor     ***********************************
subckt rnwod ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 rsh=r_rnwod dw=0.21u pvc1=0.005037 pvc2=0.0001668 
+ ptc1=2.93e-03 ptc2=9.99e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) 
+ * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnwod
 
//  *********************************     N-well under STI resistor     ***********************************
subckt rnwsti ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp mf=1 rsh=r_rnwsti dw=0.30u pvc1=0.00629 pvc2=-1.97e-04 
+ ptc1=2.30e-03 ptc2=9.34e-06 tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) 
+ * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh / mf * l * factor / (w * factor - dw) * (1 + pvc1 * abs(v(n2,n1)) 
+ + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
ends rnwsti
 
//  *********************************     Metal 1 with W/S=0.09/0.45     ***********************************
subckt rm1l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm1l dw=0 pvc1=0 pvc2=0 ptc1=2.650e-03 ptc2=-2.641e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm1l
 
//  *********************************     Metal 1 with W/S=0.09/0.09     ***********************************
subckt rm1s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm1s dw=0 pvc1=0 pvc2=0 ptc1=2.650e-03 ptc2=-2.641e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm1s
 
//  *********************************     Metal 1 with W/S=0.27/0.135     ***********************************
subckt rm1w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm1w dw=0 pvc1=0 pvc2=0 ptc1=2.650e-03 ptc2=-2.641e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm1w
 
//  *********************************     Metal 2with W/S=0.1/0.5     ***********************************
subckt rm2l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm2l dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm2l
 
//  *********************************     Metal 2 with W/S=0.1/0.1     ***********************************
subckt rm2s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm2s dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm2s
 
//  *********************************     Metal 2 with W/S=0.3/0.13     ***********************************
subckt rm2w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm2w dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm2w
 
//  *********************************     Metal 3 with W/S=0.1/0.5     ***********************************
subckt rm3l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm3l dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm3l
 
//  *********************************     Metal 3 with W/S=0.1/0.1     ***********************************
subckt rm3s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm3s dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm3s
 
//  *********************************     Metal 3 with W/S=0.3/0.13     ***********************************
subckt rm3w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm3w dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm3w
 
//  *********************************     Metal 4 with W/S=0.1/0.5     ***********************************
subckt rm4l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm4l dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm4l
 
//  *********************************     Metal 4 with W/S=0.1/0.1     ***********************************
subckt rm4s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm4s dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm4s
 
//  *********************************     Metal 4 with W/S=0.3/0.13     ***********************************
subckt rm4w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm4w dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm4w
 
//  *********************************     Metal 5 with W/S=0.1/0.5     ***********************************
subckt rm5l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm5l dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm5l
 
//  *********************************     Metal 5 with W/S=0.1/0.1     ***********************************
subckt rm5s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm5s dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm5s
 
//  *********************************     Metal 5 with W/S=0.3/0.13     ***********************************
subckt rm5w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm5w dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm5w
 
//  *********************************     Metal 6 with W/S=0.1/0.5     ***********************************
subckt rm6l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm6l dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm6l
 
//  *********************************     Metal 6 with W/S=0.1/0.1     ***********************************
subckt rm6s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm6s dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm6s
 
//  *********************************     Metal 6 with W/S=0.3/0.13     ***********************************
subckt rm6w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm6w dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm6w
 
//  *********************************     Metal 7 with W/S=0.1/0.5     ***********************************
subckt rm7l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm7l dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm7l
 
//  *********************************     Metal 7 with W/S=0.1/0.1     ***********************************
subckt rm7s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm7s dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm7s
 
//  *********************************     Metal 7 with W/S=0.3/0.13     ***********************************
subckt rm7w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm7w dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm7w
 
//  *********************************     Metal 8 with W/S=0.4/1.5     ***********************************
subckt rm8l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm8l dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm8l
 
//  *********************************     Metal 8 with W/S=0.4/0.4     ***********************************
subckt rm8s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm8s dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm8s
 
//  *********************************     Metal 8 with W/S=1.5/0.4     ***********************************
subckt rm8w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm8w dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm8w
 
//  *********************************     Metal 9 with W/S=0.4/1.5     ***********************************
subckt rm9l ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm9l dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm9l
 
//  *********************************     Metal 9 with W/S=0.4/0.4     ***********************************
subckt rm9s ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm9s dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm9s
 
//  *********************************     Metal 9 with W/S=1.5/0.4     ***********************************
subckt rm9w ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm9w dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm9w
 
//  *********************************     Metal 10 (AL_RDL) with W/S=3/2     ***********************************
subckt rm10 ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rm10 dw=0 pvc1=0 pvc2=0 ptc1=3.890e-03 ptc2=-1.500e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rm10
 
//  *********************************     Metal x with W/S=0.1/0.5     ***********************************
subckt rmxl ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rmxl dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rmxl
 
//  *********************************     Metal x with W/S=0.1/0.1     ***********************************
subckt rmxs ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rmxs dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rmxs
 
//  *********************************     Metal x with W/S=0.3/0.13     ***********************************
subckt rmxw ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rmxw dw=0 pvc1=0 pvc2=0 ptc1=2.709e-03 ptc2=-3.483e-07 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rmxw
 
//  *********************************     Metal z with W/S=0.4/1.5     ***********************************
subckt rmzl ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rmzl dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rmzl
 
//  *********************************     Metal z with W/S=0.4/0.4     ***********************************
subckt rmzs ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rmzs dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rmzs
 
//  *********************************     Metal z with W/S=1.5/0.4     ***********************************
subckt rmzw ( n1 n2 ) 
parameters l=1u w=1u factor=1 pt=temp rsh=r_rmzw dw=0 pvc1=0 pvc2=0 ptc1=3.625e-03 ptc2=-1.393e-06 
+ tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25.0) 
r1 ( n1 n2 ) bsource r=rsh * l * factor / (w * factor - dw) * (1 + pvc1 * (abs(v(n2,n1)) 
+ / l / factor) + pvc2 * (v(n2,n1) / l / factor) * (v(n2,n1) / l / factor)) * tfac
ends rmzw
endsection res
 
 
//  ************************************************************************
// 
//    RESISTANCE MODEL
// 
//  ************************************************************************

section tt_disres
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_disres
parameters par_res_m=0
parameters r_rnwod_m=316
parameters r_rnwsti_m=605
parameters r_rnodl_m=15.24567155
parameters r_rnods_m=15.24567155
parameters dxw_rnods_m=0
parameters r_rnodwo_m=104.1410518
parameters dxw_rnodwo_m=0
parameters rend_rnodwo_m=5.32e-06
parameters dxl_rnodwo_m=0
parameters r_rpodl_m=14.552007
parameters r_rpods_m=14.552007
parameters dxw_rpods_m=0
parameters r_rpodwo_m=257.3520919
parameters dxw_rpodwo_m=0
parameters rend_rpodwo_m=4.98e-06
parameters dxl_rpodwo_m=0
parameters r_rnpolyl_m=15.39650316
parameters r_rnpolys_m=15.39650316
parameters dxw_rnpolys_m=0
parameters r_rnpolywo_m=124.4470272
parameters dxw_rnpolywo_m=0
parameters rend_rnpolywo_m=4.27e-06
parameters dxl_rnpolywo_m=0
parameters r_rppolyl_m=14.81890631
parameters r_rppolys_m=14.81890631
parameters dxw_rppolys_m=0
parameters r_rppolywo_m=756.206475
parameters dxw_rppolywo_m=0
parameters rend_rppolywo_m=6.34e-07
parameters dxl_rppolywo_m=0
parameters ca_pofox=10.77e-17
parameters cf_polfox=5.51e-17
parameters cf_posfox=4.28e-17
parameters a1_rnpolywo_dis=4.25e-23
parameters a1_rppolywo_dis=-1.75e-23
parameters b1_rnpolywo_dis=4.75e-23
parameters b1_rppolywo_dis=4.25e-23
parameters c1_rnpolywo_dis=7.5e-23
parameters c1_rppolywo_dis=7.5E-23
parameters kf_rnpolywo_dis=a1_rnpolywo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) + b1_rnpolywo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rnpolywo_dis
parameters kf_rppolywo_dis=a1_rppolywo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) + b1_rppolywo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppolywo_dis
include "crn65gplus_2d5_lk_v1d0.scs" section=disres
endsection tt_disres
 

section ss_disres
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_disres
parameters par_res_m=0
parameters r_rnwod_m=316 * 1.20
parameters r_rnwsti_m=605 * 1.20
parameters r_rnodl_m=15.24567155 * 1.30
parameters r_rnods_m=15.24567155 * 1.33
parameters dxw_rnods_m=0 + 0.013u
parameters r_rnodwo_m=104.1410518 * 1.18
parameters dxw_rnodwo_m=0 + 0.030u
parameters rend_rnodwo_m=5.32e-06 * 1.50
parameters dxl_rnodwo_m=0 + 0.0u
parameters r_rpodl_m=14.552007 * 1.30
parameters r_rpods_m=14.552007 * 1.34
parameters dxw_rpods_m=0 + 0.0128u
parameters r_rpodwo_m=257.3520919 * 1.16
parameters dxw_rpodwo_m=0 + 0.061u
parameters rend_rpodwo_m=4.98e-06 * 1.60
parameters dxl_rpodwo_m=0 + 0.0u
parameters r_rnpolyl_m=15.39650316 * 1.30
parameters r_rnpolys_m=15.39650316 * 1.38
parameters dxw_rnpolys_m=0 + 0.0058u
parameters r_rnpolywo_m=124.4470272 * 1.18
parameters dxw_rnpolywo_m=0 + 0.040u
parameters rend_rnpolywo_m=4.27e-06 * 1.50
parameters dxl_rnpolywo_m=0 + 0.0u
parameters r_rppolyl_m=14.81890631 * 1.30
parameters r_rppolys_m=14.81890631 * 1.38
parameters dxw_rppolys_m=0 + 0.006u
parameters r_rppolywo_m=756.206475 * 1.18
parameters dxw_rppolywo_m=0 + 0.043u
parameters rend_rppolywo_m=6.34e-07 * 1.50
parameters dxl_rppolywo_m=0 + 0.0u
parameters ca_pofox=11.84e-17
parameters cf_polfox=5.74e-17
parameters cf_posfox=4.56e-17
parameters a1_rnpolywo_dis=4.25e-23
parameters a1_rppolywo_dis=-1.75e-23
parameters b1_rnpolywo_dis=4.75e-23
parameters b1_rppolywo_dis=4.25e-23
parameters c1_rnpolywo_dis=7.5e-23
parameters c1_rppolywo_dis=7.5E-23
parameters kf_rnpolywo_dis=a1_rnpolywo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) + b1_rnpolywo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rnpolywo_dis
parameters kf_rppolywo_dis=a1_rppolywo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) + b1_rppolywo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppolywo_dis
include "crn65gplus_2d5_lk_v1d0.scs" section=disres
endsection ss_disres
 

section ff_disres
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_disres
parameters par_res_m=0
parameters r_rnwod_m=316 * 0.80
parameters r_rnwsti_m=605 * 0.80
parameters r_rnodl_m=15.24567155 * 0.70
parameters r_rnods_m=15.24567155 * 0.71
parameters dxw_rnods_m=0 - 0.04769u
parameters r_rnodwo_m=104.1410518 * 0.82
parameters dxw_rnodwo_m=0 - 0.054u
parameters rend_rnodwo_m=5.32e-06 * 0.50
parameters dxl_rnodwo_m=0 - 0.0u
parameters r_rpodl_m=14.552007 * 0.70
parameters r_rpods_m=14.552007 * 0.71
parameters dxw_rpods_m=0 - 0.052u
parameters r_rpodwo_m=257.3520919 * 0.85
parameters dxw_rpodwo_m=0 - 0.128u
parameters rend_rpodwo_m=4.98e-06 * 0.20
parameters dxl_rpodwo_m=0 - 0.0u
parameters r_rnpolyl_m=15.39650316 * 0.70
parameters r_rnpolys_m=15.39650316 * 0.64
parameters dxw_rnpolys_m=0 - 0.021u
parameters r_rnpolywo_m=124.4470272 * 0.83
parameters dxw_rnpolywo_m=0 - 0.078u
parameters rend_rnpolywo_m=4.27e-06 * 0.50
parameters dxl_rnpolywo_m=0 - 0.0u
parameters r_rppolyl_m=14.81890631 * 0.70
parameters r_rppolys_m=14.81890631 * 0.63
parameters dxw_rppolys_m=0 - 0.0197u
parameters r_rppolywo_m=756.206475 * 0.83
parameters dxw_rppolywo_m=0 - 0.086u
parameters rend_rppolywo_m=6.34e-07 * 0.50
parameters dxl_rppolywo_m=0 - 0.0u
parameters ca_pofox=9.91e-17
parameters cf_polfox=5.35e-17
parameters cf_posfox=4.09e-17
parameters a1_rnpolywo_dis=4.25e-23
parameters a1_rppolywo_dis=-1.75e-23
parameters b1_rnpolywo_dis=4.75e-23
parameters b1_rppolywo_dis=4.25e-23
parameters c1_rnpolywo_dis=7.5e-23
parameters c1_rppolywo_dis=7.5E-23
parameters kf_rnpolywo_dis=a1_rnpolywo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) + b1_rnpolywo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rnpolywo_dis
parameters kf_rppolywo_dis=a1_rppolywo_dis * (abs(rnoiseflag_disres) + rnoiseflag_disres) + b1_rppolywo_dis * (abs(rnoiseflag_disres) - rnoiseflag_disres) + c1_rppolywo_dis
include "crn65gplus_2d5_lk_v1d0.scs" section=disres
endsection ff_disres
 

section disres
 
//  *********************************     N-Well under OD resistor     ***********************************
subckt rnwod_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 rsh=r_rnwod_m dw=0.21u pvc1=0.005037 pvc2=0.0001668 ptc1=2.93e-03 
+ ptc2=9.99e-06 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
d1 ( body n2 ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d3 ( body nn ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d4 ( body nx ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d5 ( body n1 ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
ends rnwod_m
 
//  *********************************     N-well under STI resistor     ***********************************
subckt rnwsti_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 rsh=r_rnwsti_m dw=0.30u pvc1=0.00629 pvc2=-1.97e-04 ptc1=2.30e-03 
+ ptc2=9.34e-06 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt 
+ - 25.0) 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs(v(n2,n1)) + pvc2 * v(n2,n1) * v(n2,n1)) * tfac
d1 ( body n2 ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
d2 ( body nm ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d3 ( body nn ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d4 ( body nx ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d5 ( body n1 ) nwdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
ends rnwsti_m
 
//  *********************************     N+OD silicide resistor (W>2um)     ***********************************
subckt rnodl_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.01039 * geo_fac * par_res_m * mismatchflag rsh=r_rnodl_m 
+ * (1 + factmis) dw=-0.02258u pvc1=4.20e-08 pvc2=6.36e-13 ptc1=0.002026898 ptc2=-3.42e-06 
+ pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
d1 ( body n2 ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
d2 ( body nm ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d3 ( body nn ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d4 ( body nx ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d5 ( body n1 ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
ends rnodl_m
 
//  *********************************     N+OD silicide resistor (W<2um)     ***********************************
subckt rnods_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.01039 * geo_fac * par_res_m * mismatchflag rsh=r_rnods_m 
+ * (1 + factmis) dw= - 0.02258u + dxw_rnods_m pvc1=2.72e-08 pvc2=5.53e-14 ptc1=0.00230755 
+ ptc2=-4.78e-06 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * 
+ (pt - 25) 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
d1 ( body n2 ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
d2 ( body nm ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d3 ( body nn ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d4 ( body nx ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d5 ( body n1 ) ndio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
ends rnods_m
 
//  *********************************     N+OD w/o silicide resistor     ***********************************
subckt rnodwo_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.002461 * geo_fac * par_res_m * mismatchflag rsh=r_rnodwo_m 
+ * (1 + factmis) rend0=rend_rnodwo_m * (1 + factmis) dw=0.003u + dxw_rnodwo_m dl=0 
+ + dxl_rnodwo_m pvcp1=0.1115 pvcp2=0.0000117 pvcp3=1.583 ptcp1=0.00158 ptcp2=4.18e-07 
+ pvce1=1.13e+00 pvce2=-2.31e+02 pvce3=-1.35e+00 ptce1=0.00251 ptce2=-1.38e-06 pt=temp 
+ tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) tfacp=1.0 
+ + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
d1 ( body ns ) ndio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * ((wr * factor - dw) + 2.0 * (lr * factor - dl) / 5.0)
d2 ( body nm ) ndio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * (2.0 * (lr * factor - dl) / 5.0)
d3 ( body nn ) ndio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * (2.0 * (lr * factor - dl) / 5.0)
d4 ( body nx ) ndio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * (2.0 * (lr * factor - dl) / 5.0)
d5 ( body ne ) ndio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * ((wr * factor - dw) + 2.0 * (lr * factor - dl) / 5.0)
ends rnodwo_m
 
//  *********************************     P+OD silicide resistor (W>2um)     ***********************************
subckt rpodl_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.01449 * geo_fac * par_res_m * mismatchflag rsh=r_rpodl_m 
+ * (1 + factmis) dw=-0.03068u pvc1=-1.23e-09 pvc2=4.05e-13 ptc1=0.002190805 ptc2=-2.37e-06 
+ pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
d1 ( n2 body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
d2 ( nm body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d3 ( nn body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d4 ( nx body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d5 ( n1 body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
ends rpodl_m
 
//  *********************************     P+OD silicide resistor (W<2um)     ***********************************
subckt rpods_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.01449 * geo_fac * par_res_m * mismatchflag rsh=r_rpods_m 
+ * (1 + factmis) dw= - 0.03068u + dxw_rpods_m pvc1=2.39e-08 pvc2=-3.99e-14 ptc1=0.002261914 
+ ptc2=-4.41e-07 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * 
+ (pt - 25) 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
d1 ( n2 body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
d2 ( nm body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d3 ( nn body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d4 ( nx body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * 2.0 
+ * lr * factor / 5.0
d5 ( n1 body ) pdio area=mf * ((wr * factor - dw) * lr * factor / 5.0) pj=mf * ((wr 
+ * factor - dw) + 2.0 * lr * factor / 5.0)
ends rpods_m
 
//  *********************************     P+OD w/o silicide resistor     ***********************************
subckt rpodwo_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.0041 * geo_fac * par_res_m * mismatchflag rsh=r_rpodwo_m 
+ * (1 + factmis) rend0=rend_rpodwo_m * (1 + factmis) dw=0.0001u + dxw_rpodwo_m 
+ dl=0 + dxl_rpodwo_m pvcp1=-0.0137 pvcp2=-0.0000055 pvcp3=0.9113 ptcp1=0.00133 
+ ptcp2=5.71e-07 pvce1=7.68e-02 pvce2=-1.34e+03 pvce3=-4.98e-01 ptce1=0.000354 ptce2=1.59e-06 
+ pt=temp tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) 
+ tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) 
rend1 ( n2 ns ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r2 ( nm nn ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r3 ( nn nx ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
r4 ( nx ne ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3)))
rend2 ( ne n1 ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
d1 ( ns body ) pdio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * ((wr * factor - dw) + 2.0 * (lr * factor - dl) / 5.0)
d2 ( nm body ) pdio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * (2.0 * (lr * factor - dl) / 5.0)
d3 ( nn body ) pdio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * (2.0 * (lr * factor - dl) / 5.0)
d4 ( nx body ) pdio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * (2.0 * (lr * factor - dl) / 5.0)
d5 ( ne body ) pdio area=mf * ((wr * factor - dw) * (lr * factor - dl) / 5.0) pj=mf 
+ * ((wr * factor - dw) + 2.0 * (lr * factor - dl) / 5.0)
ends rpodwo_m
 
//  *********************************     N+POLY silicide resistor (W>2um)     ***********************************
subckt rnpolyl_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.00776 * geo_fac * par_res_m * mismatchflag rsh=r_rnpolyl_m 
+ * (1 + factmis) dw=-0.01204u pvc1=3.39e-09 pvc2=6.01e-14 ptc1=0.002092435 ptc2=-4.21e-06 
+ pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) ca=ca_pofox 
+ cf=cf_polfox 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
c1 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rnpolyl_m
 
//  *********************************     N+POLY silicide resistor (W<2um)     ***********************************
subckt rnpolys_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.00776 * geo_fac * par_res_m * mismatchflag rsh=r_rnpolys_m 
+ * (1 + factmis) dw= - 0.01204u + dxw_rnpolys_m pvc1=4.04e-08 pvc2=5.83e-13 ptc1=0.002431439 
+ ptc2=-6.10e-06 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * 
+ (pt - 25) ca=ca_pofox cf=cf_posfox 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
c1 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rnpolys_m
 
//  *********************************     N+POLY w/o silicide resistor     ***********************************
subckt rnpolywo_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.033 * geo_fac * par_res_m * mismatchflag rsh=r_rnpolywo_m 
+ * (1 + factmis) rend0=rend_rnpolywo_m * (1 + factmis) dw=0.0691u + dxw_rnpolywo_m 
+ dl=0 + dxl_rnpolywo_m pvcp1=-5.89e+00 pvcp2=-6.64e-05 pvcp3=-3.92e+00 ptcp1=0.000175 
+ ptcp2=2.52e-07 pvce1=1.76e+00 pvce2=-4.38e+03 pvce3=-1.44e+00 ptce1=0.00252 ptce2=9.92e-06 
+ pt=temp tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) 
+ tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) ca=ca_pofox 
+ cf=cf_polfox 
rend1 ( n2 ns ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rnpolywo_dis af=2 fexp=0.86 wdexp=1 ldexp=1
r2 ( nm nn ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rnpolywo_dis af=2 fexp=0.86 wdexp=1 ldexp=1
r3 ( nn nx ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rnpolywo_dis af=2 fexp=0.86 wdexp=1 ldexp=1
r4 ( nx ne ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rnpolywo_dis af=2 fexp=0.86 wdexp=1 ldexp=1
rend2 ( ne n1 ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
c1 ( body ns ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body ne ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rnpolywo_m
 
//  *********************************     P+POLY silicide resistor (W>2um)     ***********************************
subckt rppolyl_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.0113 * geo_fac * par_res_m * mismatchflag rsh=r_rppolyl_m 
+ * (1 + factmis) dw=-0.01549u pvc1=3.53e-07 pvc2=7.56e-12 ptc1=0.00230054 ptc2=-3.32e-06 
+ pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * (pt - 25) ca=ca_pofox 
+ cf=cf_polfox 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
c1 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppolyl_m
 
//  *********************************     P+POLY silicide resistor (W<2um)     ***********************************
subckt rppolys_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.0113 * geo_fac * par_res_m * mismatchflag rsh=r_rppolys_m 
+ * (1 + factmis) dw= - 0.01549u + dxw_rppolys_m pvc1=4.28e-08 pvc2=7.04e-13 ptc1=0.002614034 
+ ptc2=-5.37e-06 pt=temp tfac=1.0 + ptc1 * (pt - 25.0) + ptc2 * (pt - 25.0) * 
+ (pt - 25) ca=ca_pofox cf=cf_posfox 
r1 ( n2 nm ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r2 ( nm nn ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r3 ( nn nx ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
r4 ( nx n1 ) bsource r=rsh / mf * lr * factor / (4.0 * (wr * factor - dw)) * (1 + 
+ pvc1 * abs((v(n2,n1) / lr / factor)) + pvc2 * (v(n2,n1) / lr / factor) * (v(n2,n1) 
+ / lr / factor)) * tfac
c1 ( body n2 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body n1 ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppolys_m
 
//  *********************************     P+POLY w/o silicide resistor     ***********************************
subckt rppolywo_m ( n2 n1 body ) 
parameters lr=1u wr=1u factor=1 mf=1 mismatchflag=0 geo_fac=1 / sqrt(mf * lr * factor * wr * 
+ factor * 1e12) factmis=0.007 * geo_fac * par_res_m * mismatchflag rsh=r_rppolywo_m 
+ * (1 + factmis) rend0=rend_rppolywo_m * (1 + factmis) dw=0.0583u + dxw_rppolywo_m 
+ dl=0 + dxl_rppolywo_m pvcp1=0.0588 pvcp2=-0.000005457 pvcp3=2.6393 ptcp1=-3.44e-04 
+ ptcp2=7.32e-07 pvce1=2.1812 pvce2=-369.5605 pvce3=-2.7756 ptce1=-2.83e-03 ptce2=5.84e-06 
+ pt=temp tface=1.0 + ptce1 * (pt - 25.0) + ptce2 * (pt - 25.0) * (pt - 25.0) 
+ tfacp=1.0 + ptcp1 * (pt - 25.0) + ptcp2 * (pt - 25.0) * (pt - 25.0) ca=ca_pofox 
+ cf=cf_polfox 
rend1 ( n2 ns ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(ns,n2)) + pvce3) - tanh(pvce3)))
r1 ( ns nm ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rppolywo_dis af=2 fexp=0.9 wdexp=1 ldexp=1
r2 ( nm nn ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rppolywo_dis af=2 fexp=0.9 wdexp=1 ldexp=1
r3 ( nn nx ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rppolywo_dis af=2 fexp=0.9 wdexp=1 ldexp=1
r4 ( nx ne ) bsource r=rsh / mf * (lr * factor - dl) / (4.0 * (wr * factor - dw)) 
+ * tfacp * (1 + pvcp1 * (tanh(pvcp2 * abs(v(n2,n1) / (lr * factor - dl)) + pvcp3) 
+ - tanh(pvcp3))) kf=kf_rppolywo_dis af=2 fexp=0.9 wdexp=1 ldexp=1
rend2 ( ne n1 ) bsource r=rend0 / mf / wr / factor * tface * (1 + pvce1 * (tanh(pvce2 
+ * abs(v(n1,ne)) + pvce3) - tanh(pvce3)))
c1 ( body ns ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c2 ( body nm ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c3 ( body nn ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c4 ( body nx ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
c5 ( body ne ) capacitor c=mf * (ca * ((wr * factor - 0.02u) * lr * factor / 5.0) 
+ * 1e12 + 2 * cf * lr * factor / 5.0 * 1e6)
ends rppolywo_m
 
endsection disres
 
 
 

section mc_mos_cap
parameters a1_mos_cap=par1 * 2.5913e+000 * 3 / 2.9
parameters a2_mos_cap=par2 * 5.3415e-001 * 3 / 2.9
parameters toxm_var=2.0000e+001 + ( - 3.4724e-001) * a1_mos_cap + ( - 3.5241e-002) 
+ * a2_mos_cap
parameters ndep0_var=3.8000e+000 + (3.2772e-001) * a1_mos_cap + (8.7316e-002) * 
+ a2_mos_cap
parameters pndep_var=3.0000e-014 + (1.1956e-014) * a1_mos_cap + (2.2945e-015) * 
+ a2_mos_cap
parameters fac_var=1.0000e+000 + (4.0302e-001) * a1_mos_cap + (5.2741e-001) * a2_mos_cap
parameters rs0_var=8.0000e+000 + ( - 4.8583e+001) * a1_mos_cap + (1.2210e+002) * 
+ a2_mos_cap
parameters dxl_var=0.0000e+000 + ( - 1.9291e-009) * a1_mos_cap + ( - 1.9579e-010) 
+ * a2_mos_cap
parameters dxw_var=0.0000e+000 + (3.0866e-009) * a1_mos_cap + (3.1326e-010) * a2_mos_cap
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap
endsection mc_mos_cap
 
 
//  *************************     CORNER_LIB OF TYPICAL MODEL     ***************************

section tt_mos_cap
parameters toxm_var=20.0
parameters ndep0_var=3.8
parameters pndep_var=3.0e-14
parameters fac_var=1.0
parameters rs0_var=8.0
parameters dxl_var=0
parameters dxw_var=0
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap
endsection tt_mos_cap
 
//  *************************     CORNER_LIB OF SLOW MODEL     ***************************

section ss_mos_cap
parameters toxm_var=20.9
parameters ndep0_var=3.0
parameters pndep_var=0.0e-14
parameters fac_var=0.4
parameters rs0_var=250
parameters dxl_var=5e-9
parameters dxw_var=-8e-9
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap
endsection ss_mos_cap
 
//  *************************     CORNER_LIB OF FAST MODEL     ***************************

section ff_mos_cap
parameters toxm_var=19.1
parameters ndep0_var=4.7
parameters pndep_var=6.2e-14
parameters fac_var=2.5
parameters rs0_var=1.0
parameters dxl_var=-5e-9
parameters dxw_var=8e-9
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap
endsection ff_mos_cap
 
//  ************************************************************************
//                                                                         *
//               NMOS in N-Well varactor MODEL                             *
//                                                                         *
//  ************************************************************************

section mos_cap
ahdl_include "mosCap_ahdl.va"
subckt nmoscap ( ng nds ) 
parameters factor=1.0 lr=5e-6 wr=5e-6 toxa=toxm_var * 0.88 + 0.5 weff=wr * factor + 0.8e-9 + 
+ dxw_var leff=lr * factor - 6.5e-8 + 1.0e-14 / wr / factor + dxl_var rvalue=rs0_var 
+ * (1.0 - 4.0e-7 / wr / factor - 2.0e-7 / lr / factor) eff=wr * factor * lr * factor 
+ * (1.0 + 1.6e-3 * (temp - 25)) * 9393.931 / toxa / toxa / toxa * 5.6 * fac_var 
+ phit=(temp + 273.0) / 11606.0 as=sqrt(ndep0_var * (1.0 + 3.0e-7 / lr / factor 
+ + 3.0e-7 / wr / factor + pndep_var / wr / factor / lr / factor) * 3.8850499 / (temp 
+ + 273.0)) * toxa / 3.399936 as2=as * as a0=1.0 / (1.0 + 0.707106781186547 * as) 
+ vfb=(0.05 + 5.0e-9 / wr / factor + 4.0e-9 / lr / factor - 1.8e-14 / lr / factor 
+ / wr / factor) * (1.0 + (temp - 25.0) * 7.5e-3) 
cg ( ng n1 ) mosCap toxa=toxa weff=weff leff=leff as=as as2=as2 phit=phit a0=a0 vfb=vfb
gdf1 ( ng n1 ) bsource i =eff * (1.34e4 * (pow(0.5 * (sqrt(v(ng,n1) * v(ng,n1) + 
+ 1.0e-4) + v(ng,n1)),4.0) - pow(5.0e-3,4.0)) - 150 * (pow(0.5 * (sqrt(v(ng,n1) 
+ * v(ng,n1) + 1.0e-4) - v(ng,n1)),1.8) - pow(5.0e-3,1.8)) + 150.0 * v(ng,n1))
rs ( n1 nds ) resistor r=rvalue
ends nmoscap
endsection mos_cap
 

section mc_mos_cap_25
parameters a1_mos_cap_25=par6 * 2.0000e+000 * 3 / 2.9
parameters cgmin_var25=1.0000e+000 + ( - 5.0000e-002) * a1_mos_cap_25
parameters dcg_var25=1.0000e+000 + ( - 2.6800e-002) * a1_mos_cap_25
parameters dxl_var25=0.0000e+000 + (5.0000e-009) * a1_mos_cap_25
parameters dxw_var25=0.0000e+000 + ( - 6.0000e-009) * a1_mos_cap_25
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap_25
endsection mc_mos_cap_25
 
//  *************************     CORNER_LIB OF TYPICAL MODEL     ***************************

section tt_mos_cap_25
parameters cgmin_var25=1
parameters dcg_var25=1
parameters dxl_var25=0
parameters dxw_var25=0
 
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap_25
endsection tt_mos_cap_25
 
//  *************************     CORNER_LIB OF SLOW MODEL     ***************************

section ss_mos_cap_25
parameters cgmin_var25=0.9
parameters dcg_var25=0.9464
parameters dxl_var25=1e-8
parameters dxw_var25=-1.2e-08
 
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap_25
endsection ss_mos_cap_25
 
//  *************************     CORNER_LIB OF FAST MODEL     ***************************

section ff_mos_cap_25
parameters cgmin_var25=1.1
parameters dcg_var25=1.0536
parameters dxl_var25=-1e-8
parameters dxw_var25=1.2e-08
 
include "crn65gplus_2d5_lk_v1d0.scs" section=mos_cap_25
endsection ff_mos_cap_25
 
//  ************************************************************************
//                                                                         *
//               2.5V IO NMOS in N-Well varactor MODEL                     *
//                                                                         *
//  ************************************************************************

section mos_cap_25
// 
subckt nmoscap_25 ( ng nds ) 
parameters factor=1.0 lr=1e-6 wr=1e-6 xl=1.5e-08 xw=-7.0e-09 area=(lr * factor - xl + dxl_var25) 
+ * (wr * factor - xw + dxw_var25) cgmin=1.420e-10 * cgmin_var25 * 2 * (wr * factor 
+ - xw + dxw_var25) + 3.964e-10 * cgmin_var25 * 2 * (lr * factor - xl + dxl_var25) 
+ + 8.80e-04 * cgmin_var25 * area dcg= - 9e-11 * dcg_var25 * 2 * (wr * factor - xw 
+ + dxw_var25) + 2e-12 * dcg_var25 * 2 * (lr * factor - xl + dxl_var25) + 2.4e-03 
+ * dcg_var25 * area dvgs= - 0.22 - 1.1e-03 * (temp - 25) vgnorm=0.7 + 1.0e-03 
+ * (temp - 25) 
 
cg ( ng nds ) bsource q=(cgmin+dcg)*v(ng,nds)+vgnorm*dcg*ln(cosh((v(ng,nds)-dvgs)/vgnorm))
 
ends nmoscap_25
 
endsection mos_cap_25
 
 
 
//  *********** Library of MC corner ************************************

section mc_rtmom
parameters a1_mom=par1_mom * 1.0000e+000 / 3
parameters rtmom_fac=1.0000e+000 + (1.5000e-001) * a1_mom
parameters par_mom=0
include "crn65gplus_2d5_lk_v1d0.scs" section=rtmom
endsection mc_rtmom



//  *********************************************************************
//              	              RTMOM                                   *
//  *********************************************************************
//  *********** Library of typical corner *******************************

section tt_rtmom
parameters rtmom_fac=1
parameters par_mom=0
include "crn65gplus_2d5_lk_v1d0.scs" section=rtmom
endsection tt_rtmom


//  *********** Library of slow corner **********************************

section ss_rtmom
parameters rtmom_fac=1.15
parameters par_mom=0
include "crn65gplus_2d5_lk_v1d0.scs" section=rtmom
endsection ss_rtmom


//  *********** Library of fast corner **********************************

section ff_rtmom
parameters rtmom_fac=0.85
parameters par_mom=0
include "crn65gplus_2d5_lk_v1d0.scs" section=rtmom
endsection ff_rtmom


// 
//  **********************************************************************

section rtmom
//*********************************************************************************************************************
//*                                                                                                                   *
//*           N65 BB RTMOM                                                                                            *
//*                                                                                                                   *
//*           parameter range: nv : 6~288, nh : 6~288                                                                 *
//*                            nv and nh should be even fingers                                                       *
//*                            w(width):0.1u ~0.16u                                                                   *
//*                            s(spacing):0.1u ~0.16u                                                                 *
//*                            stm(start metal layer):M1,M2,M3,M4,M5 (M2,M3,M4,M5 are inter metals (Mx thk=0.22um))   *
//*                            spm(stop metal layer):M3,M4,M5,M6,M7 (M3,M4,M5,M6,M7 are inter metals (Mx thk=0.22um)) *
//*                            Total metal is at least 3 layers stacked with ploy shield                              *
//*                            mismatchflag=0 for no mismatch                                                         *
//*                            mismatchflag=1 for parallel                                                            *
//*********************************************************************************************************************
subckt crtmom ( a b p ) 
parameters nv=32 nh=32 w=0.14u s=0.14u stm=1 spm=7 mf=1 mismatchflag=0 layno=spm 
+ - stm + 1 laym1=int(layno / spm) layodd=int((layno + (stm - 2) * (stm - 3) * (stm 
+ - 4) * (stm - 5) / (24) + (stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) / (4) 
+ + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 4) / 24) / 2) - laym1 layeven=int((layno 
+ + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) / ( - 6) + (stm - 1) * (stm - 
+ 2) * (stm - 3) * (stm - 5) / ( - 6)) / 2) edg=((layodd + 1800 / 2200 * laym1) 
+ * (nv - 1) * (nh * (w + s) - s) + layeven * (nh - 1) * (nv * (w + s) - s)) area=nv 
+ * nh / 2 * w * (layno - 1) fri1=(2 * nh * nv * w) * (layno - 1) fri2=((layodd 
+ + 1800 / 2200 * laym1) * nv * w + layeven * nh * w) + layeven * (nv * (w + s) 
+ - s + 0.2u) * 2 + layno * 0.11u * 2 + (layodd + 1800 / 2200 * laym1) * (nh * (w 
+ + s) - s) * 2 abm=((nv * (w + s) - s + (0.11u + 0.2u) * 2) + (nh * (w + s) - s 
+ + 0.2u)) * 0.11u afm=(nv * w * (nh * (w + s) - s + 0.2u)) / 2 pf=(nh * (w + s) 
+ - s + 0.2u) * (nv) * 2 / 2 + 2 * ((nv * (w + s) - s + (0.2u + 0.11u) * 2) + (nh 
+ * (w + s) - s + 0.2u + 0.11u)) pfb=((nh * (w + s) - s) + 0.2u + 0.11u) * 3.6 cc1=1.14 
+ * ( - 0.244660016615909 * (s * 1e6) - 0.0710279441604613 * (w * 1e6) - 0.488519079260245 
+ * (s * 1e6) * (w * 1e6) + 0.110902118000523) cc2=1.14 * 0.0434096210759646 cf=(0.0123567105762849 
+ * (s * 1e6) - 0.00266215734172082 * (w * 1e6) + 0.215236738982277 * (s * 1e6) 
+ * (w * 1e6) + 0.00623893734392313) ca=(0.164257743030535 * (s * 1e6) + 0.210106799625508 
+ * (w * 1e6) - 0.838732645422224 * (s * 1e6) * (w * 1e6) - 0.0143235048162527) 
+ ca_p_a=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.184399492837775) + (stm - 1) * (stm - 3) * (stm - 4) * (stm 
+ - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.0562169811320459) + (stm - 1) 
+ * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * 
+ (0.0303182627269607) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) 
+ / (4 - 2) / (4 - 3) / (4 - 5) * (0.0204185653257779) + (stm - 1) * (stm - 2) 
+ * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.0155405838248919)) 
+ ca_p_b=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.272366297594863) + (stm - 1) * (stm - 3) * (stm - 4) * (stm 
+ - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.0717877358490275) + (stm - 
+ 1) * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) 
+ * (0.0386390174439423) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 
+ 1) / (4 - 2) / (4 - 3) / (4 - 5) * (0.026074225703015) + (stm - 1) * (stm - 2) 
+ * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.0198943574067541)) 
+ ca_p_c=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * ( - 1.01476676416181) + (stm - 1) * (stm - 3) * (stm - 4) * 
+ (stm - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * ( - 0.287264150943196) + 
+ (stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / 
+ (3 - 5) * ( - 0.15489498042016) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 
+ 5) / (4 - 1) / (4 - 2) / (4 - 3) / (4 - 5) * ( - 0.104334282661256) + (stm - 
+ 1) * (stm - 2) * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) 
+ * ( - 0.0793787823805835)) ca_p_d=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 
+ 5) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) * ( - 0.0154122508267569) + (stm - 
+ 1) * (stm - 3) * (stm - 4) * (stm - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) 
+ * ( - 0.00492283018867496) + (stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) / 
+ (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * ( - 0.00265463866144706) + (stm - 1) 
+ * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) / (4 - 2) / (4 - 3) / (4 - 5) * 
+ ( - 0.00178095140622209) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 4) / (5 
+ - 1) / (5 - 2) / (5 - 3) / (5 - 4) * ( - 0.00136225257923501)) cf_p_a=((stm - 
+ 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) 
+ * (0.0197079634015853) + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) / (2 - 
+ 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.00024528301895136) + (stm - 1) * (stm - 
+ 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * ( - 0.000029725860215765) 
+ + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) / (4 - 2) / (4 - 3) 
+ / (4 - 5) * (0.000307493769546562) + (stm - 1) * (stm - 2) * (stm - 3) * (stm 
+ - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.000347276542606783)) cf_p_b=((stm 
+ - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 
+ 5) * ( - 0.0129061444823706) + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) 
+ / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * ( - 0.00660377358476723) + (stm - 1) 
+ * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * 
+ ( - 0.00402500889011157) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 
+ - 1) / (4 - 2) / (4 - 3) / (4 - 5) * ( - 0.00245194019285392) + (stm - 1) * (stm 
+ - 2) * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * ( - 0.00172347820089183)) 
+ cf_p_c=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.30428922059544) + (stm - 1) * (stm - 3) * (stm - 4) * (stm 
+ - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.120754716980374) + (stm - 1) 
+ * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * 
+ (0.0691705231980648) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) 
+ / (4 - 2) / (4 - 3) / (4 - 5) * (0.0466269134961872) + (stm - 1) * (stm - 2) 
+ * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.0359914566866994)) 
+ cf_p_d=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.00718769653087997) + (stm - 1) * (stm - 3) * (stm - 4) * 
+ (stm - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.00355061320753045) + (stm 
+ - 1) * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 
+ 5) * (0.00233987628858116) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / 
+ (4 - 1) / (4 - 2) / (4 - 3) / (4 - 5) * (0.00170373887511912) + (stm - 1) * (stm 
+ - 2) * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.00135907886267202)) 
+ ca_p=1.1 * (ca_p_a * (s * 1e6) + ca_p_b * (w * 1e6) + ca_p_c * (s * 1e6) * (w 
+ * 1e6) + ca_p_d) cf_p=1.1 * (cf_p_a * (s * 1e6) + cf_p_b * (w * 1e6) + cf_p_c 
+ * (s * 1e6) * (w * 1e6) + cf_p_d) cc_p= - 0.03872 * (w * 1e6) + 0.012204 mis_a=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (0.32) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (0.28) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (0.165)) mis_b=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (0.027) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (0.0125) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (0.0068)) mis_c=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (2.4) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (3.3) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (3.5)) mis_d=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (0.084) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (0.043) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (0.024)) geo_fac=1 
+ / sqrt((cc1 * edg * 1e-9 + cf * 1e-9 * fri1 + ca * 1e-9 * area + cc2 * 1e-9 * 
+ fri2) * 1e15 * mf) mis=mis_a * (((geo_fac - mis_b) ** 2 + 0.000000000000000001) 
+ ** 0.5 + geo_fac) + mis_c * (((geo_fac - mis_b) ** 2 + 0.000000000000000001) 
+ ** 0.5 - geo_fac) + mis_d factmis=mis / 1.414 / 100 * par_mom 
// 
// 
cab ( a b ) bsource q=(1+factmis)*(cc1 * edg * 1e-9 + cf * 1e-9 * fri1 + ca 
+ * 1e-9 * area + cc2 * 1e-9 * fri2) *  (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(a,b) - 4.92 * 1e-6 /2 * v(a,b)**2 + 1.21 * 1e-6 /3 * v(a,b)**3) *mf* rtmom_fac
cpa ( a p ) bsource q=(ca_p * (abm + afm) / (w * 1e6) * 1e-3 + cf_p 
+ * pf * 1e-9 + cc_p * pfb * 1e-9) * (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(a,p) - 4.92 * 1e-6 /2 * v(a,p)**2 + 1.21 * 1e-6 /3 * v(a,p)**3) *mf* rtmom_fac
cpb ( b p ) bsource q=(ca_p * (abm + afm) / (w * 1e6) * 1e-3 + cf_p 
+ * pf * 1e-9 + cc_p * pfb * 1e-9) * (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(b,p) - 4.92 * 1e-6 /2 * v(b,p)**2 + 1.21 * 1e-6 /3 * v(b,p)**3) *mf* rtmom_fac
 
ends crtmom
 
//*********************************************************************************************************************
//*                                                                                                                   *
//*           N65 BB 5T RTMOM FOR MULTI-X-COUPLE MISMATCH APPLICATION                                                                                        *
//*                                                                                                                   *
//*           parameter range: nv : 6~288, nh : 6~288                                                                 *
//*                            nv and nh should be even fingers                                                       *
//*                            w(width):0.1u ~0.16u                                                                   *
//*                            s(spacing):0.1u ~0.16u                                                                 *
//*                            stm(start metal layer):M1,M2,M3,M4,M5 (M2,M3,M4,M5 are inter metals (Mx thk=0.22um))   *
//*                            spm(stop metal layer):M3,M4,M5,M6,M7 (M3,M4,M5,M6,M7 are inter metals (Mx thk=0.22um)) *
//*                            Total metal is at least 3 layers stacked with ploy shield                              *
//*                            mismatchflag=0 for no mismatch                                                         *
//*                            mismatchflag=1 for multi-x-couple                                                      *
//*********************************************************************************************************************
subckt crtmom_mx ( a b a1 b1 p ) 
parameters nv=32 nh=32 w=0.14u s=0.14u stm=1 spm=7 mf=1 mismatchflag=0 layno=spm 
+ - stm + 1 laym1=int(layno / spm) layodd=int((layno + (stm - 2) * (stm - 3) * (stm 
+ - 4) * (stm - 5) / (24) + (stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) / (4) 
+ + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 4) / 24) / 2) - laym1 layeven=int((layno 
+ + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) / ( - 6) + (stm - 1) * (stm - 
+ 2) * (stm - 3) * (stm - 5) / ( - 6)) / 2) edg=((layodd + 1800 / 2200 * laym1) 
+ * (nv - 1) * (nh * (w + s) - s) + layeven * (nh - 1) * (nv * (w + s) - s)) area=nv 
+ * nh / 2 * w * (layno - 1) fri1=(2 * nh * nv * w) * (layno - 1) fri2=((layodd 
+ + 1800 / 2200 * laym1) * nv * w + layeven * nh * w) + layeven * (nv * (w + s) 
+ - s + 0.2u) * 2 + layno * 0.11u * 2 + (layodd + 1800 / 2200 * laym1) * (nh * (w 
+ + s) - s) * 2 abm=((nv * (w + s) - s + (0.11u + 0.2u) * 2) + (nh * (w + s) - s 
+ + 0.2u)) * 0.11u afm=(nv * w * (nh * (w + s) - s + 0.2u)) / 2 pf=(nh * (w + s) 
+ - s + 0.2u) * (nv) * 2 / 2 + 2 * ((nv * (w + s) - s + (0.2u + 0.11u) * 2) + (nh 
+ * (w + s) - s + 0.2u + 0.11u)) pfb=((nh * (w + s) - s) + 0.2u + 0.11u) * 3.6 cc1=1.14 
+ * ( - 0.244660016615909 * (s * 1e6) - 0.0710279441604613 * (w * 1e6) - 0.488519079260245 
+ * (s * 1e6) * (w * 1e6) + 0.110902118000523) cc2=1.14 * 0.0434096210759646 cf=(0.0123567105762849 
+ * (s * 1e6) - 0.00266215734172082 * (w * 1e6) + 0.215236738982277 * (s * 1e6) 
+ * (w * 1e6) + 0.00623893734392313) ca=(0.164257743030535 * (s * 1e6) + 0.210106799625508 
+ * (w * 1e6) - 0.838732645422224 * (s * 1e6) * (w * 1e6) - 0.0143235048162527) 
+ ca_p_a=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.184399492837775) + (stm - 1) * (stm - 3) * (stm - 4) * (stm 
+ - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.0562169811320459) + (stm - 1) 
+ * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * 
+ (0.0303182627269607) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) 
+ / (4 - 2) / (4 - 3) / (4 - 5) * (0.0204185653257779) + (stm - 1) * (stm - 2) 
+ * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.0155405838248919)) 
+ ca_p_b=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.272366297594863) + (stm - 1) * (stm - 3) * (stm - 4) * (stm 
+ - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.0717877358490275) + (stm - 
+ 1) * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) 
+ * (0.0386390174439423) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 
+ 1) / (4 - 2) / (4 - 3) / (4 - 5) * (0.026074225703015) + (stm - 1) * (stm - 2) 
+ * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.0198943574067541)) 
+ ca_p_c=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * ( - 1.01476676416181) + (stm - 1) * (stm - 3) * (stm - 4) * 
+ (stm - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * ( - 0.287264150943196) + 
+ (stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / 
+ (3 - 5) * ( - 0.15489498042016) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 
+ 5) / (4 - 1) / (4 - 2) / (4 - 3) / (4 - 5) * ( - 0.104334282661256) + (stm - 
+ 1) * (stm - 2) * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) 
+ * ( - 0.0793787823805835)) ca_p_d=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 
+ 5) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) * ( - 0.0154122508267569) + (stm - 
+ 1) * (stm - 3) * (stm - 4) * (stm - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) 
+ * ( - 0.00492283018867496) + (stm - 1) * (stm - 2) * (stm - 4) * (stm - 5) / 
+ (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * ( - 0.00265463866144706) + (stm - 1) 
+ * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) / (4 - 2) / (4 - 3) / (4 - 5) * 
+ ( - 0.00178095140622209) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 4) / (5 
+ - 1) / (5 - 2) / (5 - 3) / (5 - 4) * ( - 0.00136225257923501)) cf_p_a=((stm - 
+ 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 5) 
+ * (0.0197079634015853) + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) / (2 - 
+ 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.00024528301895136) + (stm - 1) * (stm - 
+ 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * ( - 0.000029725860215765) 
+ + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) / (4 - 2) / (4 - 3) 
+ / (4 - 5) * (0.000307493769546562) + (stm - 1) * (stm - 2) * (stm - 3) * (stm 
+ - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.000347276542606783)) cf_p_b=((stm 
+ - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 - 4) / (1 - 
+ 5) * ( - 0.0129061444823706) + (stm - 1) * (stm - 3) * (stm - 4) * (stm - 5) 
+ / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * ( - 0.00660377358476723) + (stm - 1) 
+ * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * 
+ ( - 0.00402500889011157) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 
+ - 1) / (4 - 2) / (4 - 3) / (4 - 5) * ( - 0.00245194019285392) + (stm - 1) * (stm 
+ - 2) * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * ( - 0.00172347820089183)) 
+ cf_p_c=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.30428922059544) + (stm - 1) * (stm - 3) * (stm - 4) * (stm 
+ - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.120754716980374) + (stm - 1) 
+ * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 5) * 
+ (0.0691705231980648) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / (4 - 1) 
+ / (4 - 2) / (4 - 3) / (4 - 5) * (0.0466269134961872) + (stm - 1) * (stm - 2) 
+ * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.0359914566866994)) 
+ cf_p_d=((stm - 2) * (stm - 3) * (stm - 4) * (stm - 5) / (1 - 2) / (1 - 3) / (1 
+ - 4) / (1 - 5) * (0.00718769653087997) + (stm - 1) * (stm - 3) * (stm - 4) * 
+ (stm - 5) / (2 - 1) / (2 - 3) / (2 - 4) / (2 - 5) * (0.00355061320753045) + (stm 
+ - 1) * (stm - 2) * (stm - 4) * (stm - 5) / (3 - 1) / (3 - 2) / (3 - 4) / (3 - 
+ 5) * (0.00233987628858116) + (stm - 1) * (stm - 2) * (stm - 3) * (stm - 5) / 
+ (4 - 1) / (4 - 2) / (4 - 3) / (4 - 5) * (0.00170373887511912) + (stm - 1) * (stm 
+ - 2) * (stm - 3) * (stm - 4) / (5 - 1) / (5 - 2) / (5 - 3) / (5 - 4) * (0.00135907886267202)) 
+ ca_p=1.1 * (ca_p_a * (s * 1e6) + ca_p_b * (w * 1e6) + ca_p_c * (s * 1e6) * (w 
+ * 1e6) + ca_p_d) cf_p=1.1 * (cf_p_a * (s * 1e6) + cf_p_b * (w * 1e6) + cf_p_c 
+ * (s * 1e6) * (w * 1e6) + cf_p_d) cc_p= - 0.03872 * (w * 1e6) + 0.012204 mis_a=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (0.165)) mis_b=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (0.0068)) mis_c=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (3.5)) mis_d=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) 
+ * (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) 
+ / (1 - 2) / (1 - 3) * (0.024)) geo_fac=1 
+ / sqrt((cc1 * edg * 1e-9 + cf * 1e-9 * fri1 + ca * 1e-9 * area + cc2 * 1e-9 * 
+ fri2) * 1e15 * mf) mis=mis_a * (((geo_fac - mis_b) ** 2 + 0.000000000000000001) 
+ ** 0.5 + geo_fac) + mis_c * (((geo_fac - mis_b) ** 2 + 0.000000000000000001) 
+ ** 0.5 - geo_fac) + mis_d factmis=mis / 1.414 / 100 * par_mom 
// 
// 
cab ( a b ) bsource q=(1+factmis)*(cc1 * edg * 1e-9 + cf * 1e-9 * fri1 + ca 
+ * 1e-9 * area + cc2 * 1e-9 * fri2) *  (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(a,b) - 4.92 * 1e-6 /2 * v(a,b)**2 + 1.21 * 1e-6 /3 * v(a,b)**3) *mf* rtmom_fac
cpa ( a p ) bsource q=(ca_p * (abm + afm) / (w * 1e6) * 1e-3 + cf_p 
+ * pf * 1e-9 + cc_p * pfb * 1e-9) * (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(a,p) - 4.92 * 1e-6 /2 * v(a,p)**2 + 1.21 * 1e-6 /3 * v(a,p)**3) *mf* rtmom_fac
cpb ( b p ) bsource q=(ca_p * (abm + afm) / (w * 1e6) * 1e-3 + cf_p 
+ * pf * 1e-9 + cc_p * pfb * 1e-9) * (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(b,p) - 4.92 * 1e-6 /2 * v(b,p)**2 + 1.21 * 1e-6 /3 * v(b,p)**3) *mf* rtmom_fac
ca1b1 ( a1 b1 ) bsource q=(1+factmis)*(cc1 * edg * 1e-9 + cf * 1e-9 * fri1 + ca 
+ * 1e-9 * area + cc2 * 1e-9 * fri2) *  (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(a1,b1) - 4.92 * 1e-6 /2 * v(a1,b1)**2 + 1.21 * 1e-6 /3 * v(a1,b1)**3) *mf* rtmom_fac
cpa1 ( a1 p ) bsource q=(ca_p * (abm + afm) / (w * 1e6) * 1e-3 + cf_p 
+ * pf * 1e-9 + cc_p * pfb * 1e-9) * (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(a1,p) - 4.92 * 1e-6 /2 * v(a1,p)**2 + 1.21 * 1e-6 /3 * v(a1,p)**3) *mf* rtmom_fac
cpb1 ( b1 p ) bsource q=(ca_p * (abm + afm) / (w * 1e6) * 1e-3 + cf_p 
+ * pf * 1e-9 + cc_p * pfb * 1e-9) * (1 + (temp - 25) * ( - 9 * 1e-6) 
+ + (temp - 25) * (temp - 25) * (3e-8)) * (v(b1,p) - 4.92 * 1e-6 /2 * v(b1,p)**2 + 1.21 * 1e-6 /3 * v(b1,p)**3) *mf* rtmom_fac

ends crtmom_mx
 
endsection rtmom
 
section mc_mim
parameters par_mim=0
parameters a1_mim=par1_mim * 1.0000e+000
parameters cmimbb_mimfac=1.0000e+000 + (1.0000e-001) * a1_mim
parameters cmimbb2p0_mimfac=1.0000e+000 + (1.5000e-001) * a1_mim
parameters cm5bb_mimfac=1.0
include "crn65gplus_2d5_lk_v1d0.scs" section=mim
endsection mc_mim


 
 
 
 


 

 
//  ******************************************************
//  ************** MIM Corner Parameters *****************
//  ******************************************************

section tt_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.0
parameters cmimbb2p0_mimfac=1.0
parameters cm5bb_mimfac=1.0
include "crn65gplus_2d5_lk_v1d0.scs" section=mim
endsection tt_mim


 

section ff_mim
parameters par_mim=0
parameters cmimbb_mimfac=0.9
parameters cmimbb2p0_mimfac=0.85
parameters cm5bb_mimfac=0.931
include "crn65gplus_2d5_lk_v1d0.scs" section=mim
endsection ff_mim


 

section ss_mim
parameters par_mim=0
parameters cmimbb_mimfac=1.1
parameters cmimbb2p0_mimfac=1.15
parameters cm5bb_mimfac=1.074
include "crn65gplus_2d5_lk_v1d0.scs" section=mim
endsection ss_mim


//*************************************************************************************************
//     MIM CAPACITOR MODEL :
//
//
//     ## library files:
//
//     1. The 2T base band MIM capacitors with sub-circuit 'mimcap_sin'
//        a. mimflag=1 for 2T base band 1.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=1 for mismatch
//        b. mimflag=2 for 2T base band 1.5fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=2 for mismatch
//        c. mimflag=3 for 2T base band 2.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=3 for mismatch
//     2. The 3T base band MIM capacitors with sub-circuit 'mimcap_sin_3t'
//        a. mimflag=1 for 3T base band 1.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=1 for mismatch
//        b. mimflag=2 for 3T base band 1.5fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=2 for mismatch
//        c. mimflag=3 for 3T base band 2.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=3 for mismatch
//     3. The 2T base band UTM direct contact MIM capacitors with sub-circuit 'mimcap_sin_udc'
//        a. mimflag=1 for 2T base band 1.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=1 for mismatch
//        b. mimflag=2 for 2T base band 1.5fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=2 for mismatch
//        c. mimflag=3 for 2T base band 2.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=3 for mismatch
//     4. The 3T base band UTM direct contact MIM capacitors with sub-circuit 'mimcap_sin_udc_3t'
//        a. mimflag=1 for 3T base band 1.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=1 for mismatch
//        b. mimflag=2 for 3T base band 1.5fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=2 for mismatch
//        c. mimflag=3 for 3T base band 2.0fF MIM capacitors ,and mismatchflag==0 for no mismatch mismatchflag=3 for mismatch
//
//       
//
//     Model name              lt             wt
//                             low    high    low    high
//     --------------------------------------------------
//     mimcap_sin            (um)   2     100      2     100
//     mimcap_sin_3t         (um)   2     100      2     100
//     mimcap_sin_udc        (um)   2     100      2     100
//     mimcap_sin_udc_3t     (um)   2     100      2     100
//     --------------------------------------------------
//            **lt: length dimension of top metal (CTM) 
//            **wt: width dimension of top metal (CTM) 
//            **lay: the number of metal layer under MIM, ex. for MIM is between M7 and M8, lay=7
//            **MIM is between Mz and Mx      
//*************************************************************************************************

section mim
// 
subckt mimcap_sin ( top bottom ) 
parameters lt=10u wt=10u mf=1 mismatchflag=0 mimflag=1 mis=((mismatchflag - 1) * 
+ (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) * (0) + 
+ (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) / (1 - 
+ 2) / (1 - 3) * (0.007083) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (0.006203) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (0.006082)) geo_fac=1 
+ / sqrt(mf * lt * wt * 1e12) factmis=mis * geo_fac * par_mim mim_a=((mimflag - 
+ 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.029u) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.049u) + (mimflag - 1) * (mimflag - 2) / (3 - 
+ 1) / (3 - 2) * ( - 0.037u)) mim_b=((mimflag - 2) * (mimflag - 3) / (1 - 2) / 
+ (1 - 3) * (1.03) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (1.485) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * (2.014)) mim_c=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * (0.207) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * (0.21) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / 
+ (3 - 2) * (0.218)) tcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * 
+ ( - 5.11e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * ( - 5.365e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 1.573e-5)) tcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.03e-6) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.052e-6) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 0.018e-6)) vcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) 
+ / (1 - 3) * (3.66e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (4.335e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 2.9e-5)) vcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 1.84e-5) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 4.23e-5) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 2.97e-5)) cmimbb_corner=((mimflag - 2) * (mimflag - 3) / 
+ (1 - 2) / (1 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 3) / (2 - 1) 
+ / (2 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 
+ 2) * (cmimbb2p0_mimfac)) cmim_para=(1 + factmis) * (((wt + mim_a) * (lt + mim_a) 
+ * 1e12 * mim_b) + 2 * ((wt + mim_a) + (lt + mim_a)) * 1e6 * mim_c) * 1e-15 * 
+ (1 + (temp - 25) * tcc1 + (temp - 25) * (temp - 25) * tcc2) 
// 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*vcc1+1/3*v(top,bottom)**3*vcc2)*cmimbb_corner*mf
// 
ends mimcap_sin
// 
subckt mimcap_sin_udc ( top bottom ) 
parameters lt=10u wt=10u mf=1 mismatchflag=0 mimflag=1 mis=((mismatchflag - 1) * 
+ (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) * (0) + 
+ (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) / (1 - 
+ 2) / (1 - 3) * (0.007083) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (0.006203) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (0.006082)) geo_fac=1 
+ / sqrt(mf * lt * wt * 1e12) factmis=mis * geo_fac * par_mim mim_a=((mimflag - 
+ 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.029u) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.049u) + (mimflag - 1) * (mimflag - 2) / (3 - 
+ 1) / (3 - 2) * ( - 0.037u)) mim_b=((mimflag - 2) * (mimflag - 3) / (1 - 2) / 
+ (1 - 3) * (1.03) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (1.485) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * (2.014)) mim_c=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * (0.207) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * (0.21) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / 
+ (3 - 2) * (0.218)) tcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * 
+ ( - 5.11e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * ( - 5.365e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 1.573e-5)) tcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.03e-6) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.052e-6) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 0.018e-6)) vcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) 
+ / (1 - 3) * (3.66e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (4.335e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 2.9e-5)) vcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 1.84e-5) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 4.23e-5) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 2.97e-5)) cmimbb_corner=((mimflag - 2) * (mimflag - 3) / 
+ (1 - 2) / (1 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 3) / (2 - 1) 
+ / (2 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 
+ 2) * (cmimbb2p0_mimfac)) cmim_para=(1 + factmis) * (((wt + mim_a) * (lt + mim_a) 
+ * 1e12 * mim_b) + 2 * ((wt + mim_a) + (lt + mim_a)) * 1e6 * mim_c) * 1e-15 * 
+ (1 + (temp - 25) * tcc1 + (temp - 25) * (temp - 25) * tcc2) 
//
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*vcc1+1/3*v(top,bottom)**3*vcc2)*cmimbb_corner*mf
//
ends mimcap_sin_udc
//
// 
// 
subckt mimcap_sin_3t ( top bottom gnode ) 
parameters lt=10u wt=10u mf=1 mismatchflag=0 lay=9 mimflag=1 mis=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) * 
+ (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) / 
+ (1 - 2) / (1 - 3) * (0.007083) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (0.006203) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (0.006082)) geo_fac=1 
+ / sqrt(mf * lt * wt * 1e12) factmis=mis * geo_fac * par_mim mim_a=((mimflag - 
+ 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.029u) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.049u) + (mimflag - 1) * (mimflag - 2) / (3 - 
+ 1) / (3 - 2) * ( - 0.037u)) mim_b=((mimflag - 2) * (mimflag - 3) / (1 - 2) / 
+ (1 - 3) * (1.03) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (1.485) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * (2.014)) mim_c=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * (0.207) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * (0.21) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / 
+ (3 - 2) * (0.218)) tcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * 
+ ( - 5.11e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * ( - 5.365e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 1.573e-5)) tcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.03e-6) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.052e-6) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 0.018e-6)) vcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) 
+ / (1 - 3) * (3.66e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (4.335e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 2.9e-5)) vcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 1.84e-5) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 4.23e-5) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 2.97e-5)) cmimbb_corner=((mimflag - 2) * (mimflag - 3) / 
+ (1 - 2) / (1 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 3) / (2 - 1) 
+ / (2 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 
+ 2) * (cmimbb2p0_mimfac)) cmim_para=(1 + factmis) * (((wt + mim_a) * (lt + mim_a) 
+ * 1e12 * mim_b) + 2 * ((wt + mim_a) + (lt + mim_a)) * 1e6 * mim_c) * 1e-15 * 
+ (1 + (temp - 25) * tcc1 + (temp - 25) * (temp - 25) * tcc2) cox_para=((lt 
+ * 1e6 + 0.8) * (wt * 1e6 + 0.8) * 0.0105357 + 2 * ((lt * 1e6 + 0.8) + (wt * 1e6 
+ + 0.8)) * 0.0149) * 1e-15 
// 
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*vcc1+1/3*v(top,bottom)**3*vcc2)*cmimbb_corner*mf
cox ( bottom gnode ) capacitor c=cox_para * ((1 / (4.35717 + (1.42106) * (lay - 
+ 2))) / 0.0872414) * cm5bb_mimfac * mf
// 
ends mimcap_sin_3t
// 
subckt mimcap_sin_udc_3t ( top bottom gnode ) 
parameters lt=10u wt=10u mf=1 mismatchflag=0 lay=9 mimflag=1 mis=((mismatchflag 
+ - 1) * (mismatchflag - 2) * (mismatchflag - 3) / (0 - 1) / (0 - 2) / (0 - 3) * 
+ (0) + (mismatchflag - 0) * (mismatchflag - 2) * (mismatchflag - 3) / (1 - 0) / 
+ (1 - 2) / (1 - 3) * (0.007083) + (mismatchflag - 0) * (mismatchflag - 1) * (mismatchflag 
+ - 3) / (2 - 0) / (2 - 1) / (2 - 3) * (0.006203) + (mismatchflag - 0) * (mismatchflag 
+ - 1) * (mismatchflag - 2) / (3 - 0) / (3 - 1) / (3 - 2) * (0.006082)) geo_fac=1 
+ / sqrt(mf * lt * wt * 1e12) factmis=mis * geo_fac * par_mim mim_a=((mimflag - 
+ 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.029u) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.049u) + (mimflag - 1) * (mimflag - 2) / (3 - 
+ 1) / (3 - 2) * ( - 0.037u)) mim_b=((mimflag - 2) * (mimflag - 3) / (1 - 2) / 
+ (1 - 3) * (1.03) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (1.485) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * (2.014)) mim_c=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * (0.207) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * (0.21) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / 
+ (3 - 2) * (0.218)) tcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * 
+ ( - 5.11e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * ( - 5.365e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 1.573e-5)) tcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 0.03e-6) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 0.052e-6) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 0.018e-6)) vcc1=((mimflag - 2) * (mimflag - 3) / (1 - 2) 
+ / (1 - 3) * (3.66e-5) + (mimflag - 1) * (mimflag - 3) / (2 - 1) / (2 - 3) * (4.335e-5) 
+ + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 2) * ( - 2.9e-5)) vcc2=((mimflag 
+ - 2) * (mimflag - 3) / (1 - 2) / (1 - 3) * ( - 1.84e-5) + (mimflag - 1) * (mimflag 
+ - 3) / (2 - 1) / (2 - 3) * ( - 4.23e-5) + (mimflag - 1) * (mimflag - 2) / (3 
+ - 1) / (3 - 2) * ( - 2.97e-5)) cmimbb_corner=((mimflag - 2) * (mimflag - 3) / 
+ (1 - 2) / (1 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 3) / (2 - 1) 
+ / (2 - 3) * (cmimbb_mimfac) + (mimflag - 1) * (mimflag - 2) / (3 - 1) / (3 - 
+ 2) * (cmimbb2p0_mimfac)) cmim_para=(1 + factmis) * (((wt + mim_a) * (lt + mim_a) 
+ * 1e12 * mim_b) + 2 * ((wt + mim_a) + (lt + mim_a)) * 1e6 * mim_c) * 1e-15 * 
+ (1 + (temp - 25) * tcc1 + (temp - 25) * (temp - 25) * tcc2) cox_para=((lt 
+ * 1e6 + 0.8) * (wt * 1e6 + 0.8) * 0.0105357 + 2 * ((lt * 1e6 + 0.8) + (wt * 1e6 
+ + 0.8)) * 0.0149) * 1e-15 
//
cmim (top bottom) bsource q=cmim_para*(v(top,bottom)+0.5*v(top,bottom)**(2)*vcc1+1/3*v(top,bottom)**3*vcc2)*cmimbb_corner*mf
cox ( bottom gnode ) capacitor c=cox_para * ((1 / (4.35717 + (1.42106) * (lay - 
+ 2))) / 0.0872414) * cm5bb_mimfac * mf
//
ends mimcap_sin_udc_3t
// 
// 
endsection mim

section mc_rfmvar
parameters a1_var_rf=par1 * 3.2709e+000 * 3 / 2.9
parameters a2_var_rf=par2 * 5.4874e-001 * 3 / 2.9
parameters l_mvfacrf=1.0000e+000 + (7.2304e-003) * a1_var_rf + ( - 5.5488e-005) 
+ * a2_var_rf
parameters rm_mvfacrf=1.0000e+000 + (3.0572e-002) * a1_var_rf + (4.3270e-004) * 
+ a2_var_rf
parameters rsub_mvfacrf=1.0000e+000 + ( - 6.1145e-002) * a1_var_rf + ( - 8.6540e-004) 
+ * a2_var_rf
parameters csub_mvfacrf=1.0000e+000 + (6.3726e-002) * a1_var_rf + (4.4566e-002) 
+ * a2_var_rf
parameters toxm_varrf=2.0000e+001 + ( - 2.7515e-001) * a1_var_rf + ( - 3.8943e-003) 
+ * a2_var_rf
parameters ndep0_varrf=3.8000e+000 + (2.5984e-001) * a1_var_rf + (5.6285e-002) * 
+ a2_var_rf
parameters pndep_varrf=3.0000e-014 + (9.4770e-015) * a1_var_rf + (1.1863e-015) * 
+ a2_var_rf
parameters fac_varrf=1.0000e+000 + (3.2082e-001) * a1_var_rf + (4.7801e-001) * a2_var_rf
parameters rs0_varrf=8.0000e+000 + ( - 3.8112e+001) * a1_var_rf + (1.2309e+002) 
+ * a2_var_rf
parameters dxl_varrf=0.0000e+000 + ( - 1.5286e-009) * a1_var_rf + ( - 2.1635e-011) 
+ * a2_var_rf
parameters dxw_varrf=0.0000e+000 + (2.4458e-009) * a1_var_rf + (3.4616e-011) * a2_var_rf
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar
endsection mc_rfmvar
 
// *******************************************************
// ************ 1.0V MOS Varactor Corner Parameters ***********
// *******************************************************



section tt_rfmvar
parameters l_mvfacrf=1
parameters rm_mvfacrf=1
parameters rsub_mvfacrf=1
parameters csub_mvfacrf=1
parameters toxm_varrf=20.0
parameters ndep0_varrf=3.8
parameters pndep_varrf=3.0e-14
parameters fac_varrf=1.0
parameters rs0_varrf=8
parameters dxl_varrf=0
parameters dxw_varrf=0
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar
endsection tt_rfmvar
 
 
 

section ff_rfmvar
parameters l_mvfacrf=1.0235
parameters rm_mvfacrf=1.1
parameters rsub_mvfacrf=0.8
parameters csub_mvfacrf=1.25
parameters toxm_varrf=19.1
parameters ndep0_varrf=4.7
parameters pndep_varrf=6.2e-14
parameters fac_varrf=2.5
parameters rs0_varrf=1.0
parameters dxl_varrf=-5e-9
parameters dxw_varrf=8e-9
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar
endsection ff_rfmvar
 
 
 

section ss_rfmvar
parameters l_mvfacrf=0.9762
parameters rm_mvfacrf=0.9
parameters rsub_mvfacrf=1.2
parameters csub_mvfacrf=0.833
parameters toxm_varrf=20.9
parameters ndep0_varrf=3.0
parameters pndep_varrf=0.0e-14
parameters fac_varrf=0.4
parameters rs0_varrf=250
parameters dxl_varrf=5e-9
parameters dxw_varrf=-8e-9
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar
endsection ss_rfmvar
 
 
 
 
 
// *******************************************************
// ************ 2.5V MOS Varactor Corner Parameters ***********
// *******************************************************

section mc_rfmvar_25
parameters a1_var_25rf=par6 * 2.8264e+000 * 3 / 2.9
parameters l_mvfacrf25=1.0000e+000 + (8.3664e-003) * a1_var_25rf
parameters rm_mvfacrf25=1.0000e+000 + (3.5378e-002) * a1_var_25rf
parameters rsub_mvfacrf25=1.0000e+000 + ( - 7.0755e-002) * a1_var_25rf
parameters csub_mvfacrf25=1.0000e+000 + (7.3879e-002) * a1_var_25rf
parameters cgmin_varrf25=1.0000e+000 + (3.5378e-002) * a1_var_25rf
parameters dcg_varrf25=1.0000e+000 + (1.8962e-002) * a1_var_25rf
parameters dxl_varrf25=0.0000e+000 + ( - 3.5378e-009) * a1_var_25rf
parameters dxw_varrf25=0.0000e+000 + (4.2453e-009) * a1_var_25rf
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar_25
endsection mc_rfmvar_25
 
 
// *******************************************************
// ************ 2.5V MOS Varactor Corner Parameters ***********
// *******************************************************

section tt_rfmvar_25
parameters l_mvfacrf25=1
parameters rm_mvfacrf25=1
parameters rsub_mvfacrf25=1
parameters csub_mvfacrf25=1
parameters cgmin_varrf25=1
parameters dcg_varrf25=1
parameters dxl_varrf25=0
parameters dxw_varrf25=0
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar_25
endsection tt_rfmvar_25
 
 
 

section ff_rfmvar_25
parameters l_mvfacrf25=1.0235
parameters rm_mvfacrf25=1.1
parameters rsub_mvfacrf25=0.8
parameters csub_mvfacrf25=1.25
parameters cgmin_varrf25=1.1
parameters dcg_varrf25=1.0536
parameters dxl_varrf25=-1.0e-08
parameters dxw_varrf25=1.2e-08
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar_25
endsection ff_rfmvar_25
 
 
 

section ss_rfmvar_25
parameters l_mvfacrf25=0.9762
parameters rm_mvfacrf25=0.9
parameters rsub_mvfacrf25=1.2
parameters csub_mvfacrf25=0.833
parameters cgmin_varrf25=0.9
parameters dcg_varrf25=0.9464
parameters dxl_varrf25=1.0e-08
parameters dxw_varrf25=-1.2e-08
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_mvar_25
endsection ss_rfmvar_25
 
 
// **************************************************************************
//  RF MOS VARACTOR MODEL : 
// 
//   
//      ## library files:
//      
//            
//       Model name          W                L               Group      Branch 
//   
//       -------------------------------------------------------------------------
//        moscap_rf      0.4um<=W<=3.2um  0.2um<=L<=3.2um    1<=G<=16    2<=B<=64 
//           
//        moscap_rf25    0.4um<=W<=3.2um  0.4um<=L<=3.2um    1<=G<=16    2<=B<=64 
//       
//        moscap_rf_nw   0.4um<=W<=3.2um  0.2um<=L<=3.2um    1<=G<=16    2<=B<=64 
//            
//        moscap_rf25_nw 0.4um<=W<=3.2um  0.4um<=L<=3.2um    1<=G<=16    2<=B<=64 
//  
//       -------------------------------------------------------------------------
// **************************************************************************

section rf_mvar
ahdl_include "mosCAPrf_ahdl.va" 
subckt moscap_rf ( gate bulk gnode ) 
parameters wr=2u lr=0.4u gr=2 br=32 factor=1 toxa=toxm_varrf * 0.88 + 0.7 dt=temp 
+ - 25 weff=br * (wr * factor + dxw_varrf - 0.5e-7 + 2.45e-14 * (1.1 + 0.2e-6 / 
+ lr / factor + 0.25 / gr) / wr / factor + ( - 8.0e-8 + 6.0e-14 / wr / factor) * 
+ exp( - 0.5 * br)) leff=gr * (lr * factor + dxl_varrf - 1.6e-8 - 2.0e-2 * lr * 
+ factor / (1.0 + 1.4e5 * lr * factor)) cfrw=1.39e-10 * (((0.7 + 6.2e11 * lr * lr 
+ * factor * factor / (1.0 + 1.1e5 * lr * factor) / (1.0 + 1.1e5 * lr * factor)) 
+ * (1.0 + 4.0e-7 / wr / factor) + 1.5 / (1.0 + 1.5e6 * lr * factor) * gr) * (1.0 
+ + 1.0 / br) * (1 - 1.0 * wr * wr * lr / br / gr / (1e-6 / factor + wr) / (1e-6 
+ / factor + wr) / (1e-6 / factor + lr))) rvalue=rs0_varrf eff=wr * factor * lr 
+ * factor * br * gr * (1.0 + 1.6e-3 * (temp - 25)) * 9393.931 / toxa / toxa / 
+ toxa * fac_varrf phit=(temp + 273.0) / 11606.0 as00=(ndep0_varrf + 0.54 + 4.58 
+ / (lr * factor * 1e6 + 0.45)) * (1.0 + (1e-6 / wr / factor - 1 / 0.8) * (0.258167 
+ + 0.039 * (1e-6 / wr / factor - 1.0 / 3.2) + 0.1049 * (1e-6 / lr / factor - 1.0 
+ / 0.8) - 0.03056 * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 / lr / factor - 1.0 
+ / 0.8) + 0.154 * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) as03=(1.95 + (4.32e-13 
+ + pndep_varrf) / lr / lr / factor / factor) * (1.0 + (1e-6 / wr / factor - 1 / 
+ 0.8) * ( - 2.27929 + 2.3737 * (1e-6 / wr / factor - 1.0 / 3.2) - 1.2015 * (1e-6 
+ / lr / factor - 1.0 / 0.8) + 4.025603 * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 
+ / lr / factor - 1.0 / 0.8) + 3.6233 * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) 
+ as=sqrt(((as00 - 1.75 + 2.1 / br + 0.7 / gr + as03 * (0.5 - 1 / br) * (1 - 1 / 
+ gr)) * (1 - 0.9 * wr * wr * lr / br / gr / (2e-6 / factor + wr) / (2e-6 / factor 
+ + wr) / (2e-6 / factor + lr))) * 3.8850499 / (temp + 273.0)) * toxa / 3.399936 
+ as2=as * as a0=1.0 / (1.0 + 0.707106781186547 * as) vfb00=(0.037 - 0.0077e-6 / 
+ lr / factor) * (1.0 + (1e-6 / wr / factor - 1 / 0.8) * (1.463842 - 0.3372 * (1e-6 
+ / wr / factor - 1.0 / 3.2) - 0.0993 * (1e-6 / lr / factor - 1.0 / 0.8) + 1.794024 
+ * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 / lr / factor - 1.0 / 0.8) - 5.9152 
+ * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) vfb03=(0.01 - 0.105e-6 / (lr / factor 
+ + 1.0e-6)) * (1.0 + (1e-6 / wr / factor - 1 / 0.8) * (3.906341 - 2.8958 * (1e-6 
+ / wr / factor - 1.0 / 3.2) - 0.6277 * (1e-6 / lr / factor - 1.0 / 0.8) + 0.836202 
+ * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 / lr / factor - 1.0 / 0.8) - 14.1588 
+ * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) vfb=vfb00 + 0.015 * (0.5 - 1 / br) 
+ + (0.003 + vfb03 * (0.5 - 1 / br)) * (1.0 - 1.0 / gr) * (1.0 + (temp - 25.0) 
+ * 7.5e-3) ld2d=lr * factor + 2 * 9.0e-8 rdm11=0.188 * (wr * factor + 2.30e-07) 
+ / 1.30e-7 rdcont=30 / int(abs((wr * factor - 0.3e-6) / 0.34e-6 + 1.00001)) rwell=280 
+ * (lr * factor / 4 + 9.00e-8 + 1.30e-7 / 2) / wr / factor rrrd=1.735 + (gr - 1) 
+ * (2 * gr - 1) / (6 * gr) * rdm11 + (rwell / 2 + rdcont) / gr rdvia_array=0.75 
+ * 3 / ((2 * 9.8e-7 + br * ld2d + (br + 1) * 1.3e-7) / 2.3e-7 / (br + 1) * 2) rrd=rrrd 
+ + rdvia_array rdm1=0.188 * (1.3e-7 + ld2d) / 1e-06 rdm2=0.163 * (1.3e-7 + ld2d) 
+ / 2.8e-06 rdmhead=1 / (1 / rdm1 + 1 / rdm2) rd=(rdmhead / 2 + ((br + 1) / 2 - 
+ 1) * br / (6 * ((br + 1) / 2)) * rdmhead + rrd / ((br + 1) / 2)) / 2 rgm11=0.188 
+ * wr * factor / 1.3e-7 rpo=15.75 * (wr * factor / 2) / (2 * 1.3e-7) rrrg=1.44615 
+ + (gr + 1 - 1) * (2 * (gr + 1) - 1) / (6 * (gr + 1)) * rgm11 + (rpo / 2 + 22) 
+ / (gr + 1) avrrrg=rrrg / (int(abs((lr * factor - 0.2e-6) / 0.22e-6) + 1.00001)) 
+ rgviaarray=0.75 * 3 / ((2 * 1.2e-6 + (br - 1) * 4.2e-7 + br * 1.55e-7) / 2.3e-7 
+ / br * 2) rrg=avrrrg + rgviaarray rgm1=0.188 * (lr * factor + 4.2e-7) / 1e-06 
+ rgm2=0.163 * (lr * factor + 4.2e-7) / 2.8e-06 rgmhead=1 / (1 / rgm1 + 1 / rgm2) 
+ rgg=(rgmhead / 2 + (br / 2 - 1) * (br - 1) / (6 * (br / 2)) * rgmhead + rrg / 
+ (br / 2)) / 2 ww=wr * factor * gr + 2.30e-07 * (gr - 1) ll=lr * factor * br + 
+ (br - 1) * 3.10e-7 + 2 * 2.30e-7 wtub=ww + 2 * 3.6e-7 ltub=ll + 2 * 3.6e-7 area_dio=wtub 
+ * ltub pj_dio=2 * (wtub + ltub) rwsti=873.4 * 3e-6 / ll rwod=280 * ww / 6 / ll 
+ rlsti=873.4 * 3e-6 / ww rlod=280 * ll / 6 / ww rrsub=1 / (2 / (rwsti + rwod) + 
+ 2 / (rlsti + rlod)) rsub=rrsub * (1 + 3.6m * dt + 10u * dt * dt) 
 
 
 
 
lgate ( gate 1 ) inductor l=l_mvfacrf * (2.96951 * ((wr * factor * 1e6) ** 3.105522) 
+ * ((lr * factor * 1e6) ** ( - 6.93053)) * (gr ** ( - 2.14551)) * (br ** ( - 9.30307)) 
+ + 0.596551 * (wr * factor / lr / factor) + 1.114765 * (gr / br) - 0.59986 * (wr 
+ * factor * 1e6) - 0.43278 / (lr * factor * 1e6) - 0.07311 * gr + 1.105405 / br 
+ + 1.463448) * 1e-12
rgate ( 1 2 ) resistor r=rm_mvfacrf * (rgg) * (1 + 2.7m * dt + 6u * dt * dt)
cgate (2 3) mosCAPrf toxa=toxa weff=weff leff=leff as=as as2=as2 phit=phit a0=a0 vfb=vfb cfrw=cfrw
gdf1 ( 2 3 ) bsource i =eff * (2.7e4 * (pow(0.5 * (sqrt(v(2,3) * v(2,3) + 1.0e-4) 
+ + v(2,3)),4.7) - pow(5.0e-3,4.7)) - 180.0 * (pow(0.5 * (sqrt(v(2,3) * v(2,3) + 
+ 1.0e-4) - v(2,3)),1.4) - pow(5.0e-3,1.4)) + 250.0 * v(2,3))
rsd ( 3 4 ) resistor r=rm_mvfacrf * (rd) * (1 + 2.5m * dt)
lsd ( 4 bulk ) inductor l=l_mvfacrf * (2.96951 * ((wr * factor * 1e6) ** 3.105522) 
+ * ((lr * factor * 1e6) ** ( - 6.93053)) * (gr ** ( - 2.14551)) * (br ** ( - 9.30307)) 
+ + 0.596551 * (wr * factor / lr / factor) + 1.114765 * (gr / br) - 0.59986 * (wr 
+ * factor * 1e6) - 0.43278 / (lr * factor * 1e6) - 0.07311 * gr + 1.105405 / br 
+ + 1.463448) * 1e-12
dio ( 5 3 ) mvdnwpsub area=area_dio pj=pj_dio
r_sub ( 5 gnode ) resistor r=rsub_mvfacrf * rsub
c_sub ( 5 gnode ) capacitor c=csub_mvfacrf * 165f / rsub
ends moscap_rf
 
subckt moscap_rf_nw ( gate bulk gnode ) 
parameters wr=2u lr=0.4u gr=2 br=32 factor=1 toxa=toxm_varrf * 0.88 + 0.7 dt=temp 
+ - 25 weff=br * (wr * factor + dxw_varrf - 0.5e-7 + 2.45e-14 * (1.1 + 0.2e-6 / 
+ lr / factor + 0.25 / gr) / wr / factor + ( - 8.0e-8 + 6.0e-14 / wr / factor) * 
+ exp( - 0.5 * br)) leff=gr * (lr * factor + dxl_varrf - 1.6e-8 - 2.0e-2 * lr * 
+ factor / (1.0 + 1.4e5 * lr * factor)) cfrw=1.39e-10 * (((0.7 + 6.2e11 * lr * lr 
+ * factor * factor / (1.0 + 1.1e5 * lr * factor) / (1.0 + 1.1e5 * lr * factor)) 
+ * (1.0 + 4.0e-7 / wr / factor) + 1.5 / (1.0 + 1.5e6 * lr * factor) * gr) * (1.0 
+ + 1.0 / br) * (1 - 1.0 * wr * wr * lr / br / gr / (1e-6 / factor + wr) / (1e-6 
+ / factor + wr) / (1e-6 / factor + lr))) rvalue=rs0_varrf eff=wr * factor * lr 
+ * factor * br * gr * (1.0 + 1.6e-3 * (temp - 25)) * 9393.931 / toxa / toxa / 
+ toxa * fac_varrf phit=(temp + 273.0) / 11606.0 as00=(ndep0_varrf + 0.54 + 4.58 
+ / (lr * factor * 1e6 + 0.45)) * (1.0 + (1e-6 / wr / factor - 1 / 0.8) * (0.258167 
+ + 0.039 * (1e-6 / wr / factor - 1.0 / 3.2) + 0.1049 * (1e-6 / lr / factor - 1.0 
+ / 0.8) - 0.03056 * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 / lr / factor - 1.0 
+ / 0.8) + 0.154 * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) as03=(1.95 + (4.32e-13 
+ + pndep_varrf) / lr / lr / factor / factor) * (1.0 + (1e-6 / wr / factor - 1 / 
+ 0.8) * ( - 2.27929 + 2.3737 * (1e-6 / wr / factor - 1.0 / 3.2) - 1.2015 * (1e-6 
+ / lr / factor - 1.0 / 0.8) + 4.025603 * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 
+ / lr / factor - 1.0 / 0.8) + 3.6233 * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) 
+ as=sqrt(((as00 - 1.75 + 2.1 / br + 0.7 / gr + as03 * (0.5 - 1 / br) * (1 - 1 / 
+ gr)) * (1 - 0.9 * wr * wr * lr / br / gr / (2e-6 / factor + wr) / (2e-6 / factor 
+ + wr) / (2e-6 / factor + lr))) * 3.8850499 / (temp + 273.0)) * toxa / 3.399936 
+ as2=as * as a0=1.0 / (1.0 + 0.707106781186547 * as) vfb00=(0.037 - 0.0077e-6 / 
+ lr / factor) * (1.0 + (1e-6 / wr / factor - 1 / 0.8) * (1.463842 - 0.3372 * (1e-6 
+ / wr / factor - 1.0 / 3.2) - 0.0993 * (1e-6 / lr / factor - 1.0 / 0.8) + 1.794024 
+ * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 / lr / factor - 1.0 / 0.8) - 5.9152 
+ * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) vfb03=(0.01 - 0.105e-6 / (lr / factor 
+ + 1.0e-6)) * (1.0 + (1e-6 / wr / factor - 1 / 0.8) * (3.906341 - 2.8958 * (1e-6 
+ / wr / factor - 1.0 / 3.2) - 0.6277 * (1e-6 / lr / factor - 1.0 / 0.8) + 0.836202 
+ * (1e-6 / wr / factor - 1.0 / 3.2) * (1e-6 / lr / factor - 1.0 / 0.8) - 14.1588 
+ * (wr / (1.0e-6 / factor + wr) - 0.8 / 1.8))) vfb=vfb00 + 0.015 * (0.5 - 1 / br) 
+ + (0.003 + vfb03 * (0.5 - 1 / br)) * (1.0 - 1.0 / gr) ld2d=lr * factor + 2 * 9.0e-8 
+ rdm11=0.188 * (wr * factor + 2.30e-07) / 1.30e-7 rdcont=30 / int(abs((wr * factor 
+ - 0.3e-6) / 0.34e-6 + 1.00001)) rwell=280 * (lr * factor / 4 + 9.00e-8 + 1.30e-7 
+ / 2) / wr / factor rrrd=1.735 + (gr - 1) * (2 * gr - 1) / (6 * gr) * rdm11 + (rwell 
+ / 2 + rdcont) / gr rdvia_array=0.75 * 3 / ((2 * 9.8e-7 + br * ld2d + (br + 1) 
+ * 1.3e-7) / 2.3e-7 / (br + 1) * 2) rrd=rrrd + rdvia_array rdm1=0.188 * (1.3e-7 
+ + ld2d) / 1e-06 rdm2=0.163 * (1.3e-7 + ld2d) / 2.8e-06 rdmhead=1 / (1 / rdm1 + 
+ 1 / rdm2) rd=(rdmhead / 2 + ((br + 1) / 2 - 1) * br / (6 * ((br + 1) / 2)) * rdmhead 
+ + rrd / ((br + 1) / 2)) / 2 rgm11=0.188 * wr * factor / 1.3e-7 rpo=15.75 * (wr 
+ * factor / 2) / (2 * 1.3e-7) rrrg=1.44615 + (gr + 1 - 1) * (2 * (gr + 1) - 1) 
+ / (6 * (gr + 1)) * rgm11 + (rpo / 2 + 22) / (gr + 1) avrrrg=rrrg / (int(abs((lr 
+ * factor - 0.2e-6) / 0.22e-6) + 1.00001)) rgviaarray=0.75 * 3 / ((2 * 1.2e-6 + 
+ (br - 1) * 4.2e-7 + br * 1.55e-7) / 2.3e-7 / br * 2) rrg=avrrrg + rgviaarray rgm1=0.188 
+ * (lr * factor + 4.2e-7) / 1e-06 rgm2=0.163 * (lr * factor + 4.2e-7) / 2.8e-06 
+ rgmhead=1 / (1 / rgm1 + 1 / rgm2) rgg=(rgmhead / 2 + (br / 2 - 1) * (br - 1) / 
+ (6 * (br / 2)) * rgmhead + rrg / (br / 2)) / 2 ww=wr * factor * gr + 2.30e-07 
+ * (gr - 1) ll=lr * factor * br + (br - 1) * 3.10e-7 + 2 * 2.30e-7 wtub=ww + 2 
+ * 1.8e-7 ltub=ll + 2 * 1.8e-7 area_dio=wtub * ltub pj_dio=2 * (wtub + ltub) rwsti=873.4 
+ * 3e-6 / ll rwod=280 * ww / 6 / ll rlsti=873.4 * 3e-6 / ww rlod=280 * ll / 6 / 
+ ww rrsub=1 / (2 / (rwsti + rwod) + 2 / (rlsti + rlod)) rsub=rrsub * (1 + 3.6m 
+ * dt + 10u * dt * dt) 
 
 
 
lgate ( gate 1 ) inductor l=l_mvfacrf * (2.96951 * ((wr * factor * 1e6) ** 3.105522) 
+ * ((lr * factor * 1e6) ** ( - 6.93053)) * (gr ** ( - 2.14551)) * (br ** ( - 9.30307)) 
+ + 0.596551 * (wr * factor / lr / factor) + 1.114765 * (gr / br) - 0.59986 * (wr 
+ * factor * 1e6) - 0.43278 / (lr * factor * 1e6) - 0.07311 * gr + 1.105405 / br 
+ + 1.463448) * 1e-12
rgate ( 1 2 ) resistor r=rm_mvfacrf * (rgg) * (1 + 2.7m * dt + 6u * dt * dt)
cgate (2 3) mosCAPrf toxa=toxa weff=weff leff=leff as=as as2=as2 phit=phit a0=a0 vfb=vfb cfrw=cfrw
gdf1 ( 2 3 ) bsource i =eff * (2.7e4 * (pow(0.5 * (sqrt(v(2,3) * v(2,3) + 1.0e-4) 
+ + v(2,3)),4.7) - pow(5.0e-3,4.7)) - 180.0 * (pow(0.5 * (sqrt(v(2,3) * v(2,3) + 
+ 1.0e-4) - v(2,3)),1.4) - pow(5.0e-3,1.4)) + 250.0 * v(2,3))
rsd ( 3 4 ) resistor r=rm_mvfacrf * (rd) * (1 + 2.5m * dt)
lsd ( 4 bulk ) inductor l=l_mvfacrf * (2.96951 * ((wr * factor * 1e6) ** 3.105522) 
+ * ((lr * factor * 1e6) ** ( - 6.93053)) * (gr ** ( - 2.14551)) * (br ** ( - 9.30307)) 
+ + 0.596551 * (wr * factor / lr / factor) + 1.114765 * (gr / br) - 0.59986 * (wr 
+ * factor * 1e6) - 0.43278 / (lr * factor * 1e6) - 0.07311 * gr + 1.105405 / br 
+ + 1.463448) * 1e-12
dio ( 5 3 ) mvnwdio area=area_dio pj=pj_dio
r_sub ( 5 gnode ) resistor r=rsub_mvfacrf * rsub
c_sub ( 5 gnode ) capacitor c=csub_mvfacrf * 165f / rsub
ends moscap_rf_nw
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_mvdnwpsub
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_mvnwdio
endsection rf_mvar
 
 

section dio_mvdnwpsub
model mvdnwpsub diode 
+ level=1                   is=2.44e-6                isw=5.88e-12
+ rs=1.0e-10                n=1.005                   cj=1.15e-04
+ cjsw=1.39e-9              bv=11.8                   area=3.1161e-8
+ pj=7.24e-4                mj=0.315                  mjsw=0.265
+ vj=0.56                   vjsw=0.45                 trs=2.5e-3
+ tbv1=-1*-8.500e-04        cta=2.20e-3               ctp=1.29e-03
+ pta=2.95e-3               ptp=1.7e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ ns=1.005                  nz=1.005                  imax=1e40
+ minr=1e-10                allow_scaling=1
endsection dio_mvdnwpsub
 
 

section dio_mvnwdio
model mvnwdio diode 
+ level=1                   is=2.49e-6                isw=8.22e-13
+ rs=1.0e-10                n=1.005                   cj=1.388e-04
+ cjsw=7.49e-10             bv=11.8                   area=3.1161e-8
+ pj=7.24e-4                mj=0.325                  mjsw=0.31
+ vj=0.5                    vjsw=0.5                  trs=2.5e-3
+ tbv1=-1*-9.000e-04        cta=2.16e-3               ctp=1.3e-03
+ pta=2.60e-3               ptp=1.6e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ ns=1.005                  nz=1.005                  imax=1e40
+ minr=1e-10                allow_scaling=1
 
endsection dio_mvnwdio
 
 
 
 
 
 

section rf_mvar_25
subckt moscap_rf25 ( gate bulk gnode ) 
parameters wr=2u lr=0.4u gr=2 br=32 factor=1 xlrf25=1.5e-08 xwrf25=-7.0e-09 leffrf25=(lr 
+ * factor - xlrf25 + dxl_varrf25) * (gr * br) weffrf25=(wr * factor - xwrf25 + 
+ dxw_varrf25) * (gr * br) arearf25=leffrf25 * weffrf25 / (gr * br) cgminrf25=3.2e-10 
+ * cgmin_varrf25 * 2 * weffrf25 + 1.8e-10 * cgmin_varrf25 * 2 * leffrf25 + 0.96e-03 
+ * cgmin_varrf25 * arearf25 dcgrf25= - 3.0e-11 * dcg_varrf25 * 2 * weffrf25 - 1.0e-11 
+ * dcg_varrf25 * 2 * leffrf25 + 2.285e-03 * dcg_varrf25 * arearf25 dt=temp - 
+ 25 dvgsrf25= - 0.16 - 2.000e-04 * dt vgnormrf25=0.55 + 1.0e-03 * dt ld2d=lr * 
+ factor + 2 * 9.0e-8 rdm11=0.188 * (wr * factor + 2.30e-07) / 1.30e-7 rdcont=30 
+ / int(abs((wr * factor - 0.3e-6) / 0.34e-6 + 1.00001)) rwell=315 * (lr * factor 
+ / 4 + 9.00e-8 + 1.30e-7 / 2) / wr / factor rrrd=1.735 + (gr - 1) * (2 * gr - 1) 
+ / (6 * gr) * rdm11 + (rwell / 2 + rdcont) / gr rdvia_array=0.75 * 3 / ((2 * 9.8e-7 
+ + br * ld2d + (br + 1) * 1.3e-7) / 2.3e-7 / (br + 1) * 2) rrd=rrrd + rdvia_array 
+ rdm1=0.188 * (1.3e-7 + ld2d) / 1e-06 rdm2=0.163 * (1.3e-7 + ld2d) / 2.8e-06 rdmhead=1 
+ / (1 / rdm1 + 1 / rdm2) rd=(rdmhead / 2 + ((br + 1) / 2 - 1) * br / (6 * ((br 
+ + 1) / 2)) * rdmhead + rrd / ((br + 1) / 2)) / 2 lm1g=1.4e-6 + wr * factor * gr 
+ + 0.23e-6 * (gr - 1) wm1g=lr * factor - 0.09e-6 * int((lr * factor - 0.2e-6) / 
+ 0.2e-6) rgm=0.16 * lm1g / (3 * wm1g * br) rgp=17.0 * wr * factor / (12 * lr * 
+ factor * gr * br) rgch=((lr * factor * 1e6) ** ( - 0.038119)) / (12 * 0.002072) 
+ / ((wr * factor * 1e6) ** 0.656366) / (gr ** 0.818013) / (br ** 1.066443) rg=rgm 
+ + rgp + rgch lm1s=(1.2 - 0.015) * 1e-6 + wr * factor * gr + 0.23e-6 * (gr - 1) 
+ wm1s=0.13e-6 rsm=0.16 * lm1s / (3 * wm1s * (br + 1)) lgm=1e-9 * 2 * lm1g * (log(2 
+ * lm1g / (wm1g + 0.18e-6)) + 0.5 + (wm1g + 0.18e-6) / (3 * lm1g)) / br lsm=1e-9 
+ * 2 * lm1s * (log(2 * lm1s / (wm1s + 0.18e-6)) + 0.5 + (wm1s + 0.18e-6) / (3 * 
+ lm1s)) / (br + 1) ww=wr * factor * gr + 2.30e-07 * (gr - 1) ll=lr * factor * br 
+ + (br - 1) * 3.10e-7 + 2 * 2.30e-7 wtub=ww + 2 * 3.6e-7 ltub=ll + 2 * 3.6e-7 area_dio=wtub 
+ * ltub pj_dio=2 * (wtub + ltub) rwsti=554 * 3e-6 / ll rwod=315 * ww / 6 / ll rlsti=554 
+ * 3e-6 / ww rlod=315 * ll / 6 / ww rrsub=1 / (2 / (rwsti + rwod) + 2 / (rlsti 
+ + rlod)) rsub=rrsub * (1 + 3.6m * dt + 10u * dt * dt) 
 
 
 
 
 
 
lgate ( gate 1 ) inductor l=l_mvfacrf25 * lgm
rgate ( 1 2 ) resistor r=rm_mvfacrf25 * rg * (1 + 2.7m * dt + 6u * dt * dt)
cgate ( 2 3 ) bsource c=cgminrf25 + dcgrf25 * (1.0 + tanh((v(2,3) - dvgsrf25) / 
+ vgnormrf25))
rsd ( 3 4 ) resistor r=rm_mvfacrf25 * rd * (1 + 2.5m * dt)
lsd ( 4 bulk ) inductor l=l_mvfacrf25 * lsm
dio ( 5 3 ) mvdnwpsub25 area=area_dio pj=pj_dio
r_sub ( 5 gnode ) resistor r=rsub_mvfacrf25 * rsub
c_sub ( 5 gnode ) capacitor c=csub_mvfacrf25 * 165f / rsub
ends moscap_rf25
 
subckt moscap_rf25_nw ( gate bulk gnode ) 
parameters wr=2u lr=0.4u gr=2 br=32 factor=1 xlrf25=1.5e-08 xwrf25=-7.0e-09 leffrf25=(lr 
+ * factor - xlrf25 + dxl_varrf25) * (gr * br) weffrf25=(wr * factor - xwrf25 + 
+ dxw_varrf25) * (gr * br) arearf25=leffrf25 * weffrf25 / (gr * br) cgminrf25=3.2e-10 
+ * cgmin_varrf25 * 2 * weffrf25 + 1.8e-10 * cgmin_varrf25 * 2 * leffrf25 + 0.96e-03 
+ * cgmin_varrf25 * arearf25 dcgrf25= - 3.0e-11 * dcg_varrf25 * 2 * weffrf25 - 1.0e-11 
+ * dcg_varrf25 * 2 * leffrf25 + 2.285e-03 * dcg_varrf25 * arearf25 dt=temp - 
+ 25 dvgsrf25= - 0.16 - 2.000e-04 * dt vgnormrf25=0.55 + 1.0e-03 * dt ld2d=lr * 
+ factor + 2 * 9.0e-8 rdm11=0.188 * (wr * factor + 2.30e-07) / 1.30e-7 rdcont=30 
+ / int(abs((wr * factor - 0.3e-6) / 0.34e-6 + 1.00001)) rwell=315 * (lr * factor 
+ / 4 + 9.00e-8 + 1.30e-7 / 2) / wr / factor rrrd=1.735 + (gr - 1) * (2 * gr - 1) 
+ / (6 * gr) * rdm11 + (rwell / 2 + rdcont) / gr rdvia_array=0.75 * 3 / ((2 * 9.8e-7 
+ + br * ld2d + (br + 1) * 1.3e-7) / 2.3e-7 / (br + 1) * 2) rrd=rrrd + rdvia_array 
+ rdm1=0.188 * (1.3e-7 + ld2d) / 1e-06 rdm2=0.163 * (1.3e-7 + ld2d) / 2.8e-06 rdmhead=1 
+ / (1 / rdm1 + 1 / rdm2) rd=(rdmhead / 2 + ((br + 1) / 2 - 1) * br / (6 * ((br 
+ + 1) / 2)) * rdmhead + rrd / ((br + 1) / 2)) / 2 lm1g=1.4e-6 + wr * factor * gr 
+ + 0.23e-6 * (gr - 1) wm1g=lr * factor - 0.09e-6 * int((lr * factor - 0.2e-6) / 
+ 0.2e-6) rgm=0.16 * lm1g / (3 * wm1g * br) rgp=17.0 * wr * factor / (12 * lr * 
+ factor * gr * br) rgch=((lr * factor * 1e6) ** ( - 0.038119)) / (12 * 0.002072) 
+ / ((wr * factor * 1e6) ** 0.656366) / (gr ** 0.818013) / (br ** 1.066443) rg=rgm 
+ + rgp + rgch lm1s=(1.2 - 0.015) * 1e-6 + wr * factor * gr + 0.23e-6 * (gr - 1) 
+ wm1s=0.13e-6 rsm=0.16 * lm1s / (3 * wm1s * (br + 1)) lgm=1e-9 * 2 * lm1g * (log(2 
+ * lm1g / (wm1g + 0.18e-6)) + 0.5 + (wm1g + 0.18e-6) / (3 * lm1g)) / br lsm=1e-9 
+ * 2 * lm1s * (log(2 * lm1s / (wm1s + 0.18e-6)) + 0.5 + (wm1s + 0.18e-6) / (3 * 
+ lm1s)) / (br + 1) ww=wr * factor * gr + 2.30e-07 * (gr - 1) ll=lr * factor * br 
+ + (br - 1) * 3.10e-7 + 2 * 2.30e-7 wtub=ww + 2 * 3.6e-7 ltub=ll + 2 * 1.8e-7 area_dio=wtub 
+ * ltub pj_dio=2 * (wtub + ltub) rwsti=554 * 3e-6 / ll rwod=315 * ww / 6 / ll rlsti=554 
+ * 3e-6 / ww rlod=315 * ll / 6 / ww rrsub=1 / (2 / (rwsti + rwod) + 2 / (rlsti 
+ + rlod)) rsub=rrsub * (1 + 3.6m * dt + 10u * dt * dt) 
 
 
 
 
 
 
lgate ( gate 1 ) inductor l=l_mvfacrf25 * lgm
rgate ( 1 2 ) resistor r=rm_mvfacrf25 * rg * (1 + 2.7m * dt + 6u * dt * dt)
cgate ( 2 3 ) bsource c=cgminrf25 + dcgrf25 * (1.0 + tanh((v(2,3) - dvgsrf25) / 
+ vgnormrf25))
rsd ( 3 4 ) resistor r=rm_mvfacrf25 * rd * (1 + 2.5m * dt)
lsd ( 4 bulk ) inductor l=l_mvfacrf25 * lsm
dio ( 5 3 ) mvnwdio25 area=area_dio pj=pj_dio
r_sub ( 5 gnode ) resistor r=rsub_mvfacrf25 * rsub
c_sub ( 5 gnode ) capacitor c=csub_mvfacrf25 * 165f / rsub
ends moscap_rf25_nw
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_mvdnwpsub25
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_mvnwdio25
endsection rf_mvar_25
 
 
 

section dio_mvdnwpsub25
model mvdnwpsub25 diode 
+ level=1                   is=2.44e-6                isw=5.88e-12
+ rs=1.0e-10                n=1.005                   cj=1.15e-04
+ cjsw=1.39e-9              bv=11.8                   area=3.1161e-8
+ pj=7.24e-4                mj=0.315                  mjsw=0.265
+ vj=0.56                   vjsw=0.45                 trs=2.5e-3
+ tbv1=-1*-8.500e-04        cta=2.20e-3               ctp=1.29e-03
+ pta=2.95e-3               ptp=1.7e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ ns=1.005                  nz=1.005                  imax=1e40
+ minr=1e-10                allow_scaling=1
endsection dio_mvdnwpsub25
 
 
 

section dio_mvnwdio25
model mvnwdio25 diode 
+ level=1                   is=2.49e-6                isw=8.22e-13
+ rs=1.0e-10                n=1.005                   cj=1.388e-04
+ cjsw=7.49e-10             bv=11.8                   area=3.1161e-8
+ pj=7.24e-4                mj=0.325                  mjsw=0.31
+ vj=0.5                    vjsw=0.5                  trs=2.5e-3
+ tbv1=-1*-9.000e-04        cta=2.16e-3               ctp=1.3e-03
+ pta=2.60e-3               ptp=1.6e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ ns=1.005                  nz=1.005                  imax=1e40
+ minr=1e-10                allow_scaling=1
 
endsection dio_mvnwdio25

 
// *******************************************************
// ************ Xj Varactor Corner Parameters ************
// *******************************************************
 
 
 

section mc_rfjvar
parameters par1mc_rfjvar=0
parameters a1mc_rfjvar=par1mc_rfjvar * 2.8264e+000 * 3 / 3
parameters cj_fac=1.0000e+000 + (2.4764e-002) * a1mc_rfjvar
parameters cjsw_fac=1.0000e+000 + (2.4764e-002) * a1mc_rfjvar
parameters l_fac=1.0000e+000 + (8.3664e-003) * a1mc_rfjvar
parameters rm_fac=1.0000e+000 + (3.5378e-002) * a1mc_rfjvar
parameters rsub_fac=1.0000e+000 + ( - 7.0755e-002) * a1mc_rfjvar
parameters csub_fac=1.0000e+000 + (7.3822e-002) * a1mc_rfjvar
parameters rwell_fac=1.0000e+000 + (5.3067e-002) * a1mc_rfjvar
parameters csti_fac=1.0000e+000 + (1.7689e-002) * a1mc_rfjvar
statistics {
    process {
        vary par1mc_rfjvar dist=gauss std=1/3
        }
    }
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_jvar
endsection mc_rfjvar



section tt_rfjvar
parameters cj_fac=1
parameters cjsw_fac=1
parameters l_fac=1
parameters rm_fac=1
parameters rsub_fac=1
parameters csub_fac=1
parameters rwell_fac=1
parameters csti_fac=1
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_jvar
endsection tt_rfjvar
 
 
 

section ff_rfjvar
parameters cj_fac=0.93
parameters cjsw_fac=0.93
parameters l_fac=0.9762
parameters rm_fac=0.9
parameters rsub_fac=1.2
parameters csub_fac=0.83333
parameters rwell_fac=0.85
parameters csti_fac=0.95
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_jvar
endsection ff_rfjvar
 
 
 

section ss_rfjvar
parameters cj_fac=1.07
parameters cjsw_fac=1.07
parameters l_fac=1.0235
parameters rm_fac=1.1
parameters rsub_fac=0.8
parameters csub_fac=1.25
parameters rwell_fac=1.15
parameters csti_fac=1.05
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_jvar
endsection ss_rfjvar
 
 

section rf_jvar
// **************************************************************************
//  JUNCTION VARACTOR MODEL :
// 
// 
//   HSPICE LEVEL 49:
//   
//      ## library files:
//      
//            
//       Model name      L(um)         W(um)(w)       Finger(nr)  
//       ---------------------------------------------------
//        xjvar        0.15 ~ 1        10 ~ 60         1 ~ 64  
//        xjvar_nw     0.15 ~ 1        10 ~ 60         1 ~ 64     
//       ---------------------------------------------------
// **************************************************************************
subckt xjvar_nw ( anode cathode gnode ) 
parameters l=0.3u w=15u nr=1 nconp=int((w - 0.28u) / 0.23u + 0.1m) + 1 nconn=int((w 
+ - 0.2u) / 0.2u + 0.1m) + 1 nstrip=int(abs(l - 0.27u) / 0.23u + 0.1m) + 1 area_d1=nr 
+ * l * w peri_d1=2 * nr * (l + w) area_d2=((l + 0.45u) * nr + 2.39u) * (w + 2.24u) 
+ peri_d2=2 * (((l + 0.45u) * nr + 2.39u) + (w + 2.82u)) m1_s_sd=l + 0.45u rr_pnsd=(0.188 
+ * m1_s_sd / 1u) * (0.163 * m1_s_sd / 3u) / ((0.188 * m1_s_sd / 1u) + (0.163 * 
+ m1_s_sd / 3u)) r_1str_p=(1.5416 + ((nconp - 1) * (2 * nconp - 1) / 6 / nconp * 
+ 0.2162) + 30 / nconp) / nstrip r_1str_n=(1.504 + ((nconn - 1) * (2 * nconn - 1) 
+ / 6 / nconn * 0.188) + 30 / nconn) dt=temp - 25 
rpsd ( anode 1 ) resistor r=( - 0.4498 * (l * 1e6) + 1.0484) * (1 - (w * 1e6) / 
+ 10 * 0.02) * ((rr_pnsd / 2 + ((nr / 2 - 1) * (nr - 1) / 3 / nr * rr_pnsd) + r_1str_p 
+ / nr * 2) / 2) * (1 + 2.69e-3 * dt - 3e-7 * dt * dt) * rm_fac
l1 ( 1 2 ) inductor l=(0.0105 * w * 1e6 + 0.3755) * (w * 1e6 / 40) * (1.27e-11 * 
+ (30 / (w * 1e6)) * (0.7382 * (1 / nr) + 0.2675)) * l_fac
d1 ( 2 3 ) pdio_xj area=area_d1 pj=peri_d1
rwell ( 3 4 ) resistor r=0.92 * (20 / (w * 1e6)) * (1.8526 * (l * 1e6) * (l * 1e6) 
+ - 3.2111 * (l * 1e6) + 2.3984) * ( - 0.086 * nr + 7.9461) * ((554 * 0.15u / w 
+ + 315 * (l + 0.15u) / 2 / w) / 2 / nr) * (1 + 2.95e-3 * dt + 8.42e-6 * dt * dt) 
+ * rwell_fac
l2 ( 4 5 ) inductor l=(0.0105 * w * 1e6 + 0.3755) * (w * 1e6 / 40) * (1.27e-11 * 
+ (30 / (w * 1e6)) * (0.7382 * (1 / nr) + 0.2675)) * l_fac
rnsd ( 5 cathode ) resistor r=( - 0.4498 * (l * 1e6) + 1.0484) * (1 - (w * 1e6) 
+ / 10 * 0.02) * ((rr_pnsd / 2 + (((nr + 1) / 2 - 1) * (nr + 1 - 1) / 3 / (nr + 
+ 1) * rr_pnsd) + r_1str_n / (nr + 1) * 2) / 2) * (1 + 2.69e-3 * dt - 3e-7 * dt 
+ * dt) * rm_fac
csti ( 2 4 ) capacitor c=0.2385 * w * nr * 1e-9 * (l * 1e6 + 0.02) / (l * 1e6)
d2 ( 30 3 ) nwpsub_xj area=area_d2 pj=peri_d2
rsub ( 30 gnode ) resistor r=(1.872 / nr + 0.2225) * (30 / (w * 1e6)) * (1 / ((1 
+ / (315 * w / 6 / ((l + 0.45u) * nr + 0.15u) + 554 * 3u / ((l + 0.45u) * nr + 0.15u))) 
+ + 1 / ((315 * w / 6 / ((l + 0.45u) * nr + 0.15u)) + 554 * 3u / ((l + 0.45u) * 
+ nr + 0.15u)) + 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 554 * 3u / w) + 
+ 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 554 * 3u / w))) * (1 + 2.95e-3 
+ * dt + 8.42e-6 * dt * dt) * rsub_fac
csub ( 30 gnode ) capacitor c=(1.65e-13 / ((1.872 / nr + 0.2225) * (30 / (w * 1e6)) 
+ * (1 / ((1 / (315 * w / 6 / ((l + 0.45u) * nr + 0.15u) + 554 * 3u / ((l + 0.45u) 
+ * nr + 0.15u))) + 1 / ((315 * w / 6 / ((l + 0.45u) * nr + 0.15u)) + 554 * 3u / 
+ ((l + 0.45u) * nr + 0.15u)) + 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 
+ 554 * 3u / w) + 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 554 * 3u / w)))) 
+ * (1 + 2.95e-3 * dt + 8.42e-6 * dt * dt)) * csub_fac
ends xjvar_nw
 
subckt xjvar ( anode cathode gnode ) 
parameters l=0.3u w=15u nr=1 nconp=int((w - 0.28u) / 0.23u + 0.1m) + 1 nconn=int((w 
+ - 0.2u) / 0.2u + 0.1m) + 1 nstrip=int(abs(l - 0.27u) / 0.23u + 0.1m) + 1 area_d1=nr 
+ * l * w peri_d1=2 * nr * (l + w) area_d2=((l + 0.45u) * nr + 2.39u) * (w + 2.24u) 
+ peri_d2=2 * (((l + 0.45u) * nr + 2.39u) + (w + 2.82u)) m1_s_sd=l + 0.45u rr_pnsd=(0.188 
+ * m1_s_sd / 1u) * (0.163 * m1_s_sd / 3u) / ((0.188 * m1_s_sd / 1u) + (0.163 * 
+ m1_s_sd / 3u)) r_1str_p=(1.5416 + ((nconp - 1) * (2 * nconp - 1) / 6 / nconp * 
+ 0.2162) + 30 / nconp) / nstrip r_1str_n=(1.504 + ((nconn - 1) * (2 * nconn - 1) 
+ / 6 / nconn * 0.188) + 30 / nconn) dt=temp - 25 
rpsd ( anode 1 ) resistor r=( - 0.4498 * (l * 1e6) + 1.0484) * (1 - (w * 1e6) / 
+ 10 * 0.02) * ((rr_pnsd / 2 + ((nr / 2 - 1) * (nr - 1) / 3 / nr * rr_pnsd) + r_1str_p 
+ / nr * 2) / 2) * (1 + 2.69e-3 * dt - 3e-7 * dt * dt) * rm_fac
l1 ( 1 2 ) inductor l=(0.0105 * w * 1e6 + 0.3755) * (w * 1e6 / 40) * (1.27e-11 * 
+ (30 / (w * 1e6)) * (0.7382 * (1 / nr) + 0.2675)) * l_fac
d1 ( 2 3 ) pdio_xj area=area_d1 pj=peri_d1
rwell ( 3 4 ) resistor r=0.64 * (20 / (w * 1e6)) * (1.8526 * (l * 1e6) * (l * 1e6) 
+ - 3.2111 * (l * 1e6) + 2.3984) * ( - 0.086 * nr + 7.9461) * ((554 * 0.15u / w 
+ + 315 * (l + 0.15u) / 2 / w) / 2 / nr) * (1 + 10.95e-3 * dt + 8.42e-6 * dt * dt) 
+ * rwell_fac
l2 ( 4 5 ) inductor l=(0.0105 * w * 1e6 + 0.3755) * (w * 1e6 / 40) * (1.27e-11 * 
+ (30 / (w * 1e6)) * (0.7382 * (1 / nr) + 0.2675)) * l_fac
rnsd ( 5 cathode ) resistor r=( - 0.4498 * (l * 1e6) + 1.0484) * (1 - (w * 1e6) 
+ / 10 * 0.02) * ((rr_pnsd / 2 + (((nr + 1) / 2 - 1) * (nr + 1 - 1) / 3 / (nr + 
+ 1) * rr_pnsd) + r_1str_n / (nr + 1) * 2) / 2) * (1 + 2.69e-3 * dt - 3e-7 * dt 
+ * dt) * rm_fac
csti ( 2 4 ) capacitor c=0.225 * w * nr * 1e-9 * (l * 1e6 + 0.02) / (l * 1e6)
d2 ( 30 3 ) dnwpsub_xj area=area_d2 pj=peri_d2
rsub ( 30 gnode ) resistor r=(1.872 / nr + 0.2225) * (30 / (w * 1e6)) * (1 / ((1 
+ / (315 * w / 6 / ((l + 0.45u) * nr + 0.15u) + 554 * 3u / ((l + 0.45u) * nr + 0.15u))) 
+ + 1 / ((315 * w / 6 / ((l + 0.45u) * nr + 0.15u)) + 554 * 3u / ((l + 0.45u) * 
+ nr + 0.15u)) + 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 554 * 3u / w) + 
+ 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 554 * 3u / w))) * (1 + 2.95e-3 
+ * dt + 8.42e-6 * dt * dt) * rsub_fac
csub ( 30 gnode ) capacitor c=(1.65e-13 / ((1.872 / nr + 0.2225) * (30 / (w * 1e6)) 
+ * (1 / ((1 / (315 * w / 6 / ((l + 0.45u) * nr + 0.15u) + 554 * 3u / ((l + 0.45u) 
+ * nr + 0.15u))) + 1 / ((315 * w / 6 / ((l + 0.45u) * nr + 0.15u)) + 554 * 3u / 
+ ((l + 0.45u) * nr + 0.15u)) + 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 
+ 554 * 3u / w) + 1 / (315 * ((l + 0.45u) * nr + 0.15u) / 6 / w + 554 * 3u / w)))) 
+ * (1 + 2.95e-3 * dt + 8.42e-6 * dt * dt)) * csub_fac
ends xjvar
 
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_pdio_xj
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_nwpsub_xj
include "crn65gplus_2d5_lk_v1d0.scs" section=dio_dnwpsub_xj
 
endsection rf_jvar
 
 
 

section dio_pdio_xj
model pdio_xj diode 
+ level=1                   is=1.73e-07               rs=1.0e-10
+ n=1.02                    bv=9.59                   ibv=0.03
+ isw=1.86e-13              cj=1.06e-03*cj_fac        pj=7.2e-4
+ mj=0.31                   fc=0                      cjsw=6.4e-11*cjsw_fac
+ area=3.08e-8              mjsw=0.063                tlevc=1
+ cta=8.5e-04               ctp=2.0e-04               trs=2.5e-3
+ tbv1=-1*-7.9e-04          tlev=1                    xti=3
+ eg=1.17                   vjsw=0.96                 vj=0.7
+ pta=1.55e-3               tnom=25                   ptp=1.5e-03
+ ns=1.02                   nz=1.02                   imax=1e40
+ minr=1e-10                allow_scaling=1
 
endsection dio_pdio_xj
 
 

section dio_dnwpsub_xj
model dnwpsub_xj diode 
+ is=2.44e-6                isw=5.88e-12              rs=1.0e-10
+ n=1.005                   cj=1.15e-04*cj_fac        cjsw=1.39e-9*cjsw_fac
+ bv=11.8                   area=3.1161e-8            pj=7.24e-4
+ mj=0.315                  mjsw=0.265                vj=0.56
+ vjsw=0.45                 trs=2.5e-3                tbv1=-1*-8.500e-04
+ cta=2.20e-3               ctp=1.29e-03              pta=2.95e-3
+ ptp=1.7e-03               ibv=0.03                  tnom=25
+ fc=0                      tlev=1                    tlevc=1
+ xti=3                     eg=1.17                   level=1
+ ns=1.005                  nz=1.005                  imax=1e40
+ minr=1e-10                allow_scaling=1
endsection dio_dnwpsub_xj
 
 

section dio_nwpsub_xj
model nwpsub_xj diode 
+ is=2.49e-6                isw=8.22e-13
+ rs=1.0e-10                n=1.005                   cj=1.388e-04*cj_fac
+ cjsw=7.49e-10*cjsw_fac    bv=11.8                   area=3.1161e-8
+ pj=7.24e-4                mj=0.325                  mjsw=0.31
+ vj=0.5                    vjsw=0.5                  trs=2.5e-3
+ tbv1=-1*-9.000e-04        cta=2.16e-3               ctp=1.3e-03
+ pta=2.60e-3               ptp=1.6e-03               ibv=0.03
+ tnom=25                   fc=0                      tlev=1
+ tlevc=1                   xti=3                     eg=1.17
+ level=1                   ns=1.005                  nz=1.005
+ imax=1e40                 minr=1e-10                allow_scaling=1
endsection dio_nwpsub_xj


//  ******************************************************
//  *************    RES Corner Parameters  **************
//  ******************************************************

section mc_rfres_sa
parameters par_rfres_sa=0
parameters a1_rfres_sal=par1_res * 3.4218e+000 * 3 / 3.1
parameters a2_rfres_sal=par2_res * 5.3941e-001 * 3 / 3.1
parameters rppolylrf=14.81890631 + (1.3027e+000) * a1_rfres_sal + ( - 7.8588e-001) 
+ * a2_rfres_sal
parameters rppolysrf=14.81890631 + (1.6180e+000) * a1_rfres_sal + ( - 1.0884e+000) 
+ * a2_rfres_sal
parameters dxw_rppolysrf=0.0000e+000 + (4.2404e-009) * a1_rfres_sal + (5.7744e-009) 
+ * a2_rfres_sal
parameters sal_fac=1
parameters sarsub_fac=1
parameters sacsub_fac=1
parameters ca_pofoxrf=10.77e-17
parameters cf_polfoxrf=5.51e-17
parameters cf_posfoxrf=4.28e-17
 
 
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_res_sa
endsection mc_rfres_sa


section tt_rfres_sa
parameters par_rfres_sa=0
parameters rppolylrf=14.81890631
parameters rppolysrf=14.81890631
parameters sal_fac=1
parameters sarsub_fac=1
parameters sacsub_fac=1
parameters dxw_rppolysrf=0
parameters ca_pofoxrf=10.77e-17
parameters cf_polfoxrf=5.51e-17
parameters cf_posfoxrf=4.28e-17
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_res_sa
endsection tt_rfres_sa


section ff_rfres_sa
parameters par_rfres_sa=0
parameters rppolylrf=14.81890631 * 0.70
parameters rppolysrf=14.81890631 * 0.63
parameters sal_fac=0.9762
parameters sarsub_fac=0.8
parameters sacsub_fac=1.25
parameters dxw_rppolysrf=0 - 0.0197u
parameters ca_pofoxrf=9.91e-17
parameters cf_polfoxrf=5.35e-17
parameters cf_posfoxrf=4.09e-17
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_res_sa
endsection ff_rfres_sa


section ss_rfres_sa
parameters par_rfres_sa=0
parameters rppolylrf=14.81890631 * 1.30
parameters rppolysrf=14.81890631 * 1.38
parameters sal_fac=1.0235
parameters sarsub_fac=1.2
parameters sacsub_fac=0.833
parameters dxw_rppolysrf=0 + 0.006u
parameters ca_pofoxrf=11.84e-17
parameters cf_polfoxrf=5.74e-17
parameters cf_posfoxrf=4.56e-17
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_res_sa
endsection ss_rfres_sa

section mc_rfres_rpo
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_rfresrpo
parameters par_rfres_rpo=0
parameters a1_rfres_rpo=par3_res * 3.4546e+000 * 3 / 3.2
parameters rppolyworf=756.206475 + (2.4734e+001) * a1_rfres_rpo
parameters rend_rppolyworf=6.34e-07 + (1.5035e-007) * a1_rfres_rpo
parameters rpol_fac=1
parameters rporsub_fac=1
parameters rpocsub_fac=1
parameters dxw_rppolyworf=0.0000e+000 + (3.6342e-009) * a1_rfres_rpo
parameters dxl_rppolyworf=0.0000e+000
parameters ca_pofoxrf_rpo=10.77e-17
parameters cf_polfoxrf_rpo=5.51e-17
parameters cf_posfoxrf_rpo=4.28e-17
parameters b1_rfresrpo=-1.75e-23
parameters a1_rfresrpo=4.25e-23
parameters c1_rfresrpo=7.5e-23
parameters kf_rppolywo_rf=a1_rfresrpo * (abs(rnoiseflag_rfresrpo) + rnoiseflag_rfresrpo) 
+ + b1_rfresrpo * (abs(rnoiseflag_rfresrpo) - rnoiseflag_rfresrpo) + c1_rfresrpo
include "crn65gplus_2d5_lk_v1d0.scs" section=rf_res_rpo
endsection mc_rfres_rpo



//  ******************************************************
section tt_rfres_rpo
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_rfresrpo
parameters par_rfres_rpo=0
parameters rppolyworf=756.206475
parameters rend_rppolyworf=6.34e-07
parameters rpol_fac=1
parameters rporsub_fac=1
parameters rpocsub_fac=1
parameters dxl_rppolyworf=0
parameters dxw_rppolyworf=0
parameters ca_pofoxrf_rpo=10.77e-17
parameters cf_polfoxrf_rpo=5.51e-17
parameters cf_posfoxrf_rpo=4.28e-17
parameters b1_rfresrpo=-1.75e-23
parameters a1_rfresrpo=4.25e-23
parameters c1_rfresrpo=7.5e-23
parameters kf_rppolywo_rf=a1_rfresrpo * (abs(rnoiseflag_rfresrpo) + rnoiseflag_rfresrpo) + b1_rfresrpo * (abs(rnoiseflag_rfresrpo) - rnoiseflag_rfresrpo) + c1_rfresrpo

include "crn65gplus_2d5_lk_v1d0.scs" section=rf_res_rpo
endsection tt_rfres_rpo


section ff_rfres_rpo
include "crn65gplus_2d5_lk_v1d0.scs" section=noiseflag_rfresrpo
parameters par_rfres_rpo=0
parameters rppolyworf=756.206475 * 0.83
parameters rend_rppolyworf=6.34e-07 * 0.50
parameters rpol_fac=0.9762
parameters rporsub_fac=0.8
parameters rpocsub_fac=1.25
parameters dxl_rppolyworf=0.0u + 0.0u
parameters dxw_rppolyworf=0 - 0.086u
parameters ca_pofoxrf_rpo=9.91e-17
parameters cf_polfoxrf_rpo=5.35e-17
parameters cf_posfoxrf_rpo=4.09e-17
parameters b1_rfresrpo=-1.75e-23

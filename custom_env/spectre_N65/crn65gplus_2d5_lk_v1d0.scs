+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.286533
+ lkt1=-5.8704888e-10+dlkt1p_hvt                      wkt1=-1.4988289e-009
+ pkt1=8.3112225e-17+dpkt1p_hvt                       kt1l=0
+ kt2=-0.051015683          lkt2=-1.7052037e-10+dlkt2p_hvt
+ wkt2=-1.0862696e-008      pkt2=4.6151949e-16+dpkt2p_hvt
+ ute=-1                    ua1=1.1825993e-010+dua1p_hvt
+ lua1=4.0312851e-017+dlua1p_hvt                      wua1=1.0243534e-015
+ pua1=-4.4081741e-023      ub1=1.5686513e-019+dub1p_hvt
+ lub1=-5.285227e-026+dlub1p_hvt                      wub1=-1.3443224e-024
+ pub1=5.7578403e-032       uc1=-4.1603921e-011+duc1p_hvt
+ luc1=9.9501207e-019+dluc1p_hvt                      wuc1=9.8801505e-019
+ puc1=-6.1292744e-025      prt=0                     at=108767.21+datp_hvt
+ lat=-0.0030732018         wat=-0.023049028          pat=6.1292744e-010
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt lvsat=0+dlvsatp_hvt+0.00038801*ss_flag_hvt+2.49435e-05*ff_flag_hvt+1.99548e-05*sf_flag_hvt-1.99548e-05*fs_flag_hvt
+ wvsat=0+dwvsatp_hvt+0.00149562*ss_flag_hvt+0.000897375*ff_flag_hvt+0.000717899*sf_flag_hvt-0.000717899*fs_flag_hvt
+ pvsat=0+dpvsatp_hvt-1.22611e-10*ss_flag_hvt-7.35667e-11*ff_flag_hvt-5.88533e-11*sf_flag_hvt+5.88533e-11*fs_flag_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_hvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_hvt            rnoib=0
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     21: type=p 
+ lmin=1e-005-(dxlp_hvt+dlmisp_hvt)                   lmax=2.00001e-05
+ wmin=1.2e-07              wmax=3e-007-(dxwp_hvt+dwmisp_hvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_hvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_hvt+toxmisp_hvt)
+ toxm=2.2e-009             dtox=3.219e-010           epsrox=3.9
+ wint=0                    lint=2.134663e-08         ll=0
+ wl=0                      lln=0                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_hvt+dlmisp_hvt)                  xw=1.6e-08+(dxwp_hvt+dwmisp_hvt)
+ dlc=2.134663e-08+ddlcp_hvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+(dvthp_hvt+vthmisp_hvt)                k1=0.40676
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           k2=-0.020685535+dk2p_hvt  wk2=1.5244955e-009+dwk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0006+dcitp_hvt      voff=-0.14038708+dvoffp_hvt
+ wvoff=5.8232886e-010+dwvoffp_hvt                    nfactor=0.7+dnfactorp_hvt
+ eta0=0.139774+deta0p_hvt  weta0=4.2976e-011+dweta0p_hvt
+ etab=-0.12764667          wetab=-2.3994933e-009     u0=0.010051232+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           wu0=-3.1515733e-014+dwu0p_hvt
+ ua=-1.0306667e-010        wua=-1.8622933e-017       ub=1.2223537e-018
+ pub=0+dpubp_hvt           lub=0+dlubp_hvt           wub=-1.0595687e-025
+ uc=2.3872368e-010         wuc=-3.0290421e-017       vsat=75000+dvsatp_hvt
+ a0=3.4637509+da0p_hvt     kvsat=0.5                 wa0=1.3603388e-007+dwa0p_hvt
+ ags=0.9456438+dagsp_hvt   wags=-2.2393753e-008+dwagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.082977778          wketa=9.5502222e-010
+ dwg=0                     dwb=0                     pclm=1.7880578+dpclmp_hvt
+ pdiblc1=0                 pdiblc2=0.001             pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.2337907
+ pkt1=0+dpkt1p_hvt         lkt1=0+dlkt1p_hvt         wkt1=1.7793026e-009
+ kt1l=0                    kt2=-0.000584             pkt2=0+dpkt2p_hvt
+ lkt2=0+dlkt2p_hvt         wkt2=-4.555456e-009       ute=-1
+ ua1=5.0606443e-009+dua1p_hvt                        wua1=-1.297636e-016
+ ub1=-6.3777778e-018+dub1p_hvt                       wub1=1.1937778e-025
+ uc1=-4e-011+duc1p_hvt     prt=0                     at=150000+datp_hvt
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt
+ pvth0=0+dpvthp_hvt        lk2=0+dlk2p_hvt           pk2=0+dpk2p_hvt
+ lcit=0+dlcitp_hvt         wcit=0+dwcitp_hvt         pcit=0+dpcitp_hvt
+ lvoff=0+dlvoffp_hvt       pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt
+ peta0=0+dpeta0p_hvt       lu0=0+dlu0p_hvt           pu0=0+dpu0p_hvt
+ lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt
+ la0=0+dla0p_hvt           pa0=0+dpa0p_hvt           lags=0+dlagsp_hvt
+ pags=0+dpagsp_hvt         lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       lub1=0+dlub1p_hvt         lua1=0+dlua1p_hvt
+ luc1=0+dluc1p_hvt         wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0090             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-1.8e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap_hvt
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp_hvt
+ rnoib=0                   noic=noicp_hvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     22: type=p 
+ lmin=1.000003e-006-(dxlp_hvt+dlmisp_hvt)            lmax=1e-005-(dxlp_hvt+dlmisp_hvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_hvt+dwmisp_hvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_hvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_hvt+toxmisp_hvt)
+ toxm=2.2e-009             dtox=3.219e-010           epsrox=3.9
+ wint=0                    lint=2.134663e-08         ll=0
+ wl=0                      lln=0                     wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0                     wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_hvt+dlmisp_hvt)                  xw=1.6e-08+(dxwp_hvt+dwmisp_hvt)
+ dlc=2.134663e-08+ddlcp_hvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+(dvthp_hvt+vthmisp_hvt)                k1=0.40676
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           k2=-0.019457299+dk2p_hvt  lk2=-1.2216545e-008+dlk2p_hvt
+ wk2=1.3846962e-009+dwk2p_hvt                        pk2=1.3905014e-015+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0005712011+dcitp_hvt                          lcit=2.8644571e-010+dlcitp_hvt
+ wcit=3.9166511e-012+dwcitp_hvt                      pcit=-3.8956618e-017+dpcitp_hvt
+ voff=-0.14007841+dvoffp_hvt                         lvoff=-3.0701237e-009+dlvoffp_hvt
+ wvoff=3.8172926e-010+dwvoffp_hvt                    pvoff=1.9952459e-015+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.139774+deta0p_hvt  weta0=4.2976e-011+dweta0p_hvt
+ etab=-0.12764667          wetab=-2.3994933e-009     u0=0.0099651365+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           lu0=8.5633865e-010+dlu0p_hvt
+ wu0=3.3858765e-011+dwu0p_hvt                        pu0=-3.3708663e-016+dpu0p_hvt
+ ua=-1.1784648e-010        lua=1.4700607e-016        wua=-1.4038644e-017
+ pua=-4.5597224e-023       ub=1.1761782e-018         lub=4.5928126e-25+dlubp_hvt
+ wub=-1.0441238e-025       pub=-1.5362124e-32+dpubp_hvt
+ uc=2.6555417e-010         luc=-2.6686702e-016       wuc=-3.2822777e-017
+ puc=2.5187851e-023        vsat=75000+dvsatp_hvt     a0=3.5342392+da0p_hvt
+ kvsat=0.5                 la0=-7.0110538e-007+dla0p_hvt
+ wa0=1.5167497e-007+dwa0p_hvt                        pa0=-1.5557278e-013+dpa0p_hvt
+ ags=0.89617453+dagsp_hvt  lags=4.9204168e-007+dlagsp_hvt
+ wags=-1.9472497e-008+dwagsp_hvt                     pags=-2.9056013e-014+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.095250729          lketa=-1.2207181e-007
+ wketa=9.6616415e-013      pketa=9.4894327e-015      dwg=0
+ dwb=0                     pclm=1.7880578+dpclmp_hvt pdiblc1=0
+ pdiblc2=0.00089484333     lpdiblc2=1.0459313e-009   pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.23508315
+ lkt1=1.2855233e-08+dlkt1p_hvt                       wkt1=2.248859e-009
+ pkt1=-4.6703999e-15+dpkt1p_hvt                      kt1l=0
+ kt2=0.0059344992          lkt2=-6.4835665e-08+dlkt2p_hvt
+ wkt2=-5.2715003e-009      pkt2=7.1220703e-15+dpkt2p_hvt
+ ute=-1                    ua1=5.0690077e-009+dua1p_hvt
+ lua1=-8.3186246e-017+dlua1p_hvt                     wua1=-1.1579169e-016
+ pua1=-1.3897029e-022      ub1=-6.3553576e-018+dub1p_hvt
+ lub1=-2.2300004e-025+dlub1p_hvt                     wub1=9.3012452e-026
+ pub1=2.6224034e-031       uc1=-4e-011+duc1p_hvt     prt=0
+ at=149205.48+datp_hvt     lat=0.0079025922          wat=0.00025106738
+ pat=-2.4972191e-009       jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_hvt
+ wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt        lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt
+ peta0=0+dpeta0p_hvt       lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt
+ pvsat=0+dpvsatp_hvt       lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       luc1=0+dluc1p_hvt         wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0090             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-1.8e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap_hvt            rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp_hvt            rnoib=0                   noic=noicp_hvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     23: type=p 
+ lmin=2.39995e-007-(dxlp_hvt+dlmisp_hvt)             lmax=1.000003e-006-(dxlp_hvt+dlmisp_hvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_hvt+dwmisp_hvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_hvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_hvt+toxmisp_hvt)
+ toxm=2.2e-009             dtox=3.219e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_hvt+dlmisp_hvt)                  xw=1.6e-08+(dxwp_hvt+dwmisp_hvt)
+ dlc=1.25625e-09+ddlcp_hvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.3981+(dvthp_hvt+vthmisp_hvt)
+ k1=0.40676                kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0.0e-8             lkvth0=-4.33e-8           k2=-0.033900783+dk2p_hvt
+ lk2=1.4529128e-009+dlk2p_hvt                        wk2=2.9514534e-009+dwk2p_hvt
+ pk2=-9.2293339e-017+dpk2p_hvt                       k3=-2.86346
+ k3b=3.10778               w0=0                      dvt0=1.0197
+ dvt1=1.1537658            dvt2=0.02                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.515
+ minv=0                    voffl=0                   dvtp0=5.65227e-009
+ dvtp1=0.3                 lpe0=1.35409e-008         lpeb=0
+ xj=1.1e-007               ngate=2.0207e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0005044782+dcitp_hvt
+ lcit=3.4959293e-010+dlcitp_hvt                      wcit=-2.0302145e-011+dwcitp_hvt
+ pcit=-1.6035707e-017+dpcitp_hvt                     voff=-0.14490406+dvoffp_hvt
+ lvoff=1.4969205e-009+dlvoffp_hvt                    wvoff=2.450916e-009+dwvoffp_hvt
+ pvoff=3.6946869e-017+dpvoffp_hvt                    nfactor=0.7+dnfactorp_hvt
+ eta0=0.139774+deta0p_hvt  weta0=4.2976e-011+dweta0p_hvt
+ etab=-0.12764667          wetab=-2.3994933e-009     u0=0.011346841+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           lu0=-4.5132031e-010+dlu0p_hvt
+ wu0=-3.4699769e-010+dwu0p_hvt                       pu0=2.3359736e-017+dpu0p_hvt
+ ua=9.5820822e-012         lua=2.6406402e-017        wua=-4.7472827e-017
+ pua=-1.3954779e-023       ub=1.9538877e-018         lub=-2.7675082e-25+dlubp_hvt
+ wub=-1.577096e-025        pub=3.5078903e-32+dpubp_hvt
+ uc=5.5721561e-012         luc=-2.0817447e-017       wuc=-9.2001628e-018
+ puc=2.8311727e-024        vsat=75000+dvsatp_hvt     a0=2.9702579+da0p_hvt
+ kvsat=0.5                 la0=-1.6734779e-007+dla0p_hvt
+ wa0=-1.4610723e-008+dwa0p_hvt                       pa0=1.8016705e-015+dpa0p_hvt
+ ags=1.0276093+dagsp_hvt   lags=3.6765046e-007+dlagsp_hvt
+ wags=4.4236271e-009+dwagsp_hvt                      pags=-5.1671544e-014+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.022541435         lketa=-1.0592125e-008
+ wketa=1.1438241e-008      pketa=-1.3349183e-015     dwg=0
+ dwb=0                     pclm=1.7880578+dpclmp_hvt pdiblc1=0
+ pdiblc2=0.002             pdiblcb=0                 drout=0.5
+ pvag=2.7713               delta=0.018               pscbe1=4.632e+008
+ pscbe2=5e-016             fprout=0                  pdits=1
+ pditsd=3                  pditsl=1300000            rsh=15.5
+ rsw=203+drdswp_hvt        rdw=203+drdswp_hvt        prwg=0
+ prwb=0                    wr=1                      alpha0=7.45e-009
+ alpha1=0                  beta0=12.21               agidl=1e-008
+ bgidl=2.17018e+009        cgidl=0.154               aigbacc=0.0125
+ bigbacc=0.004             cigbacc=0                 nigbacc=1
+ aigbinv=0.01134           bigbinv=0.003             cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0062447
+ bigc=0.000459788          cigc=-0.033313            aigsd=0.0047986
+ bigsd=0.00061108          cigsd=0.14                nigc=1
+ poxedge=1                 pigcd=3.0117              ntox=ntoxp_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_hvt
+ cgdo=cgop_hvt             cgbo=0                    cgdl=cglp_hvt
+ cgsl=cglp_hvt             clc=1e-007                cle=0.6
+ cf=cfp_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.3898
+ voffcv=-0.084627          kt1=-0.21812136           lkt1=-3.1975792e-09+dlkt1p_hvt
+ wkt1=-2.4701924e-009      pkt1=-2.0424251e-16+dpkt1p_hvt
+ kt1l=0                    kt2=-0.059863521          lkt2=-2.5637612e-09+dlkt2p_hvt
+ wkt2=2.1968414e-009       pkt2=5.3957045e-17+dpkt2p_hvt
+ ute=-1                    ua1=6.157081e-009+dua1p_hvt
+ lua1=-1.1129496e-015+dlua1p_hvt                     wua1=-3.4020902e-016
+ pua1=7.3420509e-023       ub1=-8.2409158e-018+dub1p_hvt
+ lub1=1.561511e-024+dlub1p_hvt                       wub1=4.7519396e-025
+ pub1=-9.9460058e-032      uc1=-3.8831579e-011+duc1p_hvt
+ luc1=-1.1058054e-018+dluc1p_hvt                     wuc1=5.6420297e-019
+ puc1=-5.3396734e-025      prt=0                     at=165668.86+datp_hvt
+ lat=-0.0076785139         wat=-0.0019644033         pat=-4.004755e-010
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt
+ pvth0=0+dpvthp_hvt        lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt       peta0=0+dpeta0p_hvt
+ lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt
+ lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt       ppclm=0+dppclmp_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_hvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_hvt            rnoib=0
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     24: type=p 
+ lmin=9.99969e-008-(dxlp_hvt+dlmisp_hvt)             lmax=2.39995e-007-(dxlp_hvt+dlmisp_hvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_hvt+dwmisp_hvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_hvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_hvt+toxmisp_hvt)
+ toxm=2.2e-009             dtox=3.219e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_hvt+dlmisp_hvt)                  xw=1.6e-08+(dxwp_hvt+dwmisp_hvt)
+ dlc=1.25625e-09+ddlcp_hvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.40360767+(dvthp_hvt+vthmisp_hvt)
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           lvth0=1.18861e-009+dlvthp_hvt
+ wvth0=1.7404233e-009+dwvthp_hvt                     pvth0=-3.7560075e-016+dpvthp_hvt
+ k1=0.40676                k2=-0.023568822+dk2p_hvt  lk2=-7.7682755e-010+dlk2p_hvt
+ wk2=1.9194553e-009+dwk2p_hvt                        pk2=1.3042217e-016+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0010091009+dcitp_hvt                          lcit=2.406903e-010+dlcitp_hvt
+ wcit=-2.7580774e-011+dwcitp_hvt                     pcit=-1.4464906e-017+dpcitp_hvt
+ voff=-0.14859873+dvoffp_hvt                         lvoff=2.2942669e-009+dlvoffp_hvt
+ wvoff=5.9423857e-009+dwvoffp_hvt                    pvoff=-7.1654721e-016+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.13977369+deta0p_hvt
+ leta0=6.7424091e-014+dleta0p_hvt                    weta0=4.3351727e-011+dweta0p_hvt
+ peta0=-8.1085573e-020+dpeta0p_hvt                   etab=-0.12765089
+ letab=9.1069967e-013      wetab=-2.3991277e-009     petab=-7.890772e-020
+ u0=0.0091629897+du0p_hvt  ku0=-0.5354e-9            pku0=-0.5e-16
+ wku0=0                    lku0=-4.0055e-8           lu0=1.9976638e-011+dlu0p_hvt
+ wu0=-2.0950474e-010+dwu0p_hvt                       pu0=-6.3126176e-018+dpu0p_hvt
+ ua=2.5662541e-010         lua=-2.690802e-017        wua=-1.2614149e-016
+ pua=3.0227056e-024        ub=6.532009e-019          lub=3.9503934e-27+dlubp_hvt
+ wub=2.9678096e-026        pub=-5.361237e-33+dpubp_hvt
+ uc=-1.9651561e-011        luc=-1.5373916e-017       wuc=-2.8059195e-018
+ puc=1.4512311e-024        vsat=75000+dvsatp_hvt     a0=1.8874006+da0p_hvt
+ kvsat=0.5                 la0=6.6343634e-008+dla0p_hvt
+ wa0=-9.785084e-008+dwa0p_hvt                        pa0=1.976572e-014+dpa0p_hvt
+ ags=3.3273066+dagsp_hvt   lags=-1.286472e-007+dlagsp_hvt
+ wags=-2.9029844e-007+dwagsp_hvt                     pags=1.1932425e-014+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.19892931          lketa=2.7474143e-008
+ wketa=2.4188793e-008      pketa=-4.086615e-015      dwg=0
+ dwb=0                     pclm=1.903256+dpclmp_hvt  lpclm=-2.4860929e-008+dlpclmp_hvt
+ pdiblc1=0                 pdiblc2=-0.00030053384    lpdiblc2=4.9647821e-010
+ wpdiblc2=1.4625406e-010   ppdiblc2=-3.1563088e-017  pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.18746924
+ lkt1=-9.8126126e-09+dlkt1p_hvt                      wkt1=-7.8198981e-009
+ pkt1=9.502775e-16+dpkt1p_hvt                        kt1l=0
+ kt2=-0.07160475           lkt2=-2.9886666e-11+dlkt2p_hvt
+ wkt2=3.4979318e-009       pkt2=-2.2683129e-16+dpkt2p_hvt
+ ute=-1                    ua1=-1.4414124e-010+dua1p_hvt
+ lua1=2.4691712e-016+dlua1p_hvt                      wua1=1.3894135e-016
+ pua1=-2.9984934e-023      ub1=4.7086615e-019+dub1p_hvt
+ lub1=-3.1857861e-025+dlub1p_hvt                     wub1=-1.5029823e-025
+ pub1=3.5527412e-032       uc1=-5.0435166e-011+duc1p_hvt
+ luc1=1.3983647e-018+dluc1p_hvt                      wuc1=1.3751235e-019
+ puc1=-4.4188323e-025      prt=0                     at=192598.07+datp_hvt
+ lat=-0.013490106          wat=-0.0049901213         pat=2.525047e-010
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt
+ pvsat=0+dpvsatp_hvt       wpclm=0+dwpclmp_hvt       ppclm=0+dppclmp_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_hvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_hvt            rnoib=0
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     25: type=p 
+ lmin=6e-08                lmax=9.99969e-008-(dxlp_hvt+dlmisp_hvt)
+ wmin=1.2e-07              wmax=3e-007-(dxwp_hvt+dwmisp_hvt)
+ version=4.5               gbmin=1.00e-12            rbsb=50
+ ud=0                      rbdb=50                   rgeomod=1
+ rbpb=50                   rshg=15.882               rbps=50
+ rbpd=50                   ngcon=1                   binunit=2
+ paramchk=1                mobmod=0                  capmod=2
+ igcmod=1                  igbmod=1                  diomod=1
+ rdsmod=1                  rbodymod=0                rgatemod=1*rgflag_hvt
+ permod=1                  acnqsmod=0                trnqsmod=0
+ tempmod=0                 tnom=25                   toxe=(toxp_hvt+toxmisp_hvt)
+ toxm=2.2e-009             dtox=3.219e-010           epsrox=3.9
+ wint=0                    lint=1.25625e-09          ll=0.0050965
+ wl=0                      lln=-0.9                  wln=1
+ lw=0                      ww=0                      lwn=1
+ wwn=1                     lwl=0                     wwl=0
+ llc=0.0050965             wlc=0                     lwc=0
+ wwc=0                     lwlc=0                    wwlc=0
+ xl=-1.09e-08+(dxlp_hvt+dlmisp_hvt)                  xw=1.6e-08+(dxwp_hvt+dwmisp_hvt)
+ dlc=1.25625e-09+ddlcp_hvt dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=-0.35570327+(dvthp_hvt+vthmisp_hvt)+0.00708155*ss_flag_hvt
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           lvth0=-2.7385923e-009+dlvthp_hvt-5.80545e-10*ss_flag_hvt
+ wvth0=-6.1150131e-009+dwvthp_hvt-9.63091e-10*ss_flag_hvt
+ pvth0=2.6838792e-016+dpvthp_hvt+7.89542e-17*ss_flag_hvt
+ k1=0.40676                k2=-0.031587197+dk2p_hvt  lk2=-1.1948117e-010+dlk2p_hvt
+ wk2=4.8636056e-009+dwk2p_hvt                        pk2=-1.1093927e-016+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0019172496+dcitp_hvt-0.000708155*ff_flag_hvt-0.000566524*sf_flag_hvt+0.000566524*fs_flag_hvt
+ lcit=1.6624027e-010+dlcitp_hvt+5.80545e-11*ff_flag_hvt+4.64436e-11*sf_flag_hvt-4.64436e-11*fs_flag_hvt
+ wcit=-4.9585779e-010+dwcitp_hvt+2.20135e-10*ff_flag_hvt+1.76108e-10*sf_flag_hvt-1.76108e-10*fs_flag_hvt
+ pcit=2.3924444e-017+dpcitp_hvt-1.80467e-17*ff_flag_hvt-1.44373e-17*sf_flag_hvt+1.44373e-17*fs_flag_hvt
+ voff=-0.069444337+dvoffp_hvt+0.00242796*ff_flag_hvt+0.00194237*sf_flag_hvt-0.00194237*fs_flag_hvt
+ lvoff=-4.1948102e-009+dlvoffp_hvt-1.99044e-10*ff_flag_hvt-1.59235e-10*sf_flag_hvt+1.59235e-10*fs_flag_hvt
+ wvoff=-1.109165e-008+dwvoffp_hvt-3.30203e-10*ff_flag_hvt-2.64162e-10*sf_flag_hvt+2.64162e-10*fs_flag_hvt
+ pvoff=6.7990307e-016+dpvoffp_hvt+2.707e-17*ff_flag_hvt+2.1656e-17*sf_flag_hvt-2.1656e-17*fs_flag_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.058770681+deta0p_hvt
+ leta0=6.6406939e-009+dleta0p_hvt                    weta0=4.7707236e-009+dweta0p_hvt
+ peta0=-3.8763103e-016+dpeta0p_hvt                   etab=-0.22946403
+ letab=8.3475518e-009      wetab=-4.9338654e-009     petab=2.0771889e-016
+ u0=0.011572936+du0p_hvt   ku0=-0.5354e-9            pku0=-0.5e-16
+ wku0=0                    lku0=-4.0055e-8           lu0=-1.7759076e-010+dlu0p_hvt
+ wu0=-5.3410665e-010+dwu0p_hvt                       pu0=2.0298246e-017+dpu0p_hvt
+ ua=-8.0832921e-011        lua=7.5681449e-019        wua=-7.328191e-017
+ pua=-1.3107228e-024       ub=1.5370737e-018-6.78702e-20*ff_flag_hvt-5.42961e-20*sf_flag_hvt+5.42961e-20*fs_flag_hvt
+ lub=-6.8509496e-26+5.56399e-27*ff_flag_hvt+4.45119e-27*sf_flag_hvt-4.45119e-27*fs_flag_hvt+dlubp_hvt
+ wub=-1.5289797e-025+6.87927e-27*ff_flag_hvt+5.50338e-27*sf_flag_hvt-5.50338e-27*fs_flag_hvt
+ pub=9.6063487e-33-5.63958e-34*ff_flag_hvt-4.51167e-34*sf_flag_hvt+4.51167e-34*fs_flag_hvt+dpubp_hvt
+ uc=-2.2018971e-010        luc=1.0662014e-018        wuc=1.9006199e-017
+ puc=-3.3692641e-025       vsat=75000+dvsatp_hvt+3667.55*ff_flag_hvt+2934.04*sf_flag_hvt-2934.04*fs_flag_hvt
+ kvsat=0.5                 a0=-1.1961143+da0p_hvt+0.348315*ff_flag_hvt+0.278652*sf_flag_hvt-0.278652*fs_flag_hvt
+ la0=3.1913018e-007+dla0p_hvt-2.85549e-08*ff_flag_hvt-2.28439e-08*sf_flag_hvt+2.28439e-08*fs_flag_hvt
+ wa0=2.1038044e-007+dwa0p_hvt-1.10068e-07*ff_flag_hvt-8.80541e-08*sf_flag_hvt+8.80541e-08*fs_flag_hvt
+ pa0=-5.5030801e-015+dpa0p_hvt+9.02333e-15*ff_flag_hvt+7.21867e-15*sf_flag_hvt-7.21867e-15*fs_flag_hvt
+ ags=2.168072+dagsp_hvt    lags=-3.3613145e-008+dlagsp_hvt
+ wags=-2.0148722e-007+dwagsp_hvt                     pags=4.6516814e-015+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.20764716           lketa=-5.8569958e-009
+ wketa=-4.5323561e-008     pketa=1.6120078e-015      dwg=0
+ dwb=0                     pclm=1.9660534+dpclmp_hvt lpclm=-3.000906e-008+dlpclmp_hvt
+ wpclm=-6.4375995e-009+dwpclmp_hvt                   ppclm=5.277544e-016+dppclmp_hvt
+ pdiblc1=0                 pdiblc2=0.0064677102      lpdiblc2=-5.8382438e-011
+ wpdiblc2=-4.6379643e-010  ppdiblc2=1.8448851e-017   pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.30942638+0.0174158*ff_flag_hvt-0.0348315*ss_flag_hvt
+ lkt1=1.8543385e-10+dlkt1p_hvt-1.42774e-09*ff_flag_hvt+2.85549e-09*ss_flag_hvt
+ wkt1=5.7354789e-009-5.50338e-09*ff_flag_hvt+1.10068e-08*ss_flag_hvt
+ pkt1=-1.6099232e-16+dpkt1p_hvt+4.51167e-16*ff_flag_hvt-9.02333e-16*ss_flag_hvt
+ kt1l=0                    kt2=-0.10265508           lkt2=2.5156198e-09+dlkt2p_hvt
+ wkt2=5.4553547e-009       pkt2=-3.8730081e-16+dpkt2p_hvt
+ ute=-1                    ua1=4.6000251e-009+dua1p_hvt
+ lua1=-1.4200963e-016+dlua1p_hvt                     wua1=-3.9188443e-016
+ pua1=1.3532164e-023       ub1=-5.5029326e-018+dub1p_hvt
+ lub1=1.7115341e-025+dlub1p_hvt                      wub1=4.4417364e-025
+ pub1=-1.3207392e-032      uc1=-1.3149021e-011+duc1p_hvt
+ luc1=-1.6583535e-018+dluc1p_hvt                     wuc1=-8.0037331e-018
+ puc1=2.2553607e-025       prt=0                     at=53189.557+datp_hvt
+ lat=-0.0020613963         wat=-0.0054864886         pat=2.9319689e-010
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt lvsat=0+dlvsatp_hvt-0.000300666*ff_flag_hvt-0.000240533*sf_flag_hvt+0.000240533*fs_flag_hvt
+ wvsat=0+dwvsatp_hvt-0.00035772*ff_flag_hvt-0.000286175*sf_flag_hvt+0.000286175*fs_flag_hvt
+ pvsat=0+dpvsatp_hvt+2.93258e-11*ff_flag_hvt+2.34607e-11*sf_flag_hvt-2.34607e-11*fs_flag_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap_hvt            rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp_hvt            rnoib=0
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     } 
ends pch_hvt_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                 1.0V HI-VT NMOS DEVICE MODELS              
//                     *
//                                                                            
//                   *
// *********************************************************************************************
model nch_hvt bsim4  { 
     1: type=n 
+ lmin=9.999997e-006-dxln_hvt                         lmax=2.00001e-05
+ wmin=1e-005-dxwn_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.032390531+dk2n_hvt  k3=-5.3535651
+ k3b=2.9186544             w0=0                      dvt0=0.4
+ dvt1=0.94060682           dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=1.5e-008
+ dvtp1=2.8                 lpe0=1.5e-010             lpeb=8e-010
+ xj=1.1e-007               ngate=4.7766e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.001+dcitn_hvt
+ voff=-0.19043345+dvoffn_hvt                         nfactor=0.5+dnfactorn_hvt
+ eta0=0.12+deta0n_hvt      etab=-0.083627            u0=0.028+du0n_hvt
+ ua=-5.2987206e-010        ub=7.0542014e-019         pub=0+dpubn_hvt
+ lub=0+dlubn_hvt           ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               uc=5.5655874e-011
+ vsat=115000+dvsatn_hvt    a0=3.497566+da0n_hvt      kvsat=0.5
+ ags=0.77+dagsn_hvt        a1=0                      a2=0.7
+ b0=0                      b1=0                      keta=0.1
+ dwg=0                     dwb=0                     pclm=0.2+dpclmn_hvt
+ pdiblc1=0                 pdiblc2=0.0005            pdiblcb=0.88134005
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.1846457            kt1l=0                    kt2=-0.042448859
+ pkt2=0+dpkt2n_hvt         lkt2=0+dlkt2n_hvt         lkt1=0+dlkt1n_hvt
+ ute=-1                    ua1=4.35e-009             ub1=-4.899027e-018
+ uc1=2e-010                prt=0                     at=200000
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ pa0=0+dpa0n_hvt           wa0=0+dwa0n_hvt           la0=0+dla0n_hvt
+ pags=0+dpagsn_hvt         wags=0+dwagsn_hvt         lags=0+dlagsn_hvt
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lcit=0+dlcitn_hvt         wcit=0+dwcitn_hvt         pcit=0+dpcitn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       weta0=0+dweta0n_hvt       peta0=0+dpeta0n_hvt
+ lu0=0+dlu0n_hvt           wu0=0+dwu0n_hvt           pu0=0+dpu0n_hvt
+ lk2=0+dlk2n_hvt           wk2=0+dwk2n_hvt           pk2=0+dpk2n_hvt
+ lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt
+ lvoff=0+dlvoffn_hvt       wvoff=0+dwvoffn_hvt       pvoff=0+dpvoffn_hvt
+ lpclm=0+dlpclmn_hvt       wpclm=0+dwpclmn_hvt       ppclm=0+dppclmn_hvt
+ lat=0+dlatn_hvt           pat=0+dpatn_hvt           lub1=0+dlub1n_hvt
+ luc1=0+dluc1n_hvt         pkt1=0+dpkt1n_hvt+dpkt1n_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     2: type=n 
+ lmin=9.999973e-007-dxln_hvt                         lmax=9.999997e-006-dxln_hvt
+ wmin=1e-005-dxwn_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.032164035+dk2n_hvt  lk2=-2.2523286e-009+dlk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00096464298+dcitn_hvt                         lcit=3.5159797e-010+dlcitn_hvt
+ voff=-0.1950409+dvoffn_hvt                          lvoff=4.581754e-008+dlvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.12+deta0n_hvt      etab=-0.083627
+ u0=0.02925896+du0n_hvt    ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-1.2519375e-008+dlu0n_hvt
+ ua=-4.36109e-010          lua=-9.3240041e-016       ub=6.1478009e-019
+ pub=0+dpubn_hvt           lub=9.0134458e-25+dlubn_hvt
+ uc=5.8072727e-011         luc=-2.4033717e-017       vsat=115000+dvsatn_hvt
+ a0=3.6593818+da0n_hvt     kvsat=0.5                 la0=-1.6091318e-006+dla0n_hvt
+ ags=0.70007566+dagsn_hvt  lags=6.9534301e-007+dlagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.1126026            lketa=-1.2532302e-007
+ dwg=0                     dwb=0                     pclm=0.1874104+dpclmn_hvt
+ lpclm=1.2519375e-007+dlpclmn_hvt                    pdiblc1=0
+ pdiblc2=0.00023771667     lpdiblc2=2.6082032e-009   pdiblcb=0.88134005
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.17975975           lkt1=-4.8586868e-08+dlkt1n_hvt
+ kt1l=0                    kt2=-0.040481615          pkt2=0+dpkt2n_hvt
+ lkt2=-1.9562714e-08+dlkt2n_hvt                      ute=-1
+ ua1=4.4372242e-009        lua1=-8.6737688e-016      ub1=-5.0062401e-018
+ lub1=1.0661514e-024+dlub1n_hvt                      uc1=2.188844e-010
+ luc1=-1.8779063e-016+dluc1n_hvt                     prt=0
+ at=200000                 jss=1.203e-07             jsd=1.203e-07
+ jsws=1.666e-13            jswd=1.666e-13            jswgs=1.666e-13
+ jswgd=1.666e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.92                  bvd=8.92
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_hvt               cjd=cjn_hvt
+ mjs=0.34                  mjd=0.34                  pbsws=0.9
+ pbswd=0.9                 cjsws=cjswn_hvt           cjswd=cjswn_hvt
+ mjsws=0.06                mjswd=0.06                pbswgs=1.06
+ pbswgd=1.06               cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt
+ mjswgs=0.78               mjswgd=0.78               tpb=1.55e-03
+ tcj=8.00e-04              tpbsw=1.0e-03             tcjsw=3.0e-04
+ tpbswg=1.30e-03           tcjswg=1.00e-03           xtis=3
+ xtid=3                    jtsswgs=5.4e-006          jtsswgd=5.4e-006
+ njtsswg=14.625            xtsswgs=0.134             xtsswgd=0.134
+ tnjtsswg=0.1              vtsswgs=12.5              vtsswgd=12.5
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             pa0=0+dpa0n_hvt           wa0=0+dwa0n_hvt
+ pags=0+dpagsn_hvt         wags=0+dwagsn_hvt         lvth0=0+dlvthn_hvt
+ wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt        wcit=0+dwcitn_hvt
+ pcit=0+dpcitn_hvt         lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       weta0=0+dweta0n_hvt
+ peta0=0+dpeta0n_hvt       wu0=0+dwu0n_hvt           pu0=0+dpu0n_hvt
+ wk2=0+dwk2n_hvt           pk2=0+dpk2n_hvt           lvsat=0+dlvsatn_hvt
+ wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt       wvoff=0+dwvoffn_hvt
+ pvoff=0+dpvoffn_hvt       wpclm=0+dwpclmn_hvt       ppclm=0+dppclmn_hvt
+ lat=0+dlatn_hvt           pat=0+dpatn_hvt           pkt1=0+dpkt1n_hvt+dpkt1n_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     3: type=n 
+ lmin=2.399969e-007-dxln_hvt                         lmax=9.999973e-007-dxln_hvt
+ wmin=1e-005-dxwn_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=3.259685e-09+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.03697904+dk2n_hvt   lk2=2.2940953e-009+dlk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0012867525+dcitn_hvt                          lcit=4.745575e-011+dlcitn_hvt
+ voff=-0.14425003+dvoffn_hvt                         lvoff=-2.1402157e-009+dlvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.12+deta0n_hvt      etab=-0.083627
+ u0=0.016412848+du0n_hvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-3.8981964e-010+dlu0n_hvt
+ ua=-1.4098786e-009        lua=-1.294765e-017        ub=1.6173488e-018
+ pub=0+dpubn_hvt           lub=-4.5300833e-26+dlubn_hvt
+ uc=3.1894513e-011         luc=6.8427689e-019        vsat=115000+dvsatn_hvt
+ a0=2.0673469+da0n_hvt     kvsat=0.5                 la0=-1.0590062e-007+dla0n_hvt
+ ags=1.4443187+dagsn_hvt   lags=-7.3861977e-009+dlagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.00056104273       lketa=-1.8471647e-008
+ dwg=0                     dwb=0                     pclm=0.24614742+dpclmn_hvt
+ lpclm=6.9733088e-008+dlpclmn_hvt                    pdiblc1=0
+ pdiblc2=0.0026098441      lpdiblc2=3.68393e-010     pdiblcb=0.88134006
+ lpdiblcb=-1.3442057e-014  drout=0.5                 pvag=1
+ delta=0.008               pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rsw=55
+ rdw=55                    prwg=0                    prwb=0
+ wr=1                      alpha0=4.3356e-009        alpha1=0.1571
+ beta0=9.86                agidl=4.96e-008           bgidl=2.2e+009
+ cgidl=0.459               egidl=0.1                 aigbacc=0.013655
+ bigbacc=0.0068735         cigbacc=0.16236           nigbacc=2.35
+ aigbinv=0.335             bigbinv=0.0285            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0099777
+ bigc=1e-005               cigc=-0.1                 aigsd=0.0094155
+ bigsd=0.00056771          cigsd=-0.0038             nigc=1
+ poxedge=1                 pigcd=3.289               ntox=ntoxn_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_hvt
+ cgdo=cgon_hvt             cgbo=0                    cgdl=cgln_hvt
+ cgsl=cgln_hvt             clc=1e-007                cle=0.6
+ cf=cfn_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.4566
+ voffcv=-0.10362           kt1=-0.23172966           lkt1=4.8415653e-10+dlkt1n_hvt
+ kt1l=0                    kt2=-0.061660112          pkt2=0+dpkt2n_hvt
+ lkt2=4.3444727e-10+dlkt2n_hvt                       ute=-1
+ ua1=3.8566889e-009        lua1=-3.1922381e-016      ub1=-4.2557421e-018
+ lub1=3.5751613e-025+dlub1n_hvt                      uc1=3.1388919e-011
+ luc1=-1.0753645e-017+dluc1n_hvt                     prt=0
+ at=230361.15              lat=-0.028667605+dlatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ pa0=0+dpa0n_hvt           wa0=0+dwa0n_hvt           pags=0+dpagsn_hvt
+ wags=0+dwagsn_hvt         lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt
+ pvth0=0+dpvthn_hvt        wcit=0+dwcitn_hvt         pcit=0+dpcitn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       weta0=0+dweta0n_hvt       peta0=0+dpeta0n_hvt
+ wu0=0+dwu0n_hvt           pu0=0+dpu0n_hvt           wk2=0+dwk2n_hvt
+ pk2=0+dpk2n_hvt           lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt
+ pvsat=0+dpvsatn_hvt       wvoff=0+dwvoffn_hvt       pvoff=0+dpvoffn_hvt
+ wpclm=0+dwpclmn_hvt       ppclm=0+dppclmn_hvt       pat=0+dpatn_hvt
+ pkt1=0+dpkt1n_hvt+dpkt1n_hvt                        wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     4: type=n 
+ lmin=1e-007-dxln_hvt      lmax=2.399969e-007-dxln_hvt
+ wmin=1e-005-dxwn_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.8625e-10+ddlcn_hvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.47011+dvthn_hvt    k1=0.393                  kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ k2=-0.03937047+dk2n_hvt   lk2=2.7945259e-009+dlk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00075960737+dcitn_hvt                        lcit=4.7567701e-010+dlcitn_hvt
+ voff=-0.14654649+dvoffn_hvt                         lvoff=-1.6596599e-009+dlvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.12+deta0n_hvt      etab=-0.083626971
+ letab=-6.0644726e-015     u0=0.014621557+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-1.4974006e-011+dlu0n_hvt                       ua=-1.4320585e-009
+ lua=-8.3062935e-018       ub=1.4201886e-018         pub=0+dpubn_hvt
+ lub=-4.0431003e-27+dlubn_hvt                        uc=5.4587867e-012
+ luc=6.2162169e-018        vsat=115000+dvsatn_hvt    a0=1.9586922+da0n_hvt
+ kvsat=0.5                 la0=-8.3163521e-008+dla0n_hvt
+ ags=0.90274163+dagsn_hvt  lags=1.0594423e-007+dlagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.12830865          lketa=8.2608179e-009
+ dwg=0                     dwb=0                     pclm=0.54614901+dpclmn_hvt
+ lpclm=6.9547543e-009+dlpclmn_hvt                    pdiblc1=0
+ pdiblc2=0.0057837286      lpdiblc2=-2.9577406e-010  pdiblcb=0.88134
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.20208476           lkt1=-5.7193352e-09+dlkt1n_hvt
+ kt1l=0                    kt2=-0.058336963          pkt2=0+dpkt2n_hvt
+ lkt2=-2.6095501e-10+dlkt2n_hvt                      ute=-1
+ ua1=2.4988818e-009        lua1=-3.5089088e-017      ub1=-2.7013404e-018
+ lub1=3.2242031e-026+dlub1n_hvt                      uc1=2.1741552e-011
+ luc1=-8.7348371e-018+dluc1n_hvt                     prt=0
+ at=101233.69              lat=-0.001646392+dlatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ pa0=0+dpa0n_hvt           wa0=0+dwa0n_hvt           pags=0+dpagsn_hvt
+ wags=0+dwagsn_hvt         lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt
+ pvth0=0+dpvthn_hvt        wcit=0+dwcitn_hvt         pcit=0+dpcitn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       weta0=0+dweta0n_hvt       peta0=0+dpeta0n_hvt
+ wu0=0+dwu0n_hvt           pu0=0+dpu0n_hvt           wk2=0+dwk2n_hvt
+ pk2=0+dpk2n_hvt           lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt
+ pvsat=0+dpvsatn_hvt       wvoff=0+dwvoffn_hvt       pvoff=0+dpvoffn_hvt
+ wpclm=0+dwpclmn_hvt       ppclm=0+dppclmn_hvt       pat=0+dpatn_hvt
+ pkt1=0+dpkt1n_hvt+dpkt1n_hvt                        wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     5: type=n 
+ lmin=6e-08                lmax=1e-007-dxln_hvt      wmin=1e-005-dxwn_hvt
+ wmax=0.0009000001         version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_hvt             toxm=2e-009               dtox=2.374e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+dxln_hvt     xw=1.6e-08+dxwn_hvt
+ dlc=2.8625e-10+ddlcn_hvt  dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.47011+dvthn_hvt
+ k1=0.393                  kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            k2=0.0086926572+dk2n_hvt
+ lk2=-9.625687e-010+dlk2n_hvt                        k3=-5.3535651
+ k3b=2.9186544             w0=0                      dvt0=0.4
+ dvt1=0.94060682           dvt2=0.05                 dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=0                    voffl=0                   dvtp0=1.5e-008
+ dvtp1=2.8                 lpe0=1.5e-010             lpeb=8e-010
+ xj=1.1e-007               ngate=4.7766e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0019248956+dcitn_hvt-0.000661736*ff_flag_hvt+0.000529388*sf_flag_hvt-0.000529388*fs_flag_hvt
+ lcit=2.6582941e-010+dlcitn_hvt+5.17277e-11*ff_flag_hvt-4.13822e-11*sf_flag_hvt+4.13822e-11*fs_flag_hvt
+ voff=-0.15458306+dvoffn_hvt                         lvoff=-1.0314408e-009+dlvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.093901741+deta0n_hvt+0.00386012*ff_flag_hvt-0.0030881*sf_flag_hvt+0.0030881*fs_flag_hvt
+ leta0=2.0401009e-009+dleta0n_hvt-3.01745e-10*ff_flag_hvt+2.41396e-10*sf_flag_hvt-2.41396e-10*fs_flag_hvt
+ etab=-0.1116793           letab=2.1928443e-009      u0=0.019316468+du0n_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-3.8197517e-010+dlu0n_hvt
+ ua=-1.4818113e-009        lua=-4.4171186e-018       ub=1.5039208e-018-8.82314e-21*ff_flag_hvt+1.54405e-20*ss_flag_hvt+7.05851e-21*sf_flag_hvt-7.05851e-21*fs_flag_hvt
+ pub=0+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt+dpubn_hvt
+ wub=0+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ lub=-1.0588447e-26+6.89703e-28*ff_flag_hvt-1.20698e-27*ss_flag_hvt-5.51762e-28*sf_flag_hvt+5.51762e-28*fs_flag_hvt+dlubn_hvt
+ uc=1.4239431e-010         luc=-4.4880333e-018       vsat=115000+dvsatn_hvt-551.446*ff_flag_hvt-2426.36*ss_flag_hvt+441.157*sf_flag_hvt-441.157*fs_flag_hvt
+ kvsat=0.5                 a0=0.99939325+da0n_hvt    la0=-8.1751233e-009+dla0n_hvt
+ ags=2.2580471+dagsn_hvt   a1=0                      a2=0.7
+ b0=0                      b1=0                      keta=-0.15789803
+ lketa=1.0573819e-008      dwg=0                     dwb=0
+ pclm=0.67978331+dpclmn_hvt                          lpclm=-3.4914391e-009+dlpclmn_hvt
+ pdiblc1=0                 pdiblc2=0.00089695991     lpdiblc2=8.6224644e-011
+ pdiblcb=0.88134           drout=0.5                 pvag=1
+ delta=0.008               pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rsw=55
+ rdw=55                    prwg=0                    prwb=0
+ wr=1                      alpha0=4.3356e-009        alpha1=0.1571
+ beta0=9.86                agidl=4.96e-008           bgidl=2.2e+009
+ cgidl=0.459               egidl=0.1                 aigbacc=0.013655
+ bigbacc=0.0068735         cigbacc=0.16236           nigbacc=2.35
+ aigbinv=0.335             bigbinv=0.0285            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0099777
+ bigc=1e-005               cigc=-0.1                 aigsd=0.0094155
+ bigsd=0.00056771          cigsd=-0.0038             nigc=1
+ poxedge=1                 pigcd=3.289               ntox=ntoxn_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_hvt
+ cgdo=cgon_hvt             cgbo=0                    cgdl=cgln_hvt
+ cgsl=cgln_hvt             clc=1e-007                cle=0.6
+ cf=cfn_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.4566
+ voffcv=-0.10362           kt1=-0.27347096           lkt1=-1.3907638e-10+dlkt1n_hvt
+ kt1l=0                    kt2=-0.063240769          pkt2=0+dpkt2n_hvt
+ lkt2=1.2237553e-10+dlkt2n_hvt                       ute=-1
+ ua1=2.436064e-009         lua1=-3.0178625e-017      ub1=-2.6450296e-018
+ lub1=2.7840213e-026+dlub1n_hvt                      uc1=-9e-011
+ prt=0                     at=97922.121              lat=-0.001387527+dlatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ pa0=0+dpa0n_hvt           wa0=0+dwa0n_hvt           pags=0+dpagsn_hvt
+ wags=0+dwagsn_hvt         lags=0+dlagsn_hvt         lvth0=0+dlvthn_hvt
+ wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt        wcit=0+dwcitn_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pcit=0+dpcitn_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ weta0=0+dweta0n_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ peta0=0+dpeta0n_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ wu0=0+dwu0n_hvt           pu0=0+dpu0n_hvt           wk2=0+dwk2n_hvt
+ pk2=0+dpk2n_hvt           lvsat=0+dlvsatn_hvt+4.31064e-05*ff_flag_hvt+0.000189668*ss_flag_hvt-3.44851e-05*sf_flag_hvt+3.44851e-05*fs_flag_hvt
+ wvsat=0+dwvsatn_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pvsat=0+dpvsatn_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ wvoff=0+dwvoffn_hvt       pvoff=0+dpvoffn_hvt       wpclm=0+dwpclmn_hvt
+ ppclm=0+dppclmn_hvt       pat=0+dpatn_hvt           luc1=0+dluc1n_hvt
+ pkt1=0+dpkt1n_hvt+dpkt1n_hvt                        wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     6: type=n 
+ lmin=9.999997e-006-dxln_hvt                         lmax=2.00001e-05
+ wmin=1e-006-dxwn_hvt      wmax=1e-005-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.032086605+dk2n_hvt  wk2=-3.0441206e-009+dwk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00097064889+dcitn_hvt                         wcit=2.9398073e-010+dwcitn_hvt
+ voff=-0.19128106+dvoffn_hvt                         wvoff=8.4896818e-009+dwvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.12+deta0n_hvt      etab=-0.083359115
+ wetab=-2.6831395e-009     u0=0.028352042+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ wu0=-3.5260491e-009+dwu0n_hvt                       ua=-5.3611093e-010
+ wua=6.248857e-017         ub=7.1709512e-019         pub=0+dpubn_hvt
+ lub=0+dlubn_hvt           wub=-1.1693665e-025       uc=5.6469345e-011
+ wuc=-8.1477181e-018       vsat=115000+dvsatn_hvt    kvsat=0.5
+ a0=3.4413302+da0n_hvt+0.0451556*ff_flag_hvt-0.0361244*sf_flag_hvt+0.0361244*fs_flag_hvt
+ wa0=5.6325747e-007+dwa0n_hvt-4.52278e-07*ff_flag_hvt+3.61822e-07*sf_flag_hvt-3.61822e-07*fs_flag_hvt
+ ags=0.77112889+dagsn_hvt  wags=-1.1306951e-008+dwagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.1                  dwg=0
+ dwb=0                     pclm=0.2+dpclmn_hvt       pdiblc1=0
+ pdiblc2=0.00044355556     wpdiblc2=5.6534756e-010   pdiblcb=0.88134005
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.18379871           wkt1=-8.4834143e-009      kt1l=0
+ lkt1=0+dlkt1n_hvt         kt2=-0.04197815           wkt2=-4.7146239e-009
+ ute=-1                    pkt2=0+dpkt2n_hvt         lkt2=0+dlkt2n_hvt
+ ua1=4.4233778e-009        wua1=-7.3495182e-016      ub1=-4.982703e-018
+ wub1=8.3809939e-025       uc1=1.9661333e-010        wuc1=3.3920853e-017
+ prt=0                     at=200000                 jss=1.203e-07
+ jsd=1.203e-07             jsws=1.666e-13            jswd=1.666e-13
+ jswgs=1.666e-13           jswgd=1.666e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.92
+ bvd=8.92                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_hvt
+ cjd=cjn_hvt               mjs=0.34                  mjd=0.34
+ pbsws=0.9                 pbswd=0.9                 cjsws=cjswn_hvt
+ cjswd=cjswn_hvt           mjsws=0.06                mjswd=0.06
+ pbswgs=1.06               pbswgd=1.06               cjswgs=cjswgn_hvt
+ cjswgd=cjswgn_hvt         mjswgs=0.78               mjswgd=0.78
+ tpb=1.55e-03              tcj=8.00e-04              tpbsw=1.0e-03
+ tcjsw=3.0e-04             tpbswg=1.30e-03           tcjswg=1.00e-03
+ xtis=3                    xtid=3                    jtsswgs=5.4e-006
+ jtsswgd=5.4e-006          njtsswg=14.625            xtsswgs=0.134
+ xtsswgd=0.134             tnjtsswg=0.1              vtsswgs=12.5
+ vtsswgd=12.5              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             pa0=0+dpa0n_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ la0=0+dla0n_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pags=0+dpagsn_hvt         lags=0+dlagsn_hvt         lvth0=0+dlvthn_hvt
+ wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt        lcit=0+dlcitn_hvt
+ pcit=0+dpcitn_hvt         lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       weta0=0+dweta0n_hvt
+ peta0=0+dpeta0n_hvt       lu0=0+dlu0n_hvt           pu0=0+dpu0n_hvt
+ lk2=0+dlk2n_hvt           pk2=0+dpk2n_hvt           lvsat=0+dlvsatn_hvt
+ wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt       lvoff=0+dlvoffn_hvt
+ pvoff=0+dpvoffn_hvt       lpclm=0+dlpclmn_hvt       wpclm=0+dwpclmn_hvt
+ ppclm=0+dppclmn_hvt       lat=0+dlatn_hvt           pat=0+dpatn_hvt
+ lub1=0+dlub1n_hvt         luc1=0+dluc1n_hvt         pkt1=0+dpkt1n_hvt+dpkt1n_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     7: type=n 
+ lmin=9.999973e-007-dxln_hvt                         lmax=9.999997e-006-dxln_hvt
+ wmin=1e-006-dxwn_hvt      wmax=1e-005-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.031858914+dk2n_hvt  lk2=-2.2642138e-009+dlk2n_hvt
+ wk2=-3.0560916e-009+dwk2n_hvt                       pk2=1.190422e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00092889562+dcitn_hvt                         lcit=4.152037e-010+dlcitn_hvt
+ wcit=3.5804558e-010+dwcitn_hvt                      pcit=-6.3707495e-016+dpcitn_hvt
+ voff=-0.19611593+dvoffn_hvt                         lvoff=4.807896e-008+dlvoffn_hvt
+ wvoff=1.0767425e-008+dwvoffn_hvt                    pvoff=-2.2650384e-014+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.12+deta0n_hvt      etab=-0.083359115
+ wetab=-2.6831395e-009     u0=0.029612405+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-1.2533329e-008+dlu0n_hvt                       wu0=-3.5401037e-009+dwu0n_hvt
+ pu0=1.3976186e-016+dpu0n_hvt                        ua=-4.4260788e-010
+ lua=-9.2981493e-016       wua=6.5092715e-017        pua=-2.5896193e-023
+ ub=6.2505906e-019         lub=9.1522691e-25+dlubn_hvt
+ wub=-1.0295411e-025       pub=-1.3904537e-31+dpubn_hvt
+ uc=5.857503e-011          luc=-2.0939396e-017       wuc=-5.0310608e-018
+ puc=-3.0992725e-023       vsat=115000+dvsatn_hvt    kvsat=0.5
+ a0=3.5994954+da0n_hvt+0.049893*ff_flag_hvt-0.0399144*sf_flag_hvt+0.0399144*fs_flag_hvt
+ la0=-1.5728288e-006+dla0n_hvt-4.71099e-08*ff_flag_hvt+3.7688e-08*sf_flag_hvt-3.7688e-08*fs_flag_hvt
+ wa0=5.9982245e-007+dwa0n_hvt-4.99728e-07*ff_flag_hvt+3.99782e-07*sf_flag_hvt-3.99782e-07*fs_flag_hvt
+ pa0=-3.6361021e-013+dpa0n_hvt+4.71853e-13*ff_flag_hvt-3.77483e-13*sf_flag_hvt+3.77483e-13*fs_flag_hvt
+ ags=0.70008376+dagsn_hvt  lags=7.0648835e-007+dlagsn_hvt
+ wags=-8.1160776e-011+dwagsn_hvt                     pags=-1.1163173e-013+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.11289472           lketa=-1.2822794e-007
+ wketa=-2.9258867e-009     pketa=2.9095661e-014      dwg=0
+ dwb=0                     pclm=0.18835788+dpclmn_hvt
+ lpclm=1.1577176e-007+dlpclmn_hvt                    wpclm=-9.4899994e-009+dwpclmn_hvt
+ ppclm=9.4370642e-014+dppclmn_hvt                    pdiblc1=0
+ pdiblc2=0.00017535045     lpdiblc2=2.6670906e-009   wpdiblc2=6.2466005e-010
+ ppdiblc2=-5.8981651e-016  pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.17869541
+ lkt1=-5.0748297e-08+dlkt1n_hvt                      wkt1=-1.0660445e-008
+ pkt1=2.1648877e-14+dpkt1n_hvt+dpkt1n_hvt            kt1l=0
+ kt2=-0.039983267          lkt2=-1.9837561e-08+dlkt2n_hvt
+ wkt2=-4.9914553e-009      pkt2=2.7528726e-15+dpkt2n_hvt
+ ute=-1                    ua1=4.5050165e-009        lua1=-8.1183344e-016
+ wua1=-6.7900746e-016      pua1=-5.5632304e-022      ub1=-5.0840129e-018
+ lub1=1.0074481e-024+dlub1n_hvt                      wub1=7.7897238e-025
+ pub1=5.8797198e-031       uc1=2.1514243e-010        luc1=-1.8425738e-016+dluc1n_hvt
+ wuc1=3.7479603e-017       puc1=-3.5388991e-023      prt=0
+ at=200000                 jss=1.203e-07             jsd=1.203e-07
+ jsws=1.666e-13            jswd=1.666e-13            jswgs=1.666e-13
+ jswgd=1.666e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.92                  bvd=8.92
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_hvt               cjd=cjn_hvt
+ mjs=0.34                  mjd=0.34                  pbsws=0.9
+ pbswd=0.9                 cjsws=cjswn_hvt           cjswd=cjswn_hvt
+ mjsws=0.06                mjswd=0.06                pbswgs=1.06
+ pbswgd=1.06               cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt
+ mjswgs=0.78               mjswgd=0.78               tpb=1.55e-03
+ tcj=8.00e-04              tpbsw=1.0e-03             tcjsw=3.0e-04
+ tpbswg=1.30e-03           tcjswg=1.00e-03           xtis=3
+ xtid=3                    jtsswgs=5.4e-006          jtsswgd=5.4e-006
+ njtsswg=14.625            xtsswgs=0.134             xtsswgd=0.134
+ tnjtsswg=0.1              vtsswgs=12.5              vtsswgd=12.5
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt
+ pvth0=0+dpvthn_hvt        lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       weta0=0+dweta0n_hvt
+ peta0=0+dpeta0n_hvt       lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt
+ pvsat=0+dpvsatn_hvt       lat=0+dlatn_hvt           pat=0+dpatn_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     8: type=n 
+ lmin=2.399969e-007-dxln_hvt                         lmax=9.999973e-007-dxln_hvt
+ wmin=1e-006-dxwn_hvt      wmax=1e-005-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=3.259685e-09+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.036672169+dk2n_hvt  lk2=2.2805577e-009+dlk2n_hvt
+ wk2=-3.0736199e-009+dwk2n_hvt                       pk2=1.3559275e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0013276467+dcitn_hvt+1.92852e-05*ff_flag_hvt-9.64262e-06*ss_flag_hvt
+ lcit=3.8694955e-011+dlcitn_hvt-1.82095e-11*ff_flag_hvt+9.10475e-12*ss_flag_hvt
+ wcit=-4.0959658e-010+dwcitn_hvt-1.93161e-10*ff_flag_hvt+9.65804e-11*ss_flag_hvt
+ pcit=8.774813e-017+dpcitn_hvt+1.82386e-16*ff_flag_hvt-9.11932e-17*ss_flag_hvt
+ voff=-0.14252347+dvoffn_hvt                         lvoff=-2.5241098e-009+dlvoffn_hvt
+ wvoff=-1.7293266e-008+dwvoffn_hvt                   pvoff=3.8450825e-015+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.12+deta0n_hvt      etab=-0.083359115
+ wetab=-2.6831395e-009     u0=0.016733837+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-3.7312759e-010+dlu0n_hvt                       wu0=-3.2150211e-009+dwu0n_hvt
+ pu0=-1.6718754e-016+dpu0n_hvt                       ua=-1.4180585e-009
+ lua=-8.7749146e-018       wua=8.1929809e-017        pua=-4.1794114e-023
+ ub=1.6466065e-018         lub=-4.9338635e-26+dlubn_hvt
+ wub=-2.9304541e-025       pub=4.0442624e-32+dpubn_hvt
+ uc=3.479874e-011          luc=1.5106527e-018        wuc=-2.9088744e-017
+ puc=-8.2769798e-024       vsat=115000+dvsatn_hvt+224.995*ss_flag_hvt
+ kvsat=0.5                 a0=2.0558208+da0n_hvt+0.0208923*ff_flag_hvt-0.0167139*sf_flag_hvt+0.0167139*fs_flag_hvt
+ la0=-1.1526039e-007+dla0n_hvt-1.9727e-08*ff_flag_hvt+1.57816e-08*sf_flag_hvt-1.57816e-08*fs_flag_hvt
+ wa0=1.1544622e-007+dwa0n_hvt-2.09258e-07*ff_flag_hvt+1.67406e-07*sf_flag_hvt-1.67406e-07*fs_flag_hvt
+ pa0=9.3747503e-014+dpa0n_hvt+1.97585e-13*ff_flag_hvt-1.58068e-13*sf_flag_hvt+1.58068e-13*fs_flag_hvt
+ ags=1.4615958+dagsn_hvt   lags=-1.2546576e-008+dlagsn_hvt
+ wags=-1.7304729e-007+dwagsn_hvt                     pags=5.1686348e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.0019823458        lketa=-1.9758716e-008
+ wketa=1.4235772e-008      pketa=1.2891279e-014      dwg=0
+ dwb=0                     pclm=0.23462131+dpclmn_hvt
+ lpclm=7.2088912e-008+dlpclmn_hvt                    wpclm=1.1544548e-007+dwpclmn_hvt
+ ppclm=-2.3595938e-014+dppclmn_hvt                   pdiblc1=0
+ pdiblc2=0.002646155       lpdiblc2=3.3410754e-010   wpdiblc2=-3.6368983e-010
+ ppdiblc2=3.4340321e-016   pdiblcb=0.88134007        lpdiblcb=-1.4959515e-014
+ wpdiblcb=-1.6096744e-014  ppdiblcb=1.5198868e-020   drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.2333965
+ lkt1=9.0156035e-10+dlkt1n_hvt                       wkt1=1.6695037e-008
+ pkt1=-4.1807166e-15+dpkt1n_hvt+dpkt1n_hvt           kt1l=0
+ kt2=-0.061792911          lkt2=7.5554155e-10+dlkt2n_hvt
+ wkt2=1.3301148e-009       pkt2=-3.2160804e-15+dpkt2n_hvt
+ ute=-1                    ua1=4.0019854e-009        lua1=-3.3686144e-016
+ wua1=-1.4552901e-015      pua1=1.7665853e-022       ub1=-4.419484e-018
+ lub1=3.7998658e-025+dlub1n_hvt                      wub1=1.6400386e-024
+ pub1=-2.25064e-031        uc1=3.1388919e-011        luc1=-1.0753645e-017+dluc1n_hvt
+ prt=0                     at=230478.21              lat=-0.028778137+dlatn_hvt
+ wat=-0.0011724868         pat=1.1070855e-009+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       weta0=0+dweta0n_hvt       peta0=0+dpeta0n_hvt
+ lvsat=0+dlvsatn_hvt-0.000212444*ss_flag_hvt         wvsat=0+dwvsatn_hvt-0.00225355*ss_flag_hvt
+ pvsat=0+dpvsatn_hvt+2.12784e-09*ss_flag_hvt         wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     9: type=n 
+ lmin=1e-007-dxln_hvt      lmax=2.399969e-007-dxln_hvt
+ wmin=1e-006-dxwn_hvt      wmax=1e-005-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.8625e-10+ddlcn_hvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.47011+dvthn_hvt    k1=0.393                  kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ k2=-0.038977189+dk2n_hvt  lk2=2.7629062e-009+dlk2n_hvt
+ wk2=-3.9390983e-009+dwk2n_hvt                       pk2=3.1670276e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00086972438+dcitn_hvt-5.42701e-05*ff_flag_hvt+3.38666e-05*ss_flag_hvt
+ lcit=4.9851683e-010+dlcitn_hvt-2.81735e-12*ff_flag_hvt+4.8e-18*ss_flag_hvt
+ wcit=1.1029319e-009+dwcitn_hvt+5.43569e-10*ff_flag_hvt-3.39208e-10*ss_flag_hvt
+ pcit=-2.2876358e-016+dpcitn_hvt+2.82183e-17*ff_flag_hvt-3.3e-23*ss_flag_hvt
+ voff=-0.14641947+dvoffn_hvt                         lvoff=-1.7088321e-009+dlvoffn_hvt
+ wvoff=-1.2721762e-009+dwvoffn_hvt                   pvoff=4.9250916e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.12+deta0n_hvt-0.000235607*ss_flag_hvt
+ etab=-0.082687533         letab=-1.4053525e-010     wetab=-9.4094145e-009
+ petab=1.4075403e-015      u0=0.015040757+du0n_hvt+6.73162e-06*ss_flag_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.8833751e-011+dlu0n_hvt-1.40866e-12*ss_flag_hvt
+ wu0=-4.1987101e-009+dwu0n_hvt-6.74239e-11*ss_flag_hvt
+ pu0=3.8659199e-017+dpu0n_hvt+1.41091e-17*ss_flag_hvt
+ ua=-1.4206363e-009        lua=-8.2354876e-018       wua=-1.1440452e-016
+ pua=-7.0919171e-025       ub=1.4311435e-018         lub=-4.2508345e-27+dlubn_hvt
+ wub=-1.0972342e-025       pub=2.0806663e-33+dpubn_hvt
+ uc=1.0045227e-011         luc=6.6905727e-018        wuc=-4.5937791e-017
+ puc=-4.7511482e-024       vsat=115000+dvsatn_hvt+47.1215*ff_flag_hvt-1530.7*ss_flag_hvt+123.862*sf_flag_hvt-123.862*fs_flag_hvt
+ kvsat=0.5                 a0=1.945581+da0n_hvt-0.0767436*ff_flag_hvt-0.0403897*ss_flag_hvt+0.0613948*sf_flag_hvt-0.0613948*fs_flag_hvt
+ la0=-9.2191618e-008+dla0n_hvt+7.0433e-10*ff_flag_hvt+8.45195e-09*ss_flag_hvt-5.63464e-10*sf_flag_hvt+5.63464e-10*fs_flag_hvt
+ wa0=1.3132161e-007+dwa0n_hvt+7.68664e-07*ff_flag_hvt+4.04543e-07*ss_flag_hvt-6.14931e-07*sf_flag_hvt+6.14931e-07*fs_flag_hvt
+ pa0=9.0425419e-014+dpa0n_hvt-7.0546e-15*ff_flag_hvt-8.46547e-14*ss_flag_hvt+5.64364e-15*sf_flag_hvt-5.64364e-15*fs_flag_hvt
+ ags=0.9005118+dagsn_hvt   lags=1.0486587e-007+dlagsn_hvt
+ wags=2.2333995e-008+dwagsn_hvt                      pags=1.0800861e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.1401724           lketa=9.1589351e-009
+ wketa=1.1882729e-007      pketa=-8.9955423e-015     dwg=0
+ dwb=0                     pclm=0.54312046+dpclmn_hvt
+ lpclm=7.5323807e-009+dlpclmn_hvt                    wpclm=3.0333988e-008+dwpclmn_hvt
+ ppclm=-5.7855067e-015+dppclmn_hvt                   pdiblc1=0
+ pdiblc2=0.0055801505      lpdiblc2=-2.7986036e-010  wpdiblc2=2.0390379e-009
+ ppdiblc2=-1.5939159e-016  pdiblcb=0.88133999        wpdiblcb=5.6534756e-014
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.20134479           lkt1=-5.8055801e-09+dlkt1n_hvt
+ wkt1=-7.4115527e-009      pkt1=8.6382822e-16+dpkt1n_hvt+dpkt1n_hvt
+ kt1l=0                    kt2=-0.056943397          lkt2=-2.5926785e-10+dlkt2n_hvt
+ wkt2=-1.3957957e-008      pkt2=-1.6898528e-17+dpkt2n_hvt
+ ute=-1                    ua1=2.5760788e-009        lua1=-3.8476225e-017
+ wua1=-7.7320576e-016      pua1=3.3925563e-023       ub1=-2.7740855e-018
+ lub1=3.5670498e-026+dlub1n_hvt                      wub1=7.2861518e-025
+ pub1=-3.4339527e-032      uc1=2.3087882e-011        luc1=-9.0165702e-018+dluc1n_hvt
+ wuc1=-1.3484848e-017      puc1=2.8218393e-024       prt=0
+ at=100028.18              lat=-0.0014801624+dlatn_hvt
+ wat=0.012074389           pat=-1.6649557e-009+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt+4.9303e-11*ss_flag_hvt          weta0=0+dweta0n_hvt+2.35984e-09*ss_flag_hvt
+ peta0=0+dpeta0n_hvt-4.93819e-16*ss_flag_hvt         lvsat=0+dlvsatn_hvt-9.86065e-06*ff_flag_hvt+0.000154953*ss_flag_hvt-2.59193e-05*sf_flag_hvt+2.59193e-05*fs_flag_hvt
+ wvsat=0+dwvsatn_hvt-0.000471966*ff_flag_hvt+0.0153314*ss_flag_hvt-0.0012406*sf_flag_hvt+0.0012406*fs_flag_hvt
+ pvsat=0+dpvsatn_hvt+9.87637e-11*ff_flag_hvt-1.55199e-09*ss_flag_hvt+2.59608e-10*sf_flag_hvt-2.59608e-10*fs_flag_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     10: type=n 
+ lmin=6e-08                lmax=1e-007-dxln_hvt      wmin=1e-006-dxwn_hvt
+ wmax=1e-005-dxwn_hvt      version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_hvt             toxm=2e-009               dtox=2.374e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+dxln_hvt     xw=1.6e-08+dxwn_hvt
+ dlc=2.8625e-10+ddlcn_hvt  dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.47151493+dvthn_hvt
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            lvth0=-1.0982301e-010+dlvthn_hvt
+ wvth0=-1.4071732e-008+dwvthn_hvt                    pvth0=1.0999873e-015+dpvthn_hvt
+ k1=0.393                  k2=0.0095988834+dk2n_hvt  lk2=-1.0342853e-009+dlk2n_hvt
+ wk2=-9.0767615e-009+dwk2n_hvt                       pk2=7.1831389e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0021886296+dcitn_hvt-0.000907677*ff_flag_hvt+6.47576e-06*ss_flag_hvt+0.000589151*sf_flag_hvt-0.000589151*fs_flag_hvt
+ lcit=2.5944529e-010+dlcitn_hvt+6.38933e-11*ff_flag_hvt+2.14115e-12*ss_flag_hvt-4.60537e-11*sf_flag_hvt+4.60537e-11*fs_flag_hvt
+ wcit=-2.6415596e-009+dwcitn_hvt+2.46335e-09*ff_flag_hvt-6.48611e-11*ss_flag_hvt-5.98577e-10*sf_flag_hvt+5.98577e-10*fs_flag_hvt
+ pcit=6.3943322e-017+dpcitn_hvt-1.21851e-16*ff_flag_hvt-2.14457e-17*ss_flag_hvt+4.67906e-17*sf_flag_hvt-4.67906e-17*fs_flag_hvt
+ voff=-0.15580641+dvoffn_hvt                         lvoff=-9.7505493e-010+dlvoffn_hvt
+ wvoff=1.2253093e-008+dwvoffn_hvt                    pvoff=-5.6476111e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.094410247+deta0n_hvt+0.00427099*ff_flag_hvt+0.000830876*ss_flag_hvt-0.00341679*sf_flag_hvt+0.00341679*fs_flag_hvt
+ leta0=2.000351e-009+dleta0n_hvt-3.33863e-10*ff_flag_hvt-3.40637e-11*ss_flag_hvt+2.6709e-10*sf_flag_hvt-2.6709e-10*fs_flag_hvt
+ weta0=-5.0931989e-009+dweta0n_hvt-4.11521e-09*ff_flag_hvt-8.32206e-09*ss_flag_hvt+3.29217e-09*sf_flag_hvt-3.29217e-09*fs_flag_hvt
+ peta0=3.9813536e-016+dpeta0n_hvt+3.21686e-16*ff_flag_hvt+3.41182e-16*ss_flag_hvt-2.57348e-16*sf_flag_hvt+2.57348e-16*fs_flag_hvt
+ etab=-0.11210419          letab=2.1589647e-009      wetab=4.2556979e-009
+ petab=3.3933847e-016      u0=0.019745564+du0n_hvt-2.37393e-05*ss_flag_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-3.8660846e-010+dlu0n_hvt+9.73247e-13*ss_flag_hvt
+ wu0=-4.2978254e-009+dwu0n_hvt+2.37773e-10*ss_flag_hvt
+ pu0=4.6407041e-017+dpu0n_hvt-9.74804e-18*ss_flag_hvt
+ ua=-1.4732195e-009        lua=-4.1250636e-018       wua=-8.605565e-017
+ pua=-2.925223e-024        ub=1.514415e-018-9.81918e-21*ff_flag_hvt+1.71836e-20*ss_flag_hvt+7.85534e-21*sf_flag_hvt-7.85534e-21*fs_flag_hvt
+ lub=-1.0760175e-26+7.67562e-28*ff_flag_hvt-1.34323e-27*ss_flag_hvt-6.1405e-28*sf_flag_hvt+6.1405e-28*fs_flag_hvt+dlubn_hvt
+ wub=-1.051099e-025+9.97628e-27*ff_flag_hvt-1.74585e-26*ss_flag_hvt-7.98103e-27*sf_flag_hvt+7.98103e-27*fs_flag_hvt
+ pub=1.7200272e-33-7.79843e-34*ff_flag_hvt+1.36473e-33*ss_flag_hvt+6.23875e-34*sf_flag_hvt-6.23875e-34*fs_flag_hvt+dpubn_hvt
+ uc=1.5933149e-010         luc=-4.9791344e-018       wuc=-1.6964274e-016
+ puc=4.9188679e-024        vsat=115000+dvsatn_hvt-804.775*ff_flag_hvt-1750.7*ss_flag_hvt+123.877*sf_flag_hvt-123.877*fs_flag_hvt
+ kvsat=0.5                 a0=0.83519892+da0n_hvt-0.142436*ff_flag_hvt+0.142436*ss_flag_hvt+0.113949*sf_flag_hvt-0.113949*fs_flag_hvt
+ la0=-5.3930506e-009+dla0n_hvt+5.83948e-09*ff_flag_hvt-5.83948e-09*ss_flag_hvt-4.67159e-09*sf_flag_hvt+4.67159e-09*fs_flag_hvt
+ wa0=1.6445704e-006+dwa0n_hvt+1.42664e-06*ff_flag_hvt-1.42664e-06*ss_flag_hvt-1.14131e-06*sf_flag_hvt+1.14131e-06*fs_flag_hvt
+ pa0=-2.786524e-014+dpa0n_hvt-5.84883e-14*ff_flag_hvt+5.84883e-14*ss_flag_hvt+4.67906e-14*sf_flag_hvt-4.67906e-14*fs_flag_hvt
+ ags=2.2437219+dagsn_hvt   lags=-1.3286195e-010+dlagsn_hvt
+ wags=1.4348169e-007+dwagsn_hvt                      pags=1.3307453e-015+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.16395409          lketa=1.101795e-008
+ wketa=6.065753e-008       pketa=-4.4484119e-015     dwg=0
+ dwb=0                     pclm=0.68099878+dpclmn_hvt
+ lpclm=-3.2455677e-009+dlpclmn_hvt                   wpclm=-1.2174115e-008+dwpclmn_hvt
+ ppclm=-2.4626483e-015+dppclmn_hvt                   pdiblc1=0
+ pdiblc2=0.00089695991     lpdiblc2=8.6224644e-011   pdiblcb=0.88133999
+ lpdiblcb=4.8669021e-016   wpdiblcb=1.1889486e-013   ppdiblcb=-4.8746891e-021
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.27547566           lkt1=-1.0769815e-11+dlkt1n_hvt
+ wkt1=2.0079132e-008       pkt1=-1.2851186e-15+dpkt1n_hvt+dpkt1n_hvt
+ kt1l=0                    kt2=-0.061039224          lkt2=6.0902926e-11+dlkt2n_hvt
+ wkt2=-2.205068e-008       pkt2=6.1570962e-16+dpkt2n_hvt
+ ute=-1                    ua1=2.4786472e-009        lua1=-3.0859992e-017
+ wua1=-4.2651268e-016      pua1=6.8245648e-024       ub1=-2.6912713e-018
+ lub1=2.9196911e-026+dlub1n_hvt                      wub1=4.6315728e-025
+ pub1=-1.3588683e-032      uc1=-9.4748197e-011       luc1=1.9467608e-019+dluc1n_hvt
+ wuc1=4.7557943e-017       puc1=-1.9498757e-024      prt=0
+ at=99560.179              lat=-0.0014435791+dlatn_hvt
+ wat=-0.016406789          pat=5.6141795e-010+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ lvsat=0+dlvsatn_hvt+5.67319e-05*ff_flag_hvt+0.000172151*ss_flag_hvt-2.59206e-05*sf_flag_hvt+2.59206e-05*fs_flag_hvt
+ wvsat=0+dwvsatn_hvt+0.00253733*ff_flag_hvt-0.00676744*ss_flag_hvt+0.00317787*sf_flag_hvt-0.00317787*fs_flag_hvt
+ pvsat=0+dpvsatn_hvt-1.36473e-10*ff_flag_hvt+1.75464e-10*ss_flag_hvt-8.57828e-11*sf_flag_hvt+8.57828e-11*fs_flag_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     11: type=n 
+ lmin=9.999997e-006-dxln_hvt                         lmax=2.00001e-05
+ wmin=6e-007-dxwn_hvt      wmax=1e-006-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.028957859+dk2n_hvt  wk2=-6.2229264e-009+dwk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0011811712+dcitn_hvt                          wcit=8.009001e-011+dwcitn_hvt
+ voff=-0.18613462+dvoffn_hvt                         wvoff=3.260896e-009+dwvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.0815+deta0n_hvt    weta0=3.9116e-008+dweta0n_hvt
+ etab=-0.08764934          wetab=1.6757294e-009      u0=0.025596594+du0n_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-7.2651383e-010+dwu0n_hvt
+ ua=-4.3562927e-010        wua=-3.9600801e-017       ub=4.9772871e-019
+ pub=0+dpubn_hvt           lub=0+dlubn_hvt           wub=1.0593963e-025
+ uc=1.2780504e-010         wuc=-8.0624783e-017       vsat=115000+dvsatn_hvt
+ kvsat=0.5                 a0=3.4135599+da0n_hvt-1.016*ff_flag_hvt+0.8128*sf_flag_hvt-0.8128*fs_flag_hvt
+ wa0=5.9147218e-007+dwa0n_hvt+6.25856e-07*ff_flag_hvt-5.00685e-07*sf_flag_hvt+5.00685e-07*fs_flag_hvt
+ ags=0.7754+dagsn_hvt      wags=-1.56464e-008+dwagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.1                  dwg=0
+ dwb=0                     pclm=0.2+dpclmn_hvt       pdiblc1=0
+ pdiblc2=0.0008768         wpdiblc2=1.251712e-010    pdiblcb=0.88134005
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.19316417           wkt1=1.0318989e-009       kt1l=0
+ lkt1=0+dlkt1n_hvt         kt2=-0.028600471          wkt2=-1.8306346e-008
+ ute=-1                    pkt2=0+dpkt2n_hvt         lkt2=0+dlkt2n_hvt
+ ua1=4.008e-009            wua1=-3.12928e-016        ub1=-4.4170599e-018
+ wub1=2.6340599e-025       uc1=4.52e-011             wuc1=1.877568e-016
+ prt=0                     at=200000                 jss=1.203e-07
+ jsd=1.203e-07             jsws=1.666e-13            jswd=1.666e-13
+ jswgs=1.666e-13           jswgd=1.666e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.92
+ bvd=8.92                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_hvt
+ cjd=cjn_hvt               mjs=0.34                  mjd=0.34
+ pbsws=0.9                 pbswd=0.9                 cjsws=cjswn_hvt
+ cjswd=cjswn_hvt           mjsws=0.06                mjswd=0.06
+ pbswgs=1.06               pbswgd=1.06               cjswgs=cjswgn_hvt
+ cjswgd=cjswgn_hvt         mjswgs=0.78               mjswgd=0.78
+ tpb=1.55e-03              tcj=8.00e-04              tpbsw=1.0e-03
+ tcjsw=3.0e-04             tpbswg=1.30e-03           tcjswg=1.00e-03
+ xtis=3                    xtid=3                    jtsswgs=5.4e-006
+ jtsswgd=5.4e-006          njtsswg=14.625            xtsswgs=0.134
+ xtsswgd=0.134             tnjtsswg=0.1              vtsswgs=12.5
+ vtsswgd=12.5              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             pa0=0+dpa0n_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ la0=0+dla0n_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pags=0+dpagsn_hvt         lags=0+dlagsn_hvt         lvth0=0+dlvthn_hvt
+ wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt        lcit=0+dlcitn_hvt
+ pcit=0+dpcitn_hvt         lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt
+ lu0=0+dlu0n_hvt           pu0=0+dpu0n_hvt           lk2=0+dlk2n_hvt
+ pk2=0+dpk2n_hvt           lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt
+ pvsat=0+dpvsatn_hvt       lvoff=0+dlvoffn_hvt       pvoff=0+dpvoffn_hvt
+ lpclm=0+dlpclmn_hvt       wpclm=0+dwpclmn_hvt       ppclm=0+dppclmn_hvt
+ lat=0+dlatn_hvt           pat=0+dpatn_hvt           lub1=0+dlub1n_hvt
+ luc1=0+dluc1n_hvt         pkt1=0+dpkt1n_hvt+dpkt1n_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     12: type=n 
+ lmin=9.999973e-007-dxln_hvt                         lmax=9.999997e-006-dxln_hvt
+ wmin=6e-007-dxwn_hvt      wmax=1e-006-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.028837805+dk2n_hvt  lk2=-1.1938493e-009+dlk2n_hvt
+ wk2=-6.1255384e-009+dwk2n_hvt                       pk2=-9.684481e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0011667693+dcitn_hvt                          lcit=1.4321586e-010+dlcitn_hvt
+ wcit=1.1636589e-010+dwcitn_hvt                      pcit=-3.6073531e-016+dpcitn_hvt
+ voff=-0.18966909+dvoffn_hvt                         lvoff=3.5147536e-008+dlvoffn_hvt
+ wvoff=4.2174372e-009+dwvoffn_hvt                    pvoff=-9.5120565e-015+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.0815+deta0n_hvt    weta0=3.9116e-008+dweta0n_hvt
+ etab=-0.08764934          wetab=1.6757294e-009      u0=0.027079711+du0n_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.4748443e-008+dlu0n_hvt
+ wu0=-9.6688641e-010+dwu0n_hvt                       pu0=2.3903179e-015+dpu0n_hvt
+ ua=-3.054061e-010         lua=-1.2949678e-015       wua=-7.4304288e-017
+ pua=3.4509912e-022        ub=3.9418677e-019         lub=1.0296438e-24+dlubn_hvt
+ wub=1.3161213e-025        pub=-2.5529298e-31+dpubn_hvt
+ uc=1.3553458e-010         luc=-7.686429e-017        wuc=-8.3221966e-017
+ puc=2.5826967e-023        vsat=115000+dvsatn_hvt    kvsat=0.5
+ a0=3.5633883+da0n_hvt-1.12259*ff_flag_hvt+0.898074*sf_flag_hvt-0.898074*fs_flag_hvt
+ la0=-1.4899272e-006+dla0n_hvt+1.05997e-06*ff_flag_hvt-8.47979e-07*sf_flag_hvt+8.47979e-07*fs_flag_hvt
+ wa0=6.365072e-007+dwa0n_hvt+6.91517e-07*ff_flag_hvt-5.53213e-07*sf_flag_hvt+5.53213e-07*fs_flag_hvt
+ pa0=-4.4783822e-013+dpa0n_hvt-6.52944e-13*ff_flag_hvt+5.22355e-13*sf_flag_hvt-5.22355e-13*fs_flag_hvt
+ ags=0.70747189+dagsn_hvt  lags=6.7549207e-007+dlagsn_hvt
+ wags=-7.5874971e-009+dwagsn_hvt                     pags=-8.0139503e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.11417376           lketa=-1.4094698e-007
+ wketa=-4.2253902e-009     pketa=4.2018209e-014      dwg=0
+ dwb=0                     pclm=0.20325231+dpclmn_hvt
+ lpclm=-3.2341719e-008+dlpclmn_hvt                   wpclm=-2.462274e-008+dwpclmn_hvt
+ ppclm=2.4485394e-013+dppclmn_hvt                    pdiblc1=0
+ pdiblc2=0.00057326474     lpdiblc2=3.0184214e-009   wpdiblc2=2.2037913e-010
+ ppdiblc2=-9.4676857e-016  pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.18939933
+ lkt1=-3.7438409e-08+dlkt1n_hvt                      wkt1=2.1473776e-010
+ pkt1=8.1260297e-15+dpkt1n_hvt+dpkt1n_hvt            kt1l=0
+ kt2=-0.026536633          lkt2=-2.0523252e-08+dlkt2n_hvt
+ wkt2=-1.8653235e-008      pkt2=3.4495341e-15+dpkt2n_hvt
+ ute=-1                    ua1=4.1861277e-009        lua1=-1.7713414e-015
+ wua1=-3.5501647e-016      pua1=4.18537e-022         ub1=-4.6176892e-018
+ lub1=1.9951019e-024+dlub1n_hvt                      wub1=3.0518747e-025
+ pub1=-4.1548429e-031      uc1=4.7843816e-011        luc1=-2.6290688e-017+dluc1n_hvt
+ wuc1=2.0745499e-016       puc1=-1.9588315e-022      prt=0
+ at=200000                 jss=1.203e-07             jsd=1.203e-07
+ jsws=1.666e-13            jswd=1.666e-13            jswgs=1.666e-13
+ jswgd=1.666e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.92                  bvd=8.92
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_hvt               cjd=cjn_hvt
+ mjs=0.34                  mjd=0.34                  pbsws=0.9
+ pbswd=0.9                 cjsws=cjswn_hvt           cjswd=cjswn_hvt
+ mjsws=0.06                mjswd=0.06                pbswgs=1.06
+ pbswgd=1.06               cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt
+ mjswgs=0.78               mjswgd=0.78               tpb=1.55e-03
+ tcj=8.00e-04              tpbsw=1.0e-03             tcjsw=3.0e-04
+ tpbswg=1.30e-03           tcjswg=1.00e-03           xtis=3
+ xtid=3                    jtsswgs=5.4e-006          jtsswgd=5.4e-006
+ njtsswg=14.625            xtsswgs=0.134             xtsswgd=0.134
+ tnjtsswg=0.1              vtsswgs=12.5              vtsswgd=12.5
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt
+ pvth0=0+dpvthn_hvt        lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt
+ lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt
+ lat=0+dlatn_hvt           pat=0+dpatn_hvt           wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     13: type=n 
+ lmin=2.399969e-007-dxln_hvt                         lmax=9.999973e-007-dxln_hvt
+ wmin=6e-007-dxwn_hvt      wmax=1e-006-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=3.259685e-09+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.031987961+dk2n_hvt  lk2=1.7805911e-009+dlk2n_hvt
+ wk2=-7.8327749e-009+dwk2n_hvt                       pk2=6.435588e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0012459167+dcitn_hvt-0.000433918*ff_flag_hvt+0.000216959*ss_flag_hvt
+ lcit=6.8483363e-011+dlcitn_hvt+4.09714e-10*ff_flag_hvt-2.04857e-10*ss_flag_hvt
+ wcit=-3.2655887e-010+dwcitn_hvt+2.67293e-10*ff_flag_hvt-1.33647e-10*ss_flag_hvt
+ pcit=5.7483107e-017+dpcitn_hvt-2.52384e-16*ff_flag_hvt+1.26192e-16*ss_flag_hvt
+ voff=-0.15398014+dvoffn_hvt                         lvoff=1.4493143e-009+dlvoffn_hvt
+ wvoff=-5.6532922e-009+dwvoffn_hvt                   pvoff=-1.9191639e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.0815+deta0n_hvt    weta0=3.9116e-008+dweta0n_hvt
+ etab=-0.08764934          wetab=1.6757294e-009      u0=0.012029446+du0n_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-5.3768226e-010+dlu0n_hvt
+ wu0=1.56464e-009+dwu0n_hvt                          pu0=-6.1387583e-031+dpu0n_hvt
+ ua=-1.6311095e-009        lua=-4.3212168e-017       wua=2.9838955e-016
+ pua=-6.8058644e-024       ub=1.4987185e-018         lub=-1.3277116e-26+dlubn_hvt
+ wub=-1.4279119e-025       pub=3.8041214e-33+dpubn_hvt
+ uc=7.5992205e-011         luc=-2.0643186e-017       wuc=-7.0941305e-017
+ puc=1.423132e-023         vsat=115000+dvsatn_hvt-5062.37*ss_flag_hvt
+ kvsat=0.5                 a0=2.0263084+da0n_hvt-0.470077*ff_flag_hvt+0.376062*sf_flag_hvt-0.376062*fs_flag_hvt
+ la0=-3.8585639e-008+dla0n_hvt+4.43857e-07*ff_flag_hvt-3.55085e-07*sf_flag_hvt+3.55085e-07*fs_flag_hvt
+ wa0=1.4543079e-007+dwa0n_hvt+2.89568e-07*ff_flag_hvt-2.31654e-07*sf_flag_hvt+2.31654e-07*fs_flag_hvt
+ pa0=1.5845956e-014+dpa0n_hvt-2.73416e-13*ff_flag_hvt+2.18733e-13*sf_flag_hvt-2.18733e-13*fs_flag_hvt
+ ags=1.4402838+dagsn_hvt   lags=-1.6443576e-008+dlagsn_hvt
+ wags=-1.5139424e-007+dwagsn_hvt                     pags=5.56457e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.040547771         lketa=5.1441803e-009
+ wketa=5.3418244e-008      pketa=-1.2410063e-014     dwg=0
+ dwb=0                     pclm=0.052139137+dpclmn_hvt
+ lpclm=1.1034236e-007+dlpclmn_hvt                    wpclm=3.0084737e-007+dwpclmn_hvt
+ ppclm=-6.2461445e-014+dppclmn_hvt                   pdiblc1=0
+ pdiblc2=0.0032774292      lpdiblc2=4.6509516e-010   wpdiblc2=-1.0050645e-009
+ ppdiblc2=2.1031979e-016   pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.22514712
+ lkt1=-3.6846333e-09+dlkt1n_hvt                      wkt1=8.3136698e-009
+ pkt1=4.7885611e-16+dpkt1n_hvt+dpkt1n_hvt            kt1l=0
+ kt2=-0.043297322          lkt2=-4.697474e-09+dlkt2n_hvt
+ wkt2=-1.7461404e-008      pkt2=2.3241834e-15+dpkt2n_hvt
+ ute=-1                    ua1=2.4548485e-009        lua1=-1.3663286e-016
+ wua1=1.1660107e-016       pua1=-2.677371e-023       ub1=-2.6356436e-018
+ lub1=1.2361483e-025+dlub1n_hvt                      wub1=-1.7234318e-025
+ pub1=3.5409701e-032       uc1=3.1388919e-011        luc1=-1.0753645e-017+dluc1n_hvt
+ prt=0                     at=231513.05              lat=-0.02975525+dlatn_hvt
+ wat=-0.0022238809         pat=2.0998328e-009+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt       lvsat=0+dlvsatn_hvt+0.00478*ss_flag_hvt
+ wvsat=0+dwvsatn_hvt+0.00311843*ss_flag_hvt          pvsat=0+dpvsatn_hvt-2.94447e-09*ss_flag_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     14: type=n 
+ lmin=1e-007-dxln_hvt      lmax=2.399969e-007-dxln_hvt
+ wmin=6e-007-dxwn_hvt      wmax=1e-006-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.8625e-10+ddlcn_hvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.47011+dvthn_hvt    k1=0.393                  kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ k2=-0.038110334+dk2n_hvt  lk2=3.0617589e-009+dlk2n_hvt
+ wk2=-4.8198231e-009+dwk2n_hvt                       pk2=1.3068487e-017+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00030677726+dcitn_hvt+0.00122108*ff_flag_hvt-0.000762*ss_flag_hvt
+ lcit=2.6500768e-010+dlcitn_hvt+6.33901e-11*ff_flag_hvt+4.1e-17*ss_flag_hvt
+ wcit=-9.2393775e-011+dwcitn_hvt-7.52183e-10*ff_flag_hvt+4.69392e-10*ss_flag_hvt
+ pcit=8.4817196e-018+dpcitn_hvt-3.9048e-17*ff_flag_hvt-1.6e-23*ss_flag_hvt
+ voff=-0.1291795+dvoffn_hvt                          lvoff=-3.7404676e-009+dlvoffn_hvt
+ wvoff=-1.8787992e-008+dwvoffn_hvt                   pvoff=2.5566509e-015+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.0815+deta0n_hvt+0.00530115*ss_flag_hvt
+ weta0=3.9116e-008+dweta0n_hvt-3.26551e-09*ss_flag_hvt
+ etab=-0.095272003         letab=1.5951184e-009      wetab=3.3764071e-009
+ petab=-3.558838e-016      u0=0.0085318875+du0n_hvt-0.000151461*ss_flag_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=1.9421683e-010+dlu0n_hvt+3.16948e-11*ss_flag_hvt
+ wu0=2.4143016e-009+dwu0n_hvt+9.33002e-11*ss_flag_hvt
+ pu0=-1.7780019e-016+dpu0n_hvt-1.9524e-17*ss_flag_hvt
+ ua=-1.8003997e-009        lua=-7.7864908e-018       wua=2.7143509e-016
+ pua=-1.1653725e-024       ub=1.3866859e-018         lub=1.0166829e-26+dlubn_hvt
+ wub=-6.4554537e-026       pub=-1.256768e-32+dpubn_hvt
+ uc=-1.9989588e-012        luc=-4.3227552e-018       wuc=-3.3700898e-017
+ puc=6.438393e-024         vsat=115000+dvsatn_hvt-1060.23*ff_flag_hvt+34440.7*ss_flag_hvt-2786.89*sf_flag_hvt+2786.89*fs_flag_hvt
+ kvsat=0.5                 a0=2.0151912+da0n_hvt+1.72673*ff_flag_hvt+0.908768*ss_flag_hvt-1.38138*sf_flag_hvt+1.38138*fs_flag_hvt
+ la0=-3.6259259e-008+dla0n_hvt-1.58473e-08*ff_flag_hvt-1.90169e-07*ss_flag_hvt+1.2678e-08*sf_flag_hvt-1.2678e-08*fs_flag_hvt
+ wa0=6.0597637e-008+dwa0n_hvt-1.06367e-06*ff_flag_hvt-5.59801e-07*ss_flag_hvt+8.50933e-07*sf_flag_hvt-8.50933e-07*fs_flag_hvt
+ pa0=3.3598141e-014+dpa0n_hvt+9.76203e-15*ff_flag_hvt+1.17144e-13*ss_flag_hvt-7.80963e-15*sf_flag_hvt+7.80963e-15*fs_flag_hvt
+ ags=0.7550947+dagsn_hvt   lags=1.2693909e-007+dlagsn_hvt
+ wags=1.7007777e-007+dwagsn_hvt                      pags=-1.1625532e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.045070294          lketa=-1.2772256e-008
+ wketa=-6.9379285e-008     pketa=1.3286548e-014      dwg=0
+ dwb=0                     pclm=0.46145979+dpclmn_hvt
+ lpclm=2.4687924e-008+dlpclmn_hvt                    wpclm=1.1330122e-007+dwpclmn_hvt
+ ppclm=-2.3215539e-014+dppclmn_hvt                   pdiblc1=0
+ pdiblc2=0.010062852       lpdiblc2=-9.5482251e-010  wpdiblc2=-2.5153873e-009
+ ppdiblc2=5.2636995e-016   pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.22620467
+ lkt1=-3.4633302e-09+dlkt1n_hvt                      wkt1=1.7846087e-008
+ pkt1=-1.5158976e-15+dpkt1n_hvt+dpkt1n_hvt           kt1l=0
+ kt2=-0.053885014          lkt2=-2.4818936e-09+dlkt2n_hvt
+ wkt2=-1.7065274e-008      pkt2=2.2412893e-15+dpkt2n_hvt
+ ute=-1                    ua1=1.8328723e-009        lua1=-6.4781295e-018
+ wua1=-1.8107942e-017      pua1=1.4154978e-024       ub1=-2.1066493e-018
+ lub1=1.2917476e-026+dlub1n_hvt                      wub1=5.0499972e-026
+ pub1=-1.1222457e-032      uc1=-4.5283454e-011       luc1=5.2908156e-018+dluc1n_hvt
+ wuc1=5.598043e-017        puc1=-1.1714465e-023      prt=0
+ at=103933.76              lat=-0.0030580085+dlatn_hvt
+ wat=0.0081063155          pat=-6.1864088e-011+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt-1.10932e-09*ss_flag_hvt         peta0=0+dpeta0n_hvt+6.8334e-16*ss_flag_hvt
+ lvsat=0+dlvsatn_hvt+0.000221863*ff_flag_hvt-0.00348643*ss_flag_hvt+0.000583185*sf_flag_hvt-0.000583185*fs_flag_hvt
+ wvsat=0+dwvsatn_hvt+0.000653106*ff_flag_hvt-0.0212155*ss_flag_hvt+0.00171672*sf_flag_hvt-0.00171672*fs_flag_hvt
+ pvsat=0+dpvsatn_hvt-1.36668e-10*ff_flag_hvt+2.14764e-09*ss_flag_hvt-3.59242e-10*sf_flag_hvt+3.59242e-10*fs_flag_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     15: type=n 
+ lmin=6e-08                lmax=1e-007-dxln_hvt      wmin=6e-007-dxwn_hvt
+ wmax=1e-006-dxwn_hvt      version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_hvt             toxm=2e-009               dtox=2.374e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+dxln_hvt     xw=1.6e-08+dxwn_hvt
+ dlc=2.8625e-10+ddlcn_hvt  dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.4576648+dvthn_hvt
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            lvth0=9.7284161e-010+dlvthn_hvt
+ k1=0.393                  k2=0.0036109655+dk2n_hvt  lk2=-1.9959511e-010+dlk2n_hvt
+ wk2=-2.9930369e-009+dwk2n_hvt                       pk2=-1.2973138e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0010667689+dcitn_hvt+0.00296968*ff_flag_hvt-0.00153844*ss_flag_hvt+0.000706557*sf_flag_hvt-0.000706557*fs_flag_hvt
+ lcit=3.7237778e-010+dlcitn_hvt-7.32979e-11*ff_flag_hvt+6.06938e-11*ss_flag_hvt-5.52314e-11*sf_flag_hvt+5.52314e-11*fs_flag_hvt
+ wcit=6.6592535e-010+dwcitn_hvt-1.47605e-09*ff_flag_hvt+1.50477e-09*ss_flag_hvt-7.17862e-10*sf_flag_hvt+7.17862e-10*fs_flag_hvt
+ pcit=-5.0796086e-017+dpcitn_hvt+1.75359e-17*ff_flag_hvt-8.09352e-17*ss_flag_hvt+5.61151e-17*sf_flag_hvt-5.61151e-17*fs_flag_hvt
+ voff=-0.1541691+dvoffn_hvt                          lvoff=-1.7870307e-009+dlvoffn_hvt
+ wvoff=1.0589578e-008+dwvoffn_hvt                    pvoff=2.6020625e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.0037690299+deta0n_hvt+0.000560269*ff_flag_hvt-0.0186947*ss_flag_hvt-0.000448216*sf_flag_hvt+0.000448216*fs_flag_hvt
+ leta0=6.0762299e-009+dleta0n_hvt-4.37961e-11*ff_flag_hvt+7.66432e-10*ss_flag_hvt+3.50369e-11*sf_flag_hvt-3.50369e-11*fs_flag_hvt
+ weta0=8.6998278e-008+dweta0n_hvt-3.45126e-10*ff_flag_hvt+1.15159e-08*ss_flag_hvt+2.76101e-10*sf_flag_hvt-2.76101e-10*fs_flag_hvt
+ peta0=-3.7429576e-015+dpeta0n_hvt+2.69784e-17*ff_flag_hvt-4.72122e-16*ss_flag_hvt-2.15827e-17*sf_flag_hvt+2.15827e-17*fs_flag_hvt
+ etab=-0.076084613         letab=9.5240137e-011      wetab=-3.234019e-008
+ petab=2.4360826e-015      u0=0.016585054+du0n_hvt+0.000534135*ss_flag_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-4.3529923e-010+dlu0n_hvt-2.18981e-11*ss_flag_hvt
+ wu0=-1.0867481e-009+dwu0n_hvt-3.29027e-10*ss_flag_hvt
+ pu0=9.5876864e-017+dpu0n_hvt+1.34892e-17*ss_flag_hvt
+ ua=-1.7610513e-009        lua=-1.0862354e-017       wua=2.0638152e-016
+ pua=3.9198645e-024        ub=1.6135703e-018-3.7366e-20*ff_flag_hvt+2.98928e-20*sf_flag_hvt-2.98928e-20*fs_flag_hvt
+ lub=-7.5687276e-27+2.92089e-27*ff_flag_hvt-2.33671e-27*sf_flag_hvt+2.33671e-27*fs_flag_hvt+dlubn_hvt
+ wub=-2.0585167e-025+3.79639e-26*ff_flag_hvt-3.03711e-26*sf_flag_hvt+3.03711e-26*fs_flag_hvt
+ pub=-1.5224828e-33-2.96763e-33*ff_flag_hvt+2.3741e-33*sf_flag_hvt-2.3741e-33*fs_flag_hvt+dpubn_hvt
+ uc=-1.3724785e-010        luc=6.2496503e-018        wuc=1.3168186e-016
+ puc=-6.4895773e-024       vsat=115000+dvsatn_hvt+5148.44*ff_flag_hvt-21365.4*ss_flag_hvt+7579.95*sf_flag_hvt-7579.95*fs_flag_hvt
+ kvsat=0.5                 a0=1.9481006+da0n_hvt+3.20481*ff_flag_hvt-3.20481*ss_flag_hvt-2.56385*sf_flag_hvt+2.56385*fs_flag_hvt
+ la0=-3.1014786e-008+dla0n_hvt-1.31388e-07*ff_flag_hvt+1.31388e-07*ss_flag_hvt+1.05111e-07*sf_flag_hvt-1.05111e-07*fs_flag_hvt
+ wa0=5.1386229e-007+dwa0n_hvt-1.97416e-06*ff_flag_hvt+1.97416e-06*ss_flag_hvt+1.57933e-06*sf_flag_hvt-1.57933e-06*fs_flag_hvt
+ pa0=-1.8335568e-015+dpa0n_hvt+8.09352e-14*ff_flag_hvt-8.09352e-14*ss_flag_hvt-6.47482e-14*sf_flag_hvt+6.47482e-14*fs_flag_hvt
+ ags=2.3407375+dagsn_hvt   lags=2.9893939e-009+dlagsn_hvt
+ wags=4.491382e-008+dwagsn_hvt                       pags=-1.8414666e-015+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.24059434          lketa=9.558148e-009
+ wketa=1.3852402e-007      pketa=-2.9652535e-015     dwg=0
+ dwb=0                     pclm=0.98600403+dpclmn_hvt
+ lpclm=-1.6315699e-008+dlpclmn_hvt                   wpclm=-3.2205945e-007+dwpclmn_hvt
+ ppclm=1.0816605e-014+dppclmn_hvt                    pdiblc1=0
+ pdiblc2=-0.0074947897     lpdiblc2=4.1765838e-010   wpdiblc2=8.5260176e-009
+ ppdiblc2=-3.3673667e-016  pdiblcb=0.88134011        lpdiblcb=-4.3112319e-015
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.24704715           lkt1=-1.8340739e-09+dlkt1n_hvt
+ wkt1=-8.8042388e-009      pkt1=5.6735839e-16+dpkt1n_hvt+dpkt1n_hvt
+ kt1l=0                    kt2=-0.10557109           lkt2=1.5584068e-09+dlkt2n_hvt
+ wkt2=2.3193695e-008       pkt2=-9.0575428e-16+dpkt2n_hvt
+ ute=-1                    ua1=2.0669609e-009        lua1=-2.4776836e-017
+ wua1=-8.2394658e-018      pua1=6.4407904e-025       ub1=-2.1054524e-018
+ lub1=1.2823915e-026+dlub1n_hvt                      wub1=-1.3203472e-025
+ pub1=3.0462797e-033       uc1=1.4638171e-010        luc1=-9.6916499e-018+dluc1n_hvt
+ wuc1=-1.9743004e-016      puc1=8.0946316e-024       prt=0
+ at=71430.022              lat=-0.00051719131+dlatn_hvt
+ wat=0.01217345            pat=-3.7979202e-010+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt        lnfactor=0+dlnfactorn_hvt
+ wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt lvsat=0+dlvsatn_hvt-0.000263467*ff_flag_hvt+0.000875923*ss_flag_hvt-0.000227188*sf_flag_hvt+0.000227188*fs_flag_hvt
+ wvsat=0+dwvsatn_hvt-0.00351113*ff_flag_hvt+0.0131611*ss_flag_hvt-0.0043975*sf_flag_hvt+0.0043975*fs_flag_hvt
+ pvsat=0+dpvsatn_hvt+1.88848e-10*ff_flag_hvt-5.39568e-10*ss_flag_hvt+1.18705e-10*sf_flag_hvt-1.18705e-10*fs_flag_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     16: type=n 
+ lmin=9.999997e-006-dxln_hvt                         lmax=2.00001e-05
+ wmin=3e-007-dxwn_hvt      wmax=6e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.037701523+dk2n_hvt  wk2=-8.3682945e-010+dwk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0016766526+dcitn_hvt                          wcit=-2.2512648e-010+dwcitn_hvt
+ voff=-0.1735528+dvoffn_hvt                          wvoff=-4.4895058e-009+dwvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.1560916+deta0n_hvt weta0=-6.8324256e-009+dweta0n_hvt
+ etab=-0.086071867         wetab=7.0400587e-010      u0=0.026963293+du0n_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-1.5684005e-009+dwu0n_hvt
+ ua=-4.7772045e-010        wua=-1.3672631e-017       ub=7.755914e-019
+ pub=0+dpubn_hvt           lub=0+dlubn_hvt           wub=-6.5223786e-026
+ uc=-2.1764062e-011        wuc=1.1509783e-017        vsat=115000+dvsatn_hvt
+ a0=3.8746424+da0n_hvt     kvsat=0.5                 wa0=3.0744531e-007+dwa0n_hvt
+ ags=0.75+dagsn_hvt        a1=0                      a2=0.7
+ b0=0                      b1=0                      keta=0.1
+ dwg=0                     dwb=0                     pclm=0.2+dpclmn_hvt
+ pdiblc1=0                 pdiblc2=0.0009536         wpdiblc2=7.78624e-011
+ pdiblcb=0.88134005        drout=0.5                 pvag=1
+ delta=0.008               pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rsw=55
+ rdw=55                    prwg=0                    prwb=0
+ wr=1                      alpha0=4.3356e-009        alpha1=0.1571
+ beta0=9.86                agidl=4.96e-008           bgidl=2.2e+009
+ cgidl=0.459               egidl=0.1                 aigbacc=0.013655
+ bigbacc=0.0068735         cigbacc=0.16236           nigbacc=2.35
+ aigbinv=0.335             bigbinv=0.0285            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0099777
+ bigc=1e-005               cigc=-0.1                 aigsd=0.0094155
+ bigsd=0.00056771          cigsd=-0.0038             nigc=1
+ poxedge=1                 pigcd=3.289               ntox=ntoxn_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_hvt
+ cgdo=cgon_hvt             cgbo=0                    cgdl=cgln_hvt
+ cgsl=cgln_hvt             clc=1e-007                cle=0.6
+ cf=cfn_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.4566
+ voffcv=-0.10362           kt1=-0.20364218           wkt1=7.4863491e-009
+ lkt1=0+dlkt1n_hvt         kt1l=0                    kt2=-0.056433729
+ wkt2=-1.1610592e-009      pkt2=0+dpkt2n_hvt         lkt2=0+dlkt2n_hvt
+ ute=-1                    ua1=4.0266667e-009        wua1=-3.2442667e-016
+ ub1=-4.4480774e-018       wub1=2.8251277e-025       uc1=6.1175333e-010
+ wuc1=-1.6124005e-016      prt=0                     at=200000
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ pa0=0+dpa0n_hvt           la0=0+dla0n_hvt           pags=0+dpagsn_hvt
+ wags=0+dwagsn_hvt         lags=0+dlagsn_hvt         lvth0=0+dlvthn_hvt
+ wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt        lcit=0+dlcitn_hvt
+ pcit=0+dpcitn_hvt         lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt
+ lu0=0+dlu0n_hvt           pu0=0+dpu0n_hvt           lk2=0+dlk2n_hvt
+ pk2=0+dpk2n_hvt           lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt
+ pvsat=0+dpvsatn_hvt       lvoff=0+dlvoffn_hvt       pvoff=0+dpvoffn_hvt
+ lpclm=0+dlpclmn_hvt       wpclm=0+dwpclmn_hvt       ppclm=0+dppclmn_hvt
+ lat=0+dlatn_hvt           pat=0+dpatn_hvt           lub1=0+dlub1n_hvt
+ luc1=0+dluc1n_hvt         pkt1=0+dpkt1n_hvt+dpkt1n_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     17: type=n 
+ lmin=9.999973e-007-dxln_hvt                         lmax=9.999997e-006-dxln_hvt
+ wmin=3e-007-dxwn_hvt      wmax=6e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.037294892+dk2n_hvt  lk2=-4.0436313e-009+dlk2n_hvt
+ wk2=-9.1597268e-010+dwk2n_hvt                       pk2=7.8701764e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0016890719+dcitn_hvt                          lcit=-1.2350069e-010+dlcitn_hvt
+ wcit=-2.053725e-010+dwcitn_hvt                      pcit=-1.9643791e-016+dpcitn_hvt
+ voff=-0.1757299+dvoffn_hvt                          lvoff=2.1649539e-008+dlvoffn_hvt
+ wvoff=-4.3691051e-009+dwvoffn_hvt                   pvoff=-1.1972902e-015+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.1560916+deta0n_hvt weta0=-6.8324256e-009+dweta0n_hvt
+ etab=-0.086071867         wetab=7.0400587e-010      u0=0.028372438+du0n_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.4012854e-008+dlu0n_hvt
+ wu0=-1.7632066e-009+dwu0n_hvt                       pu0=1.937195e-015+dpu0n_hvt
+ ua=-3.8590219e-010        lua=-9.13061e-016         wua=-2.4718699e-017
+ pua=1.0984453e-022        ub=7.1854771e-019         lub=5.6725501e-25+dlubn_hvt
+ wub=-6.819421e-026        pub=2.9538543e-32+dpubn_hvt
+ uc=-2.2093989e-011        luc=3.2808673e-018        wuc=1.3877234e-017
+ puc=-2.354245e-023        vsat=115000+dvsatn_hvt    a0=4.0377351+da0n_hvt
+ kvsat=0.5                 la0=-1.6218296e-006+dla0n_hvt
+ wa0=3.4430957e-007+dwa0n_hvt                        pa0=-3.6658639e-013+dpa0n_hvt
+ ags=0.69715161+dagsn_hvt  lags=5.2553598e-007+dlagsn_hvt
+ wags=-1.2302069e-009+dwagsn_hvt                     pags=1.2233448e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.10657895           lketa=-6.5422561e-008
+ wketa=4.5301037e-010      pketa=-4.5048348e-015     dwg=0
+ dwb=0                     pclm=0.14670403+dpclmn_hvt
+ lpclm=5.2998688e-007+dlpclmn_hvt                    wpclm=1.0211005e-008+dwpclmn_hvt
+ ppclm=-1.0154048e-013+dppclmn_hvt                   pdiblc1=0
+ pdiblc2=0.00095712509     lpdiblc2=-3.5054251e-011  wpdiblc2=-1.6078845e-011
+ ppdiblc2=9.3417241e-016   pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.20039131
+ lkt1=-3.2327355e-08+dlkt1n_hvt                      wkt1=6.9857949e-009
+ pkt1=4.9776206e-15+dpkt1n_hvt+dpkt1n_hvt            kt1l=0
+ kt2=-0.054267339          lkt2=-2.1543054e-08+dlkt2n_hvt
+ wkt2=-1.5711198e-009      pkt2=4.0777326e-15+dpkt2n_hvt
+ ute=-1                    ua1=4.1858222e-009        lua1=-1.5826772e-015
+ wua1=-3.5482823e-016      pua1=3.0231985e-022       ub1=-4.6378721e-018
+ lub1=1.8873599e-024+dlub1n_hvt                      wub1=3.1762011e-025
+ pub1=-3.491152e-031       uc1=6.7383615e-010        luc1=-6.1736517e-016+dluc1n_hvt
+ wuc1=-1.7815628e-016      puc1=1.6821873e-022       prt=0
+ at=200000                 jss=1.203e-07             jsd=1.203e-07
+ jsws=1.666e-13            jswd=1.666e-13            jswgs=1.666e-13
+ jswgd=1.666e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.92                  bvd=8.92
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_hvt               cjd=cjn_hvt
+ mjs=0.34                  mjd=0.34                  pbsws=0.9
+ pbswd=0.9                 cjsws=cjswn_hvt           cjswd=cjswn_hvt
+ mjsws=0.06                mjswd=0.06                pbswgs=1.06
+ pbswgd=1.06               cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt
+ mjswgs=0.78               mjswgd=0.78               tpb=1.55e-03
+ tcj=8.00e-04              tpbsw=1.0e-03             tcjsw=3.0e-04
+ tpbswg=1.30e-03           tcjswg=1.00e-03           xtis=3
+ xtid=3                    jtsswgs=5.4e-006          jtsswgd=5.4e-006
+ njtsswg=14.625            xtsswgs=0.134             xtsswgd=0.134
+ tnjtsswg=0.1              vtsswgs=12.5              vtsswgd=12.5
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt
+ pvth0=0+dpvthn_hvt        lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt
+ lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt
+ lat=0+dlatn_hvt           pat=0+dpatn_hvt           wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     18: type=n 
+ lmin=2.399969e-007-dxln_hvt                         lmax=9.999973e-007-dxln_hvt
+ wmin=3e-007-dxwn_hvt      wmax=6e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=3.259685e-09+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.045143+dk2n_hvt     lk2=3.3667093e-009+dlk2n_hvt
+ wk2=2.7072926e-010+dwk2n_hvt                        pk2=-3.3349006e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0014349436+dcitn_hvt                          lcit=1.1645234e-010+dlcitn_hvt
+ wcit=-4.4299946e-010+dwcitn_hvt                     pcit=2.7934219e-017+dpcitn_hvt
+ voff=-0.15243008+dvoffn_hvt                         lvoff=-3.5060953e-010+dlvoffn_hvt
+ wvoff=-6.6081245e-009+dwvoffn_hvt                   pvoff=9.168367e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.1560916+deta0n_hvt weta0=-6.8324256e-009+dweta0n_hvt
+ etab=-0.086071867         wetab=7.0400587e-010      u0=0.013967902+du0n_hvt
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-4.1180325e-010+dlu0n_hvt
+ wu0=3.7055086e-010+dwu0n_hvt                        pu0=-7.7541473e-017+dpu0n_hvt
+ ua=-1.3021034e-009        lua=-4.7965539e-017       wua=9.5721793e-017
+ pua=-3.877788e-024        ub=1.3216737e-018         lub=-2.2286389e-27+dlubn_hvt
+ wub=-3.3731602e-026       pub=-3.0017406e-33+dpubn_hvt
+ uc=-1.9932325e-011        luc=1.2397805e-018        wuc=-1.1851794e-017
+ puc=7.5141299e-025        vsat=115000+dvsatn_hvt    a0=2.3847609+da0n_hvt
+ kvsat=0.5                 la0=-6.1058245e-008+dla0n_hvt
+ wa0=-7.537596e-008+dwa0n_hvt                        pa0=2.9689081e-014+dpa0n_hvt
+ ags=1.2637446+dagsn_hvt   lags=-9.4524994e-009+dlagsn_hvt
+ wags=-4.2646136e-008+dwagsn_hvt                     pags=5.1339197e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.054356281          lketa=-1.6112869e-008
+ wketa=-5.0426521e-009     pketa=6.842796e-016       dwg=0
+ dwb=0                     pclm=0.73953465+dpclmn_hvt
+ lpclm=-2.9775648e-008+dlpclmn_hvt                   wpclm=-1.2258827e-007+dwpclmn_hvt
+ ppclm=2.385125e-014+dppclmn_hvt                     pdiblc1=0
+ pdiblc2=-0.00030824819    lpdiblc2=1.1597365e-009   wpdiblc2=1.2037128e-009
+ ppdiblc2=-2.1757928e-016  pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.23410862
+ lkt1=-4.9079526e-10+dlkt1n_hvt                      wkt1=1.3833954e-008
+ pkt1=-1.4885481e-15+dpkt1n_hvt+dpkt1n_hvt           kt1l=0
+ kt2=-0.078348771          lkt2=1.1951153e-09+dlkt2n_hvt
+ wkt2=4.130289e-009        pkt2=-1.3056516e-15+dpkt2n_hvt
+ ute=-1                    ua1=2.7142247e-009        lua1=-1.931654e-016
+ wua1=-4.3174678e-017      pua1=8.0503351e-024       ub1=-2.8193665e-018
+ lub1=1.7029057e-025+dlub1n_hvt                      wub1=-5.9169878e-026
+ pub1=6.657444e-033        uc1=3.1388919e-011        luc1=-1.0753645e-017+dluc1n_hvt
+ prt=0                     at=226338.83              lat=-0.024869651+dlatn_hvt
+ wat=0.00096343711         pat=-9.0969659e-010+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt       lvsat=0+dlvsatn_hvt
+ wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt       wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     19: type=n 
+ lmin=1e-007-dxln_hvt      lmax=2.399969e-007-dxln_hvt
+ wmin=3e-007-dxwn_hvt      wmax=6e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.8625e-10+ddlcn_hvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.47011+dvthn_hvt    k1=0.393                  kvth0=19e-10
+ pkvth0=0                  wkvth0=5e-8               lkvth0=-0.4e-8
+ k2=-0.043556133+dk2n_hvt  lk2=3.0346415e-009+dlk2n_hvt
+ wk2=-1.4652108e-009+dwk2n_hvt                       pk2=2.9772762e-017+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00090282029+dcitn_hvt                         lcit=2.2780446e-010+dlcitn_hvt
+ wcit=-4.5955628e-010+dwcitn_hvt                     pcit=3.1398899e-017+dpcitn_hvt
+ voff=-0.15517369+dvoffn_hvt                         lvoff=2.2351804e-010+dlvoffn_hvt
+ wvoff=-2.7755669e-009+dwvoffn_hvt                   pvoff=1.148357e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.1560916+deta0n_hvt weta0=-6.8324256e-009+dweta0n_hvt
+ etab=-0.096054811         letab=2.089031e-009       wetab=3.8586172e-009
+ petab=-6.6013397e-016     u0=0.01128083+du0n_hvt    ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=1.5049346e-010+dlu0n_hvt                        wu0=7.2095285e-010+dwu0n_hvt
+ pu0=-1.5086659e-016+dpu0n_hvt                       ua=-1.6025923e-009
+ lua=1.4914775e-017        wua=1.4958572e-016        pua=-1.5149352e-023
+ ub=1.4214812e-018         lub=-2.3114358e-26+dlubn_hvt
+ wub=-8.5988468e-026       pub=7.9335313e-33+dpubn_hvt
+ uc=-6.3516805e-011        luc=1.0360269e-017        wuc=4.1940955e-018
+ puc=-2.6063498e-024       vsat=115000+dvsatn_hvt    a0=1.9636611+da0n_hvt
+ kvsat=0.5                 la0=2.7061111e-008+dla0n_hvt
+ wa0=9.2340218e-008+dwa0n_hvt                        pa0=-5.4072063e-015+dpa0n_hvt
+ ags=0.50594036+dagsn_hvt  lags=1.4912563e-007+dlagsn_hvt
+ wags=3.2355684e-007+dwagsn_hvt                      pags=-2.5292438e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.062964937         lketa=8.4377687e-009
+ wketa=-2.8295827e-009     pketa=2.211727e-016       dwg=0
+ dwb=0                     pclm=0.66816082+dpclmn_hvt
+ lpclm=-1.483996e-008+dlpclmn_hvt                    wpclm=-1.4026612e-008+dwpclmn_hvt
+ ppclm=1.1336382e-015+dppclmn_hvt                    pdiblc1=0
+ pdiblc2=0.0057454973      lpdiblc2=-1.0707028e-010  wpdiblc2=1.4410348e-010
+ ppdiblc2=4.1545739e-018   pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.21417912
+ lkt1=-4.661242e-09+dlkt1n_hvt                       wkt1=1.043835e-008
+ pkt1=-7.7798398e-16+dpkt1n_hvt+dpkt1n_hvt           kt1l=0
+ kt2=-0.080705749          lkt2=1.6883364e-09+dlkt2n_hvt
+ wkt2=-5.4370118e-010      pkt2=-3.2757243e-16+dpkt2n_hvt
+ ute=-1                    ua1=1.7541119e-009        lua1=7.7478005e-018
+ wua1=3.0408473e-017       pua1=-7.3476751e-024      ub1=-1.9617769e-018
+ lub1=-9.1686259e-027+dlub1n_hvt                     wub1=-3.8741405e-026
+ pub1=2.3825818e-033       uc1=4.5593867e-011        luc1=-1.3726173e-017+dluc1n_hvt
+ prt=0                     at=131577.87              lat=-0.0050399719+dlatn_hvt
+ wat=-0.0089224557         pat=1.1590253e-009+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt       lvsat=0+dlvsatn_hvt
+ wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt       wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     20: type=n 
+ lmin=6e-08                lmax=1e-007-dxln_hvt      wmin=3e-007-dxwn_hvt
+ wmax=6e-007-dxwn_hvt      version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_hvt             toxm=2e-009               dtox=2.374e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+dxln_hvt     xw=1.6e-08+dxwn_hvt
+ dlc=2.8625e-10+ddlcn_hvt  dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.46437658+dvthn_hvt+0.00813199*ff_flag_hvt-0.00813199*ss_flag_hvt-0.0065056*sf_flag_hvt+0.0065056*fs_flag_hvt
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            lvth0=4.4818162e-010+dlvthn_hvt-6.35676e-10*ff_flag_hvt+6.35676e-10*ss_flag_hvt+5.08541e-10*sf_flag_hvt-5.08541e-10*fs_flag_hvt
+ wvth0=-4.1344577e-009+dwvthn_hvt-5.00931e-09*ff_flag_hvt+5.00931e-09*ss_flag_hvt+4.00745e-09*sf_flag_hvt-4.00745e-09*fs_flag_hvt
+ pvth0=3.2319056e-016+dpvthn_hvt+3.91576e-16*ff_flag_hvt-3.91576e-16*ss_flag_hvt-3.13261e-16*sf_flag_hvt+3.13261e-16*fs_flag_hvt
+ k1=0.393                  k2=0.004038916+dk2n_hvt   lk2=-6.8586344e-010+dlk2n_hvt
+ wk2=-3.2566544e-009+dwk2n_hvt                       pk2=1.6980991e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00019448016+dcitn_hvt+0.0019211*ff_flag_hvt+0.000462924*ss_flag_hvt-0.00153687*sf_flag_hvt+0.00153687*fs_flag_hvt
+ lcit=2.8317541e-010+dlcitn_hvt-1.50171e-10*ff_flag_hvt-3.6186e-11*ss_flag_hvt+1.20137e-10*sf_flag_hvt-1.20137e-10*fs_flag_hvt
+ wcit=-1.110041e-010+dwcitn_hvt-8.30114e-10*ff_flag_hvt+2.71934e-10*ss_flag_hvt+6.64091e-10*sf_flag_hvt-6.64091e-10*fs_flag_hvt
+ pcit=4.1525752e-018+dpcitn_hvt+6.48898e-17*ff_flag_hvt-2.1257e-17*ss_flag_hvt-5.19118e-17*sf_flag_hvt+5.19118e-17*fs_flag_hvt
+ voff=-0.13120134+dvoffn_hvt                         lvoff=-1.6504006e-009+dlvoffn_hvt
+ wvoff=-3.5585581e-009+dwvoffn_hvt                   pvoff=1.7604212e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.15609642+deta0n_hvt+0.0104554*ff_flag_hvt-0.0174257*ss_flag_hvt-0.00836434*sf_flag_hvt+0.00836434*fs_flag_hvt
+ leta0=-3.7700748e-013+dleta0n_hvt-8.17298e-10*ff_flag_hvt+1.36216e-09*ss_flag_hvt+6.53838e-10*sf_flag_hvt-6.53838e-10*fs_flag_hvt
+ weta0=-6.8353965e-009+dweta0n_hvt-6.44054e-09*ff_flag_hvt+1.07342e-08*ss_flag_hvt+5.15243e-09*sf_flag_hvt-5.15243e-09*fs_flag_hvt
+ peta0=2.3223661e-019+dpeta0n_hvt+5.03455e-16*ff_flag_hvt-8.39092e-16*ss_flag_hvt-4.02764e-16*sf_flag_hvt+4.02764e-16*fs_flag_hvt
+ etab=-0.11143241          letab=3.2910981e-009      wetab=-1.0565945e-008
+ petab=4.6743408e-016      u0=0.017554263+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-3.3990079e-010+dlu0n_hvt                       wu0=-1.6837806e-009+dwu0n_hvt
+ pu0=3.7111421e-017+dpu0n_hvt                        ua=-1.4438128e-009
+ lua=2.5029837e-018        wua=1.0962606e-017        pua=-4.3131838e-024
+ ub=1.4067731e-018+6.14384e-20*ff_flag_hvt-4.91508e-20*sf_flag_hvt+4.91508e-20*fs_flag_hvt
+ lub=-2.1964624e-26-4.80263e-27*ff_flag_hvt+3.84211e-27*sf_flag_hvt-3.84211e-27*fs_flag_hvt+dlubn_hvt
+ wub=-7.8464585e-026-2.28997e-26*ff_flag_hvt+1.83197e-26*sf_flag_hvt-1.83197e-26*fs_flag_hvt
+ pub=7.3453894e-33+1.79006e-33*ff_flag_hvt-1.43205e-33*sf_flag_hvt+1.43205e-33*fs_flag_hvt+dpubn_hvt
+ uc=1.483495e-010          luc=-6.2013201e-018       wuc=-4.4246103e-017
+ puc=1.1802205e-024        vsat=115000+dvsatn_hvt-1945.5*ff_flag_hvt-5460.05*ss_flag_hvt+1556.4*sf_flag_hvt-1556.4*fs_flag_hvt
+ kvsat=0.5                 a0=1.7137082+da0n_hvt     la0=4.6599925e-008+dla0n_hvt
+ wa0=6.5824802e-007+dwa0n_hvt                        pa0=-4.9644219e-014+dpa0n_hvt
+ ags=2.4136495+dagsn_hvt   a1=0                      a2=0.7
+ b0=0                      b1=0                      keta=-0.015716989
+ lketa=4.7443965e-009      wketa=-4.2451604e-013     pketa=1.7405158e-020
+ dwg=0                     dwb=0                     pclm=0.402627+dpclmn_hvt+0.0580857*ss_flag_hvt
+ lpclm=5.9168186e-009+dlpclmn_hvt-4.54054e-09*ss_flag_hvt
+ wpclm=3.7300801e-008+dwpclmn_hvt-3.57808e-08*ss_flag_hvt
+ ppclm=-2.8786257e-015+dppclmn_hvt+2.79697e-15*ss_flag_hvt
+ pdiblc1=0                 pdiblc2=0.0054403527      lpdiblc2=-8.3217128e-011
+ wpdiblc2=5.5796988e-010   ppdiblc2=-2.8197362e-017  pdiblcb=0.88134011
+ lpdiblcb=-4.3112323e-015  drout=0.5                 pvag=1
+ delta=0.008               pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rsw=55
+ rdw=55                    prwg=0                    prwb=0
+ wr=1                      alpha0=4.3356e-009        alpha1=0.1571
+ beta0=9.86                agidl=4.96e-008           bgidl=2.2e+009
+ cgidl=0.459               egidl=0.1                 aigbacc=0.013655
+ bigbacc=0.0068735         cigbacc=0.16236           nigbacc=2.35
+ aigbinv=0.335             bigbinv=0.0285            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0099777
+ bigc=1e-005               cigc=-0.1                 aigsd=0.0094155
+ bigsd=0.00056771          cigsd=-0.0038             nigc=1
+ poxedge=1                 pigcd=3.289               ntox=ntoxn_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_hvt
+ cgdo=cgon_hvt             cgbo=0                    cgdl=cgln_hvt
+ cgsl=cgln_hvt             clc=1e-007                cle=0.6
+ cf=cfn_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.4566
+ voffcv=-0.10362           kt1=-0.25874934           lkt1=-1.1771884e-09+dlkt1n_hvt
+ wkt1=-1.5956901e-009      pkt1=1.6271691e-16+dpkt1n_hvt+dpkt1n_hvt
+ kt1l=0                    kt2=-0.052927418          lkt2=-4.8309569e-10+dlkt2n_hvt
+ wkt2=-9.2348061e-009      pkt2=3.5181124e-16+dpkt2n_hvt
+ ute=-1                    ua1=2.1577714e-009        lua1=-2.3806263e-017
+ wua1=-6.4178718e-017      pua1=4.620563e-026        ub1=-2.2166951e-018
+ lub1=1.0758322e-026+dlub1n_hvt                      wub1=-6.3509261e-026
+ pub1=4.3186851e-033       uc1=-1.741216e-010        luc1=3.4489857e-018+dluc1n_hvt
+ prt=0                     at=77862.164              lat=-0.00084101521+dlatn_hvt
+ wat=0.0082112508          pat=-1.803165e-010+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ pags=0+dpagsn_hvt         wags=0+dwagsn_hvt         lags=0+dlagsn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ lvsat=0+dlvsatn_hvt+0.000152079*ff_flag_hvt+0.000426811*ss_flag_hvt-0.000121664*sf_flag_hvt+0.000121664*fs_flag_hvt
+ wvsat=0+dwvsatn_hvt+0.000858739*ff_flag_hvt+0.00336339*ss_flag_hvt-0.000686991*sf_flag_hvt+0.000686991*fs_flag_hvt
+ pvsat=0+dpvsatn_hvt-6.71273e-11*ff_flag_hvt-2.62916e-10*ss_flag_hvt+5.37019e-11*sf_flag_hvt-5.37019e-11*fs_flag_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
 
     21: type=n 
+ lmin=9.999997e-006-dxln_hvt                         lmax=2.00001e-05
+ wmin=1.2e-07              wmax=3e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.047395327+dk2n_hvt  wk2=2.2264125e-009+dwk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0012394207+dcitn_hvt                          wcit=-8.696122e-011+dwcitn_hvt
+ voff=-0.20003753+dvoffn_hvt                         wvoff=3.8796684e-009+dwvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.13784733+deta0n_hvt
+ weta0=-1.0672373e-009+dweta0n_hvt                   etab=-0.072920178
+ wetab=-3.4519278e-009     u0=0.022807937+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ wu0=-2.5530795e-010+dwu0n_hvt                       ua=-4.5370788e-010
+ wua=-2.1260603e-017       ub=5.3315393e-019         pub=0+dpubn_hvt
+ lub=0+dlubn_hvt           wub=1.1386453e-026        uc=-3.6890271e-011
+ wuc=1.6289665e-017        vsat=115000+dvsatn_hvt    a0=4.3474965+da0n_hvt
+ kvsat=0.5                 wa0=1.5802343e-007+dwa0n_hvt
+ ags=0.75+dagsn_hvt        a1=0                      a2=0.7
+ b0=0                      b1=0                      keta=0.1128455
+ wketa=-4.0591787e-009     dwg=0                     dwb=0
+ pclm=0.2+dpclmn_hvt       pdiblc1=0                 pdiblc2=0.0012
+ pdiblcb=0.88134005        drout=0.5                 pvag=1
+ delta=0.008               pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rsw=55
+ rdw=55                    prwg=0                    prwb=0
+ wr=1                      alpha0=4.3356e-009        alpha1=0.1571
+ beta0=9.86                agidl=4.96e-008           bgidl=2.2e+009
+ cgidl=0.459               egidl=0.1                 aigbacc=0.013655
+ bigbacc=0.0068735         cigbacc=0.16236           nigbacc=2.35
+ aigbinv=0.335             bigbinv=0.0285            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0099777
+ bigc=1e-005               cigc=-0.1                 aigsd=0.0094155
+ bigsd=0.00056771          cigsd=-0.0038             nigc=1
+ poxedge=1                 pigcd=3.289               ntox=ntoxn_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_hvt
+ cgdo=cgon_hvt             cgbo=0                    cgdl=cgln_hvt
+ cgsl=cgln_hvt             clc=1e-007                cle=0.6
+ cf=cfn_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.4566
+ voffcv=-0.10362           kt1=-0.16877259           wkt1=-3.5324419e-009
+ lkt1=0+dlkt1n_hvt         kt1l=0                    kt2=-0.068635942
+ wkt2=2.6948402e-009       pkt2=0+dpkt2n_hvt         lkt2=0+dlkt2n_hvt
+ ute=-1                    ua1=3e-009                ub1=-3.488436e-018
+ wub1=-2.0733917e-026      uc1=1.8186962e-010        wuc1=-2.5396799e-017
+ prt=0                     at=200000                 jss=1.203e-07
+ jsd=1.203e-07             jsws=1.666e-13            jswd=1.666e-13
+ jswgs=1.666e-13           jswgd=1.666e-13           njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=8.92
+ bvd=8.92                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn_hvt
+ cjd=cjn_hvt               mjs=0.34                  mjd=0.34
+ pbsws=0.9                 pbswd=0.9                 cjsws=cjswn_hvt
+ cjswd=cjswn_hvt           mjsws=0.06                mjswd=0.06
+ pbswgs=1.06               pbswgd=1.06               cjswgs=cjswgn_hvt
+ cjswgd=cjswgn_hvt         mjswgs=0.78               mjswgd=0.78
+ tpb=1.55e-03              tcj=8.00e-04              tpbsw=1.0e-03
+ tcjsw=3.0e-04             tpbswg=1.30e-03           tcjswg=1.00e-03
+ xtis=3                    xtid=3                    jtsswgs=5.4e-006
+ jtsswgd=5.4e-006          njtsswg=14.625            xtsswgs=0.134
+ xtsswgd=0.134             tnjtsswg=0.1              vtsswgs=12.5
+ vtsswgd=12.5              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             pa0=0+dpa0n_hvt
+ la0=0+dla0n_hvt           pags=0+dpagsn_hvt         wags=0+dwagsn_hvt
+ lags=0+dlagsn_hvt         lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt
+ pvth0=0+dpvthn_hvt        lcit=0+dlcitn_hvt         pcit=0+dpcitn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt       lu0=0+dlu0n_hvt
+ pu0=0+dpu0n_hvt           lk2=0+dlk2n_hvt           pk2=0+dpk2n_hvt
+ lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt
+ lvoff=0+dlvoffn_hvt       pvoff=0+dpvoffn_hvt       lpclm=0+dlpclmn_hvt
+ wpclm=0+dwpclmn_hvt       ppclm=0+dppclmn_hvt       lat=0+dlatn_hvt
+ pat=0+dpatn_hvt           lub1=0+dlub1n_hvt         luc1=0+dluc1n_hvt
+ pkt1=0+dpkt1n_hvt+dpkt1n_hvt                        wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     22: type=n 
+ lmin=9.999973e-007-dxln_hvt                         lmax=9.999997e-006-dxln_hvt
+ wmin=1.2e-07              wmax=3e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.058866e-08+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.047027015+dk2n_hvt  lk2=-3.6625701e-009+dlk2n_hvt
+ wk2=2.1593783e-009+dwk2n_hvt                        pk2=6.666023e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0013392608+dcitn_hvt                          lcit=-9.9283127e-010+dlcitn_hvt
+ wcit=-9.4832179e-011+dwcitn_hvt                     pcit=7.8270552e-017+dpcitn_hvt
+ voff=-0.20193716+dvoffn_hvt                         lvoff=1.8890374e-008+dlvoffn_hvt
+ wvoff=3.9123904e-009+dwvoffn_hvt                    pvoff=-3.2539419e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.13784733+deta0n_hvt
+ weta0=-1.0672373e-009+dweta0n_hvt                   etab=-0.072920178
+ wetab=-3.4519278e-009     u0=0.023762748+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-9.4948514e-009+dlu0n_hvt                       wu0=-3.0654436e-010+dwu0n_hvt
+ pu0=5.0950613e-016+dpu0n_hvt                        ua=-3.9288692e-010
+ lua=-6.0481701e-016       wua=-2.2511524e-017       pua=1.2439434e-023
+ ub=4.8101585e-019         lub=5.1847261e-25+dlubn_hvt
+ wub=6.8658594e-027        pub=4.4953782e-32+dpubn_hvt
+ uc=-3.1383891e-011        luc=-5.4756652e-017       wuc=1.6812843e-017
+ puc=-5.2025938e-024       vsat=115000+dvsatn_hvt    a0=4.6094774+da0n_hvt
+ kvsat=0.5                 la0=-2.6051955e-006+dla0n_hvt
+ wa0=1.6363902e-007+dwa0n_hvt                        pa0=-5.5842749e-014+dpa0n_hvt
+ ags=0.71990849+dagsn_hvt  lags=2.9923658e-007+dlagsn_hvt
+ wags=-8.4213802e-009+dwagsn_hvt                     pags=8.3744058e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.11821781           lketa=-5.3423407e-008
+ wketa=-3.2248682e-009     pketa=-8.2965676e-015     dwg=0
+ dwb=0                     pclm=0.19402115+dpclmn_hvt
+ lpclm=5.9454977e-008+dlpclmn_hvt                    wpclm=-4.7412068e-009+dwpclmn_hvt
+ ppclm=4.7147604e-014+dppclmn_hvt                    pdiblc1=0
+ pdiblc2=0.00084282839     lpdiblc2=3.5517931e-009   wpdiblc2=2.0038913e-011
+ ppdiblc2=-1.9927136e-016  pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.16702208
+ lkt1=-1.7407449e-08+dlkt1n_hvt                      wkt1=-3.5588824e-009
+ pkt1=2.6293034e-16+dpkt1n_hvt+dpkt1n_hvt            kt1l=0
+ kt2=-0.067954365          lkt2=-6.7777512e-09+dlkt2n_hvt
+ wkt2=2.7539804e-009       pkt2=-5.8810323e-16+dpkt2n_hvt
+ ute=-1                    ua1=3.1105087e-009        lua1=-1.0989229e-015
+ wua1=-1.5029185e-017      pua1=1.4945352e-022       ub1=-3.6255284e-018
+ lub1=1.3632768e-024+dlub1n_hvt                      wub1=-2.2804872e-027
+ pub1=-1.8350496e-031      uc1=2.0519333e-010        luc1=-2.319361e-016+dluc1n_hvt
+ wuc1=-3.0065154e-017      puc1=4.6423141e-023       prt=0
+ at=200000                 jss=1.203e-07             jsd=1.203e-07
+ jsws=1.666e-13            jswd=1.666e-13            jswgs=1.666e-13
+ jswgd=1.666e-13           njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=8.92                  bvd=8.92
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjn_hvt               cjd=cjn_hvt
+ mjs=0.34                  mjd=0.34                  pbsws=0.9
+ pbswd=0.9                 cjsws=cjswn_hvt           cjswd=cjswn_hvt
+ mjsws=0.06                mjswd=0.06                pbswgs=1.06
+ pbswgd=1.06               cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt
+ mjswgs=0.78               mjswgd=0.78               tpb=1.55e-03
+ tcj=8.00e-04              tpbsw=1.0e-03             tcjsw=3.0e-04
+ tpbswg=1.30e-03           tcjswg=1.00e-03           xtis=3
+ xtid=3                    jtsswgs=5.4e-006          jtsswgd=5.4e-006
+ njtsswg=14.625            xtsswgs=0.134             xtsswgd=0.134
+ tnjtsswg=0.1              vtsswgs=12.5              vtsswgd=12.5
+ dmcg=7.15e-008            dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-1.163e-8             lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt
+ pvth0=0+dpvthn_hvt        lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt
+ pnfactor=0+dpnfactorn_hvt leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt
+ lvsat=0+dlvsatn_hvt       wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt
+ lat=0+dlatn_hvt           pat=0+dpatn_hvt           wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     23: type=n 
+ lmin=2.399969e-007-dxln_hvt                         lmax=9.999973e-007-dxln_hvt
+ wmin=1.2e-07              wmax=3e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=3.259685e-09+ddlcn_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=0.47011+dvthn_hvt    k1=0.393
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.054087007+dk2n_hvt  lk2=3.0036154e-009+dlk2n_hvt
+ wk2=3.0970355e-009+dwk2n_hvt                        pk2=-2.1875237e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-9.3096014e-005+dcitn_hvt                       lcit=3.5962865e-010+dlcitn_hvt
+ wcit=3.9861058e-011+dwcitn_hvt                      pcit=-4.8909497e-017+dpcitn_hvt
+ voff=-0.18703495+dvoffn_hvt                         lvoff=4.8194086e-009+dlvoffn_hvt
+ wvoff=4.3270129e-009+dwvoffn_hvt                    pvoff=-7.1688904e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.13784733+deta0n_hvt
+ weta0=-1.0672373e-009+dweta0n_hvt                   etab=-0.072920178
+ wetab=-3.4519278e-009     u0=0.013762756+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-5.2659187e-011+dlu0n_hvt                       wu0=4.3537714e-010+dwu0n_hvt
+ pu0=-1.91031e-016+dpu0n_hvt                         ua=-1.0295508e-009
+ lua=-3.6661991e-018       wua=9.5952018e-018        pua=-1.7876379e-023
+ ub=1.0485198e-018         lub=-1.7375932e-26+dlubn_hvt
+ wub=5.2585054e-026        pub=1.784804e-33+dpubn_hvt
+ uc=-1.0355235e-010        luc=1.3386247e-017        wuc=1.4572133e-017
+ puc=-3.0868704e-024       vsat=115000+dvsatn_hvt    a0=1.5657779+da0n_hvt
+ kvsat=0.5                 la0=2.6872643e-007+dla0n_hvt
+ wa0=1.8342268e-007+dwa0n_hvt                        pa0=-7.4522877e-014+dpa0n_hvt
+ ags=0.77103689+dagsn_hvt  lags=2.5096012e-007+dlagsn_hvt
+ wags=1.1304952e-007+dwagsn_hvt                      pags=-3.0951192e-014+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=0.078453007          lketa=-1.5876685e-008
+ wketa=-1.2657217e-008     pketa=6.0964527e-016      dwg=0
+ dwb=0                     pclm=0.18542098+dpclmn_hvt
+ lpclm=6.7575429e-008+dlpclmn_hvt                    wpclm=5.2511651e-008+dwpclmn_hvt
+ ppclm=-6.9116899e-015+dppclmn_hvt                   pdiblc1=0
+ pdiblc2=0.0045114203      lpdiblc2=8.7835251e-011   wpdiblc2=-3.1930242e-010
+ ppdiblc2=1.2114152e-016   pdiblcb=0.88134005        drout=0.5
+ pvag=1                    delta=0.008               pscbe1=9.264e+008
+ pscbe2=1e-020             fprout=0                  pdits=0
+ pditsd=0                  pditsl=0                  rsh=16
+ rsw=55                    rdw=55                    prwg=0
+ prwb=0                    wr=1                      alpha0=4.3356e-009
+ alpha1=0.1571             beta0=9.86                agidl=4.96e-008
+ bgidl=2.2e+009            cgidl=0.459               egidl=0.1
+ aigbacc=0.013655          bigbacc=0.0068735         cigbacc=0.16236
+ nigbacc=2.35              aigbinv=0.335             bigbinv=0.0285
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0099777            bigc=1e-005               cigc=-0.1
+ aigsd=0.0094155           bigsd=0.00056771          cigsd=-0.0038
+ nigc=1                    poxedge=1                 pigcd=3.289
+ ntox=ntoxn_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgon_hvt             cgdo=cgon_hvt             cgbo=0
+ cgdl=cgln_hvt             cgsl=cgln_hvt             clc=1e-007
+ cle=0.6                   cf=cfn_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.4566               voffcv=-0.10362           kt1=-0.17658764
+ lkt1=-8.3754567e-09+dlkt1n_hvt                      wkt1=-4.3426771e-009
+ pkt1=1.0030049e-15+dpkt1n_hvt+dpkt1n_hvt            kt1l=0
+ kt2=-0.07056768           lkt2=-4.3102071e-09+dlkt2n_hvt
+ wkt2=1.6714641e-009       pkt2=4.3403027e-16+dpkt2n_hvt
+ ute=-1                    ua1=1.9471588e-009        lua1=-4.6468986e-019
+ wua1=1.9921814e-016       pua1=-5.2843089e-023      ub1=-2.1836833e-018
+ lub1=1.857851e-027+dlub1n_hvt                       wub1=-2.6004578e-025
+ pub1=5.9882182e-032       uc1=-4.9492308e-011       luc1=8.5431737e-018+dluc1n_hvt
+ wuc1=2.5558468e-017       puc1=-6.0977948e-024      prt=0
+ at=228833.09              lat=-0.027224777+dlatn_hvt
+ wat=0.0001752521          pat=-1.6547654e-010+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn_hvt        wvth0=0+dwvthn_hvt        pvth0=0+dpvthn_hvt
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt       lvsat=0+dlvsatn_hvt
+ wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt       wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     24: type=n 
+ lmin=1e-007-dxln_hvt      lmax=2.399969e-007-dxln_hvt
+ wmin=1.2e-07              wmax=3e-007-dxwn_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxn_hvt             toxm=2e-009
+ dtox=2.374e-010           epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+dxln_hvt
+ xw=1.6e-08+dxwn_hvt       dlc=2.8625e-10+ddlcn_hvt  dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.47055604+dvthn_hvt kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lvth0=-9.3337973e-011+dlvthn_hvt
+ wvth0=-1.409481e-010+dwvthn_hvt                     pvth0=2.94948e-017+dpvthn_hvt
+ k1=0.393                  k2=-0.055766473+dk2n_hvt  lk2=3.3550604e-009+dlk2n_hvt
+ wk2=2.3932567e-009+dwk2n_hvt                        pk2=-7.1479601e-017+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-4.4309391e-005+dcitn_hvt                       lcit=3.4941956e-010+dlcitn_hvt
+ wcit=-1.602633e-010+dwcitn_hvt                      pcit=-7.0314729e-018+dpcitn_hvt
+ voff=-0.17138694+dvoffn_hvt                         lvoff=1.5449062e-009+dlvoffn_hvt
+ wvoff=2.3478191e-009+dwvoffn_hvt                    pvoff=-3.0272294e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.13784733+deta0n_hvt
+ weta0=-1.0672373e-009+dweta0n_hvt                   etab=-0.068579779
+ letab=-9.0827192e-010     wetab=-4.8234931e-009     petab=2.8701376e-016
+ u0=0.015131015+du0n_hvt   ku0=-2.9e-8               pku0=2e-14
+ wku0=1.2e-7               lku0=2.2e-7               lu0=-3.3898107e-010+dlu0n_hvt
+ wu0=-4.957055e-010+dwu0n_hvt                        pu0=3.8073577e-018+dpu0n_hvt
+ ua=-8.3056211e-010        lua=-4.5306582e-017       wua=-9.4375819e-017
+ pua=3.8805965e-024        ub=8.9028477e-019         lub=1.5736321e-26+dlubn_hvt
+ wub=8.1869615e-026        pub=-4.3432832e-33+dpubn_hvt
+ uc=-6.3042578e-011        luc=4.9091729e-018        wuc=4.0442397e-018
+ puc=-8.8380352e-025       vsat=115000+dvsatn_hvt    a0=3.2011397+da0n_hvt
+ kvsat=0.5                 la0=-7.3489388e-008+dla0n_hvt
+ wa0=-2.9870304e-007+dwa0n_hvt                       pa0=2.6366751e-014+dpa0n_hvt
+ ags=1.6096865+dagsn_hvt   lags=7.5464316e-008+dlagsn_hvt
+ wags=-2.5226923e-008+dwagsn_hvt                     pags=-2.0154643e-015+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.024153737         lketa=5.5948023e-009
+ wketa=-1.5093922e-008     pketa=1.1195501e-015      dwg=0
+ dwb=0                     pclm=0.5752493+dpclmn_hvt lpclm=-1.4000046e-008+dlpclmn_hvt
+ wpclm=1.5333428e-008+dwpclmn_hvt                    ppclm=8.682251e-016+dppclmn_hvt
+ pdiblc1=0                 pdiblc2=0.0048901142      lpdiblc2=8.5897764e-012
+ wpdiblc2=4.1440456e-010   ppdiblc2=-3.2394004e-017  pdiblcb=0.88134005
+ drout=0.5                 pvag=1                    delta=0.008
+ pscbe1=9.264e+008         pscbe2=1e-020             fprout=0
+ pdits=0                   pditsd=0                  pditsl=0
+ rsh=16                    rsw=55                    rdw=55
+ prwg=0                    prwb=0                    wr=1
+ alpha0=4.3356e-009        alpha1=0.1571             beta0=9.86
+ agidl=4.96e-008           bgidl=2.2e+009            cgidl=0.459
+ egidl=0.1                 aigbacc=0.013655          bigbacc=0.0068735
+ cigbacc=0.16236           nigbacc=2.35              aigbinv=0.335
+ bigbinv=0.0285            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0099777            bigc=1e-005
+ cigc=-0.1                 aigsd=0.0094155           bigsd=0.00056771
+ cigsd=-0.0038             nigc=1                    poxedge=1
+ pigcd=3.289               ntox=ntoxn_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgon_hvt             cgdo=cgon_hvt
+ cgbo=0                    cgdl=cgln_hvt             cgsl=cgln_hvt
+ clc=1e-007                cle=0.6                   cf=cfn_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.4566               voffcv=-0.10362
+ kt1=-0.17414455           lkt1=-8.8866976e-09+dlkt1n_hvt
+ wkt1=-2.2125763e-009      pkt1=5.5726e-16+dpkt1n_hvt+dpkt1n_hvt
+ kt1l=0                    kt2=-0.096697674          lkt2=1.1577554e-09+dlkt2n_hvt
+ wkt2=4.5097472e-009       pkt2=-1.5990884e-16+dpkt2n_hvt
+ ute=-1                    ua1=1.8254947e-009        lua1=2.4994746e-017
+ wua1=7.8515179e-018       pua1=-1.279771e-023       ub1=-1.8654857e-018
+ lub1=-6.4728175e-026+dlub1n_hvt                     wub1=-6.9169442e-026
+ pub1=1.9939399e-032       uc1=1.177506e-010         luc1=-2.6454078e-017+dluc1n_hvt
+ wuc1=-2.2801529e-017      puc1=4.0220181e-024       prt=0
+ at=97677.08               lat=0.00022092876+dlatn_hvt
+ wat=0.0017901939          pat=-5.0341926e-010+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ leta0=0+dleta0n_hvt       peta0=0+dpeta0n_hvt       lvsat=0+dlvsatn_hvt
+ wvsat=0+dwvsatn_hvt       pvsat=0+dpvsatn_hvt       wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.2e-17          wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=0.00005             pku0we=-0.5e-17
+ wku0we=-4.5e-10           lku0we=0.95e-10           k2we=0.00045
+ pk2we=-0.105e-17          wk2we=0.2e-10             lk2we=-4.6e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian_hvt            noib=noibn_hvt
+ noic=noicn_hvt            em=3e+8                   ef=0.95
+ lintnoi=-1e-8             minr=1e-3
 
 
     25: type=n 
+ lmin=6e-08                lmax=1e-007-dxln_hvt      wmin=1.2e-07
+ wmax=3e-007-dxwn_hvt      version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn_hvt             toxm=2e-009               dtox=2.374e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+dxln_hvt     xw=1.6e-08+dxwn_hvt
+ dlc=2.8625e-10+ddlcn_hvt  dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.44828579+dvthn_hvt-0.0135533*ff_flag_hvt+0.0135533*ss_flag_hvt+0.0108427*sf_flag_hvt-0.0108427*fs_flag_hvt
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            lvth0=1.6475275e-009+dlvthn_hvt+1.05946e-09*ff_flag_hvt-1.05946e-09*ss_flag_hvt-8.47568e-10*sf_flag_hvt+8.47568e-10*fs_flag_hvt
+ wvth0=9.5023204e-010+dwvthn_hvt+1.84325e-09*ff_flag_hvt-1.84325e-09*ss_flag_hvt-1.4746e-09*sf_flag_hvt+1.4746e-09*fs_flag_hvt
+ pvth0=-5.5802752e-017+dpvthn_hvt-1.44087e-16*ff_flag_hvt+1.44087e-16*ss_flag_hvt+1.15269e-16*sf_flag_hvt-1.15269e-16*fs_flag_hvt
+ k1=0.393                  k2=-0.0030288049+dk2n_hvt lk2=-7.6744312e-010+dlk2n_hvt
+ wk2=-1.0232546e-009+dwk2n_hvt                       pk2=1.9558909e-016+dpk2n_hvt
+ k3=-5.3535651             k3b=2.9186544             w0=0
+ dvt0=0.4                  dvt1=0.94060682           dvt2=0.05
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=0                    voffl=0
+ dvtp0=1.5e-008            dvtp1=2.8                 lpe0=1.5e-010
+ lpeb=8e-010               xj=1.1e-007               ngate=4.7766e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0011659587+dcitn_hvt-0.00126416*ff_flag_hvt+0.00232343*ss_flag_hvt+0.00101133*sf_flag_hvt-0.00101133*fs_flag_hvt
+ lcit=2.5481291e-010+dlcitn_hvt+9.88191e-11*ff_flag_hvt-1.81622e-10*ss_flag_hvt-7.90552e-11*sf_flag_hvt+7.90552e-11*fs_flag_hvt
+ wcit=-4.1799132e-010+dwcitn_hvt+1.76426e-10*ff_flag_hvt-3.15986e-10*ss_flag_hvt-1.41141e-10*sf_flag_hvt+1.41141e-10*fs_flag_hvt
+ pcit=1.3115126e-017+dpcitn_hvt-1.37911e-17*ff_flag_hvt+2.47006e-17*ss_flag_hvt+1.10329e-17*sf_flag_hvt-1.10329e-17*fs_flag_hvt
+ voff=-0.1152964+dvoffn_hvt                          lvoff=-2.8396915e-009+dlvoffn_hvt
+ wvoff=-8.5845205e-009+dwvoffn_hvt                   pvoff=5.5185804e-016+dpvoffn_hvt
+ nfactor=0.5+dnfactorn_hvt eta0=0.1378393+deta0n_hvt-0.0174257*ff_flag_hvt+0.0290428*ss_flag_hvt+0.0139406*sf_flag_hvt-0.0139406*fs_flag_hvt
+ leta0=6.283458e-013+dleta0n_hvt+1.36216e-09*ff_flag_hvt-2.27027e-09*ss_flag_hvt-1.08973e-09*sf_flag_hvt+1.08973e-09*fs_flag_hvt
+ weta0=-1.0661441e-009+dweta0n_hvt+2.3699e-09*ff_flag_hvt-3.94983e-09*ss_flag_hvt-1.89592e-09*sf_flag_hvt+1.89592e-09*fs_flag_hvt
+ peta0=-8.5455029e-020+dpeta0n_hvt-1.85254e-16*ff_flag_hvt+3.08757e-16*ss_flag_hvt+1.48203e-16*sf_flag_hvt-1.48203e-16*fs_flag_hvt
+ etab=-0.15505678          letab=5.8516349e-009      wetab=3.2193533e-009
+ petab=-3.4169555e-016     u0=0.015049196+du0n_hvt   ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ lu0=-3.3258526e-010+dlu0n_hvt                       wu0=-8.9217931e-010+dwu0n_hvt
+ pu0=3.4799716e-017+dpu0n_hvt                        ua=-1.0071372e-009
+ lua=-3.1503708e-017       wua=-1.2702689e-016       pua=6.4329307e-024
+ ub=8.6878835e-019-2.60283e-20*ff_flag_hvt+2.08226e-20*sf_flag_hvt-2.08226e-20*fs_flag_hvt
+ lub=1.7416696e-26+2.03462e-27*ff_flag_hvt-1.6277e-27*sf_flag_hvt+1.6277e-27*fs_flag_hvt+dlubn_hvt
+ wub=9.15386e-026+4.73979e-27*ff_flag_hvt-3.79183e-27*sf_flag_hvt+3.79183e-27*fs_flag_hvt
+ pub=-5.0991078e-33-3.70508e-34*ff_flag_hvt+2.96406e-34*sf_flag_hvt-2.96406e-34*fs_flag_hvt+dpubn_hvt
+ uc=7.2417396e-011         luc=-5.6797333e-018       wuc=-2.0251558e-017
+ puc=1.015399e-024         vsat=115000+dvsatn_hvt+1188.67*ff_flag_hvt+9100.09*ss_flag_hvt-950.943*sf_flag_hvt+950.943*fs_flag_hvt
+ kvsat=0.5                 a0=4.3060979+da0n_hvt     la0=-1.5986397e-007+dla0n_hvt
+ wa0=-1.6094711e-007+dwa0n_hvt                       pa0=1.5598371e-014+dpa0n_hvt
+ ags=2.7531309+dagsn_hvt   lags=-1.3918735e-008+dlagsn_hvt
+ wags=-1.0727611e-007+dwagsn_hvt                     pags=4.3983203e-015+dpagsn_hvt
+ a1=0                      a2=0.7                    b0=0
+ b1=0                      keta=-0.034028999         lketa=6.3667515e-009
+ wketa=5.7861708e-009      pketa=-5.1264677e-016     dwg=0
+ dwb=0                     pclm=0.32770452+dpclmn_hvt-0.0968095*ss_flag_hvt
+ lpclm=5.3505304e-009+dlpclmn_hvt+7.56757e-09*ss_flag_hvt
+ wpclm=6.0976305e-008+dwpclmn_hvt+1.31661e-08*ss_flag_hvt
+ ppclm=-2.6996786e-015+dppclmn_hvt-1.02919e-15*ss_flag_hvt
+ pdiblc1=0                 pdiblc2=0.0080394882      lpdiblc2=-2.375968e-010
+ wpdiblc2=-2.6335695e-010  ppdiblc2=2.0586613e-017   pdiblcb=0.88134011
+ lpdiblcb=-4.3112321e-015  drout=0.5                 pvag=1
+ delta=0.008               pscbe1=9.264e+008         pscbe2=1e-020
+ fprout=0                  pdits=0                   pditsd=0
+ pditsl=0                  rsh=16                    rsw=55
+ rdw=55                    prwg=0                    prwb=0
+ wr=1                      alpha0=4.3356e-009        alpha1=0.1571
+ beta0=9.86                agidl=4.96e-008           bgidl=2.2e+009
+ cgidl=0.459               egidl=0.1                 aigbacc=0.013655
+ bigbacc=0.0068735         cigbacc=0.16236           nigbacc=2.35
+ aigbinv=0.335             bigbinv=0.0285            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0099777
+ bigc=1e-005               cigc=-0.1                 aigsd=0.0094155
+ bigsd=0.00056771          cigsd=-0.0038             nigc=1
+ poxedge=1                 pigcd=3.289               ntox=ntoxn_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon_hvt
+ cgdo=cgon_hvt             cgbo=0                    cgdl=cgln_hvt
+ cgsl=cgln_hvt             clc=1e-007                cle=0.6
+ cf=cfn_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.4566
+ voffcv=-0.10362           kt1=-0.29051243+0.0166659*ff_flag_hvt
+ lkt1=2.0977974e-10+dlkt1n_hvt-1.30277e-09*ff_flag_hvt
+ wkt1=8.4414473e-009-5.26643e-09*ff_flag_hvt         pkt1=-2.7556503e-16+dpkt1n_hvt+dpkt1n_hvt+4.11676e-16*ff_flag_hvt
+ kt1l=0                    kt2=-0.088925655          lkt2=5.5021667e-10+dlkt2n_hvt
+ wkt2=2.1406366e-009       pkt2=2.5284531e-17+dpkt2n_hvt
+ ute=-1                    ua1=2.6822098e-009        lua1=-4.1974672e-017
+ wua1=-2.2990124e-016      pua1=5.787423e-024        ub1=-3.2832465e-018
+ lub1=4.6098185e-026+dlub1n_hvt                      wub1=2.7352099e-025
+ pub1=-6.8487117e-033      uc1=-3.6479724e-010       luc1=1.1266687e-017+dluc1n_hvt
+ wuc1=6.02535e-017         puc1=-2.4703935e-024      prt=0
+ at=120968.14              lat=-0.0015997333+dlatn_hvt
+ wat=-0.005410237          pat=5.9438422e-011+dpatn_hvt
+ jss=1.203e-07             jsd=1.203e-07             jsws=1.666e-13
+ jswd=1.666e-13            jswgs=1.666e-13           jswgd=1.666e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=8.92                  bvd=8.92                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn_hvt               cjd=cjn_hvt               mjs=0.34
+ mjd=0.34                  pbsws=0.9                 pbswd=0.9
+ cjsws=cjswn_hvt           cjswd=cjswn_hvt           mjsws=0.06
+ mjswd=0.06                pbswgs=1.06               pbswgd=1.06
+ cjswgs=cjswgn_hvt         cjswgd=cjswgn_hvt         mjswgs=0.78
+ mjswgd=0.78               tpb=1.55e-03              tcj=8.00e-04
+ tpbsw=1.0e-03             tcjsw=3.0e-04             tpbswg=1.30e-03
+ tcjswg=1.00e-03           xtis=3                    xtid=3
+ jtsswgs=5.4e-006          jtsswgd=5.4e-006          njtsswg=14.625
+ xtsswgs=0.134             xtsswgd=0.134             tnjtsswg=0.1
+ vtsswgs=12.5              vtsswgd=12.5              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lnfactor=0+dlnfactorn_hvt wnfactor=0+dwnfactorn_hvt pnfactor=0+dpnfactorn_hvt
+ lvsat=0+dlvsatn_hvt-9.29183e-05*ff_flag_hvt-0.000711351*ss_flag_hvt+7.43346e-05*sf_flag_hvt-7.43346e-05*fs_flag_hvt
+ wvsat=0+dwvsatn_hvt-0.000131661*ff_flag_hvt-0.00123761*ss_flag_hvt+0.000105329*sf_flag_hvt-0.000105329*fs_flag_hvt
+ pvsat=0+dpvsatn_hvt+1.02919e-11*ff_flag_hvt+9.67439e-11*ss_flag_hvt-8.23349e-12*sf_flag_hvt+8.23349e-12*fs_flag_hvt
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.2e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=0.00005
+ pku0we=-0.5e-17           wku0we=-4.5e-10           lku0we=0.95e-10
+ k2we=0.00045              pk2we=-0.105e-17          wk2we=0.2e-10
+ lk2we=-4.6e-12            saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noian_hvt
+ noib=noibn_hvt            noic=noicn_hvt            em=3e+8
+ ef=0.95                      lintnoi=-1e-8             minr=1e-3
 
// *********************************************************************************************
//                                                                            
//                   *
//                                 1.0V HI-VT PMOS DEVICE MODELS              
//                     *
//                                                                            
//                   *
// *********************************************************************************************
     } 
model pch_hvt bsim4  { 
     1: type=p 
+ lmin=1e-005-dxlp_hvt      lmax=2.00001e-05          wmin=1e-005-dxwp_hvt
+ wmax=0.0009000001         version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_hvt             toxm=2.2e-009             dtox=3.219e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+dxlp_hvt     xw=1.6e-08+dxwp_hvt
+ dlc=2.134663e-08+ddlcp_hvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+dvthp_hvt    k1=0.40676                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ k2=-0.012302215+dk2p_hvt  k3=-2.86346               k3b=3.10778
+ w0=0                      dvt0=1.0197               dvt1=1.1537658
+ dvt2=0.02                 dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.515                minv=0
+ voffl=0                   dvtp0=5.65227e-009        dvtp1=0.3
+ lpe0=1.35409e-008         lpeb=0                    xj=1.1e-007
+ ngate=2.0207e+020         ndep=6.3687e+017          nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0006+dcitp_hvt      voff=-0.16201833+dvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.15192+deta0p_hvt   etab=-0.13803
+ u0=0.00875+du0p_hvt       ua=-1.3875e-010           ku0=-0.5354e-9
+ pku0=-0.5e-16             wku0=0                    lku0=-4.0055e-8
+ ub=1.2005209e-018         uc=1.3352e-010            vsat=75000+dvsatp_hvt
+ pub=0+dpubp_hvt           lub=0+dlubp_hvt           kvsat=0.5
+ a0=2.978316+da0p_hvt      ags=0.9973908+dagsp_hvt   a1=0
+ a2=1                      b0=0                      b1=0
+ keta=0.1                  dwg=0                     dwb=0
+ pclm=1.7880578+dpclmp_hvt pdiblc1=0                 pdiblc2=0.001
+ pdiblcb=0                 drout=0.5                 pvag=2.7713
+ delta=0.018               pscbe1=4.632e+008         pscbe2=5e-016
+ fprout=0                  pdits=1                   pditsd=3
+ pditsl=1300000            rsh=15.5                  rsw=203+drdswp_hvt
+ rdw=203+drdswp_hvt        prwg=0                    prwb=0
+ wr=1                      alpha0=7.45e-009          alpha1=0
+ beta0=12.21               agidl=1e-008              bgidl=2.17018e+009
+ cgidl=0.154               aigbacc=0.0125            bigbacc=0.004
+ cigbacc=0                 nigbacc=1                 aigbinv=0.01134
+ bigbinv=0.003             cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0062447            bigc=0.000459788
+ cigc=-0.033313            aigsd=0.0047986           bigsd=0.00061108
+ cigsd=0.14                nigc=1                    poxedge=1
+ pigcd=3.0117              ntox=ntoxp_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_hvt             cgdo=cgop_hvt
+ cgbo=0                    cgdl=cglp_hvt             cgsl=cglp_hvt
+ clc=1e-007                cle=0.6                   cf=cfp_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.3898               voffcv=-0.084627
+ kt1=-0.21875              pkt1=0+dpkt1p_hvt         lkt1=0+dlkt1p_hvt
+ kt1l=0                    kt2=-0.016                ute=-1
+ pkt2=0+dpkt2p_hvt         lkt2=0+dlkt2p_hvt         ua1=4.41425e-009+dua1p_hvt
+ ub1=-6e-018+dub1p_hvt     uc1=-2e-010+duc1p_hvt     prt=0
+ at=150000+datp_hvt        jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_hvt
+ wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt        lk2=0+dlk2p_hvt
+ wk2=0+dwk2p_hvt           pk2=0+dpk2p_hvt           lcit=0+dlcitp_hvt
+ wcit=0+dwcitp_hvt         pcit=0+dpcitp_hvt         lvoff=0+dlvoffp_hvt
+ wvoff=0+dwvoffp_hvt       pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt
+ weta0=0+dweta0p_hvt       peta0=0+dpeta0p_hvt       lu0=0+dlu0p_hvt
+ wu0=0+dwu0p_hvt           pu0=0+dpu0p_hvt           lvsat=0+dlvsatp_hvt
+ wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt       la0=0+dla0p_hvt
+ wa0=0+dwa0p_hvt           pa0=0+dpa0p_hvt           lags=0+dlagsp_hvt
+ wags=0+dwagsp_hvt         pags=0+dpagsp_hvt         lpclm=0+dlpclmp_hvt
+ wpclm=0+dwpclmp_hvt       ppclm=0+dppclmp_hvt       lub1=0+dlub1p_hvt
+ lua1=0+dlua1p_hvt         luc1=0+dluc1p_hvt         wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0090             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-1.8e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_hvt            noib=noibp_hvt            noic=noicp_hvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     2: type=p 
+ lmin=1.000003e-006-dxlp_hvt                         lmax=1e-005-dxlp_hvt
+ wmin=1e-005-dxwp_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=2.134663e-08+ddlcp_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.3981+dvthp_hvt    k1=0.40676
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           k2=-0.011720801+dk2p_hvt  lk2=-5.7829786e-009+dlk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00053926855+dcitp_hvt                         lcit=6.0405992e-010+dlcitp_hvt
+ voff=-0.16464335+dvoffp_hvt                         lvoff=2.610955e-008+dlvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.15192+deta0p_hvt   etab=-0.13803
+ u0=0.0088201871+du0p_hvt  ku0=-0.5354e-9            pku0=-0.5e-16
+ wku0=0                    lku0=-4.0055e-8           lu0=-6.9810979e-010+dlu0p_hvt
+ ua=-1.3756699e-010        lua=-1.1766727e-017       ub=1.2055003e-018
+ pub=0+dpubp_hvt           lub=-4.9526563e-26+dlubp_hvt
+ uc=1.4798114e-010         luc=-1.4383648e-016       vsat=75000+dvsatp_hvt
+ a0=3.0407097+da0p_hvt     kvsat=0.5                 la0=-6.205933e-007+dla0p_hvt
+ ags=0.97220461+dagsp_hvt  lags=2.5051214e-007+dlagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.11282911           lketa=-1.2760362e-007
+ dwg=0                     dwb=0                     pclm=1.7880578+dpclmp_hvt
+ pdiblc1=0                 pdiblc2=0.001             pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.21572675
+ pkt1=0+dpkt1p_hvt         lkt1=-3.0070525e-08+dlkt1p_hvt
+ kt1l=0                    kt2=-0.012007201          pkt2=0+dpkt2p_hvt
+ lkt2=-3.9714018e-08+dlkt2p_hvt                      ute=-1
+ ua1=4.5682256e-009+dua1p_hvt                        lua1=-1.5315049e-015+dlua1p_hvt
+ ub1=-6.2359171e-018+dub1p_hvt                       lub1=2.3465282e-024+dlub1p_hvt
+ uc1=-2.1085743e-010+duc1p_hvt                       luc1=1.0799241e-016+dluc1p_hvt
+ prt=0                     at=151051.57+datp_hvt     lat=-0.010459313
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt
+ pvth0=0+dpvthp_hvt        wk2=0+dwk2p_hvt           pk2=0+dpk2p_hvt
+ wcit=0+dwcitp_hvt         pcit=0+dpcitp_hvt         wvoff=0+dwvoffp_hvt
+ pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt       weta0=0+dweta0p_hvt
+ peta0=0+dpeta0p_hvt       wu0=0+dwu0p_hvt           pu0=0+dpu0p_hvt
+ lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt
+ wa0=0+dwa0p_hvt           pa0=0+dpa0p_hvt           wags=0+dwagsp_hvt
+ pags=0+dpagsp_hvt         lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0090             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-1.8e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noiap_hvt
+ noib=noibp_hvt            noic=noicp_hvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     3: type=p 
+ lmin=2.39995e-007-dxlp_hvt                          lmax=1.000003e-006-dxlp_hvt
+ wmin=1e-005-dxwp_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+dvthp_hvt    k1=0.40676                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ k2=-0.018753009+dk2p_hvt  lk2=8.7237257e-010+dlk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00085712564+dcitp_hvt                         lcit=3.0323679e-010+dlcitp_hvt
+ voff=-0.13875261+dvoffp_hvt                         lvoff=1.6062954e-009+dlvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.15192+deta0p_hvt   etab=-0.13803
+ u0=0.0082213046+du0p_hvt  ku0=-0.5354e-9            pku0=-0.5e-16
+ wku0=0                    lku0=-4.0055e-8           lu0=-1.3132137e-010+dlu0p_hvt
+ ua=-1.4704613e-010        lua=-2.7955754e-018       ub=1.2545371e-018
+ pub=0+dpubp_hvt           lub=-9.5935561e-26+dlubp_hvt
+ uc=7.8154941e-012         luc=-1.1182302e-017       vsat=75000+dvsatp_hvt+4430.81*fs_flag_hvt
+ a0=2.4488567+da0p_hvt     kvsat=0.5                 la0=-6.0457693e-008+dla0p_hvt
+ ags=0.84438156+dagsp_hvt  lags=3.7148516e-007+dlagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.022590775         lketa=5.5911509e-010
+ dwg=0                     dwb=0                     pclm=1.7880572+dpclmp_hvt
+ lpclm=6.150266e-013+dlpclmp_hvt                     pdiblc1=0
+ pdiblc2=0.00085230632     lpdiblc2=1.3977877e-010   pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.24173204
+ pkt1=0+dpkt1p_hvt         lkt1=-5.4588531e-09+dlkt1p_hvt
+ kt1l=0                    kt2=-0.053163599          pkt2=0+dpkt2p_hvt
+ lkt2=-7.6319067e-10+dlkt2p_hvt                      ute=-1
+ ua1=2.8646561e-009+dua1p_hvt                        lua1=8.0770304e-017+dlua1p_hvt
+ wua1=5.1447739e-015       pua1=-4.8690655e-021      ub1=-3.4140382e-018+dub1p_hvt
+ lub1=-3.2412622e-025+dlub1p_hvt                     wub1=-8.8503283e-024
+ pub1=8.3760392e-030       uc1=3.7134318e-011+duc1p_hvt
+ luc1=-1.2670946e-016+dluc1p_hvt                     prt=0
+ at=144414.19+datp_hvt     lat=-0.0041776326         wat=0.014959478
+ pat=-1.41578e-008         jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_hvt
+ wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt        wk2=0+dwk2p_hvt
+ pk2=0+dpk2p_hvt           wcit=0+dwcitp_hvt         pcit=0+dpcitp_hvt
+ wvoff=0+dwvoffp_hvt       pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt
+ weta0=0+dweta0p_hvt       peta0=0+dpeta0p_hvt       wu0=0+dwu0p_hvt
+ pu0=0+dpu0p_hvt           lvsat=0+dlvsatp_hvt-0.00419336*fs_flag_hvt
+ wvsat=0+dwvsatp_hvt+0.0*fs_flag_hvt                 pvsat=0+dpvsatp_hvt+0.0*fs_flag_hvt
+ wa0=0+dwa0p_hvt           pa0=0+dpa0p_hvt           wags=0+dwagsp_hvt
+ pags=0+dpagsp_hvt         wpclm=0+dwpclmp_hvt       ppclm=0+dppclmp_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_hvt            noib=noibp_hvt
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     4: type=p 
+ lmin=9.99969e-008-dxlp_hvt                          lmax=2.39995e-007-dxlp_hvt
+ wmin=1e-005-dxwp_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.39419819+dvthp_hvt                          kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ lvth0=-8.4205054e-010+dlvthp_hvt                    k1=0.40676
+ k2=-0.012693503+dk2p_hvt  lk2=-4.3532929e-010+dlk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00058879152+dcitp_hvt                         lcit=3.6114598e-010+dlcitp_hvt
+ voff=-0.12317926+dvoffp_hvt                         lvoff=-1.7545894e-009+dlvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.151918+deta0p_hvt  leta0=4.3189198e-013+dleta0p_hvt
+ etab=-0.13802694          letab=-6.609917e-013      u0=0.0076818977+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           lu0=-1.4911973e-011+dlu0p_hvt
+ ua=-1.2937159e-010        lua=-6.609917e-018        ub=1.0063218e-018
+ pub=0+dpubp_hvt           lub=-4.2368214e-26+dlubp_hvt
+ uc=-1.3371591e-011        luc=-6.609917e-018        vsat=75000+dvsatp_hvt-24188.5*fs_flag_hvt
+ a0=3.0033154+da0p_hvt     kvsat=0.5                 la0=-1.8011542e-007+dla0p_hvt
+ ags=3.1266842+dagsp_hvt   lags=-1.2105857e-007+dlagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.017500948         lketa=-5.3932042e-010
+ dwg=0                     dwb=0                     pclm=1.78806+dpclmp_hvt
+ pdiblc1=0                 pdiblc2=-0.00033770455    lpdiblc2=3.9659502e-010
+ pdiblcb=0                 drout=0.5                 pvag=2.7713
+ delta=0.018               pscbe1=4.632e+008         pscbe2=5e-016
+ fprout=0                  pdits=1                   pditsd=3
+ pditsl=1300000            rsh=15.5                  rsw=203+drdswp_hvt
+ rdw=203+drdswp_hvt        prwg=0                    prwb=0
+ wr=1                      alpha0=7.45e-009          alpha1=0
+ beta0=12.21               agidl=1e-008              bgidl=2.17018e+009
+ cgidl=0.154               aigbacc=0.0125            bigbacc=0.004
+ cigbacc=0                 nigbacc=1                 aigbinv=0.01134
+ bigbinv=0.003             cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0062447            bigc=0.000459788
+ cigc=-0.033313            aigsd=0.0047986           bigsd=0.00061108
+ cigsd=0.14                nigc=1                    poxedge=1
+ pigcd=3.0117              ntox=ntoxp_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_hvt             cgdo=cgop_hvt
+ cgbo=0                    cgdl=cglp_hvt             cgsl=cglp_hvt
+ clc=1e-007                cle=0.6                   cf=cfp_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.3898               voffcv=-0.084627
+ kt1=-0.24615458           pkt1=0+dpkt1p_hvt         lkt1=-4.5044258e-09+dlkt1p_hvt
+ kt1l=0                    kt2=-0.055171765          pkt2=0+dpkt2p_hvt
+ lkt2=-3.2980842e-10+dlkt2p_hvt                      ute=-1
+ ua1=4.6563569e-009+dua1p_hvt                        lua1=-3.0589664e-016+dlua1p_hvt
+ wua1=-2.8086168e-014      pua1=2.302504e-021        ub1=-7.2687835e-018+dub1p_hvt
+ lub1=5.0776638e-025+dlub1p_hvt                      wub1=4.8315399e-023
+ pub1=-3.9608964e-030      uc1=-7.2615707e-010+duc1p_hvt
+ luc1=3.8016457e-017+dluc1p_hvt                      prt=0
+ at=163682.53+datp_hvt     lat=-0.0083359342         wat=-0.081666253
+ pat=6.6949994e-009        jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             wvth0=0+dwvthp_hvt
+ pvth0=0+dpvthp_hvt        wk2=0+dwk2p_hvt           pk2=0+dpk2p_hvt
+ wcit=0+dwcitp_hvt         pcit=0+dpcitp_hvt         wvoff=0+dwvoffp_hvt
+ pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt weta0=0+dweta0p_hvt       peta0=0+dpeta0p_hvt
+ wu0=0+dwu0p_hvt           pu0=0+dpu0p_hvt           lvsat=0+dlvsatp_hvt+0.00198297*fs_flag_hvt
+ wvsat=0+dwvsatp_hvt+0.0*fs_flag_hvt                 pvsat=0+dpvsatp_hvt+0.0*fs_flag_hvt
+ wa0=0+dwa0p_hvt           pa0=0+dpa0p_hvt           wags=0+dwagsp_hvt
+ pags=0+dpagsp_hvt         lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0090             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-1.8e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noiap_hvt
+ noib=noibp_hvt            noic=noicp_hvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     5: type=p 
+ lmin=6e-08                lmax=9.99969e-008-dxlp_hvt
+ wmin=1e-005-dxwp_hvt      wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.38876369+dvthp_hvt-0.00806759*ff_flag_hvt-0.00345754*ss_flag_hvt-0.00645407*sf_flag_hvt+0.00645407*fs_flag_hvt
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           lvth0=-1.2875708e-009+dlvthp_hvt+6.61381e-10*ff_flag_hvt+2.83449e-10*ss_flag_hvt+5.29105e-10*sf_flag_hvt-5.29105e-10*fs_flag_hvt
+ k1=0.40676                k2=0.0043461096+dk2p_hvt  lk2=-1.8322367e-009+dlk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0037626862+dcitp_hvt+0.00129081*ff_flag_hvt-0.000161352*ss_flag_hvt+0.00103265*sf_flag_hvt-0.00103265*fs_flag_hvt
+ lcit=1.0095009e-010+dlcitp_hvt-1.05821e-10*ff_flag_hvt+1.32276e-11*ss_flag_hvt-8.46567e-11*sf_flag_hvt+8.46567e-11*fs_flag_hvt
+ voff=-0.10108139+dvoffp_hvt                         lvoff=-3.5661732e-009+dlvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.075350424+deta0p_hvt+0.0161352*ff_flag_hvt+0.0129081*sf_flag_hvt-0.0129081*fs_flag_hvt
+ leta0=6.2774417e-009+dleta0p_hvt-1.32276e-09*ff_flag_hvt-1.05821e-09*sf_flag_hvt+1.05821e-09*fs_flag_hvt
+ etab=-0.25583272          letab=9.6570574e-009      u0=0.0080761355+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           lu0=-4.7231586e-011+dlu0p_hvt
+ ua=3.1976897e-011         lua=-1.9837266e-017       ub=5.0911065e-019-1.15251e-20*ff_flag_hvt-2.76603e-20*ss_flag_hvt-9.22011e-21*sf_flag_hvt+9.22011e-21*fs_flag_hvt
+ pub=0+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt+dpubp_hvt
+ wub=0+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ lub=-1.6068412e-27+9.4483e-28*ff_flag_hvt+2.26759e-27*ss_flag_hvt+7.55864e-28*sf_flag_hvt-7.55864e-28*fs_flag_hvt+dlubp_hvt
+ uc=-5.5763139e-011        luc=-3.1346579e-018       vsat=75000+dvsatp_hvt
+ kvsat=0.5                 a0=-2.6001452+da0p_hvt-1.38302*ff_flag_hvt+0.922011*ss_flag_hvt-1.10641*sf_flag_hvt+1.10641*fs_flag_hvt
+ la0=2.7925628e-007+dla0p_hvt+1.1338e-07*ff_flag_hvt-7.55864e-08*ss_flag_hvt+9.07037e-08*sf_flag_hvt-9.07037e-08*fs_flag_hvt
+ ags=2.1685219+dagsp_hvt   lags=-4.2508427e-008+dlagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.031085013         lketa=5.7430121e-010
+ dwg=0                     dwb=0                     pclm=1.7880625+dpclmp_hvt
+ lpclm=-2.0781898e-013+dlpclmp_hvt                   pdiblc1=0
+ pdiblc2=0.0049099204      lpdiblc2=-3.3605273e-011  pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.30922178
+ pkt1=0+dpkt1p_hvt         lkt1=6.6582366e-10+dlkt1p_hvt
+ kt1l=0                    kt2=-0.054810179          pkt2=0+dpkt2p_hvt
+ lkt2=-3.5945126e-10+dlkt2p_hvt                      ute=-1
+ ua1=1.0834373e-009+dua1p_hvt                        lua1=-1.2988686e-017+dlua1p_hvt
+ ub1=-1.2715774e-018+dub1p_hvt                       lub1=1.6115417e-026+dlub1p_hvt
+ uc1=-5.1431533e-010+duc1p_hvt                       luc1=2.0649671e-017+dluc1p_hvt
+ prt=0                     at=108090.84+datp_hvt     lat=-0.0037785269
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             wvth0=0+dwvthp_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pvth0=0+dpvthp_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ wk2=0+dwk2p_hvt           pk2=0+dpk2p_hvt           wcit=0+dwcitp_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pcit=0+dpcitp_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ wvoff=0+dwvoffp_hvt       pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt weta0=0+dweta0p_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ peta0=0+dpeta0p_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ wu0=0+dwu0p_hvt           pu0=0+dpu0p_hvt           lvsat=0+dlvsatp_hvt
+ wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt       wa0=0+dwa0p_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pa0=0+dpa0p_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ wags=0+dwagsp_hvt         pags=0+dpagsp_hvt         wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0090             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-1.8e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noiap_hvt
+ noib=noibp_hvt            noic=noicp_hvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     6: type=p 
+ lmin=1e-005-dxlp_hvt      lmax=2.00001e-05          wmin=1e-006-dxwp_hvt
+ wmax=1e-005-dxwp_hvt      version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_hvt             toxm=2.2e-009             dtox=3.219e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+dxlp_hvt     xw=1.6e-08+dxwp_hvt
+ dlc=2.134663e-08+ddlcp_hvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+dvthp_hvt    k1=0.40676                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ k2=-0.012113716+dk2p_hvt  wk2=-1.8880098e-009+dwk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00051098746+dcitp_hvt                         wcit=8.9154962e-010+dwcitp_hvt
+ voff=-0.16313582+dvoffp_hvt                         wvoff=1.1192787e-008+dwvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.15250025+deta0p_hvt
+ weta0=-5.8117729e-009+dweta0p_hvt                   etab=-0.14304283
+ wetab=5.0208516e-008      u0=0.0087104889+du0p_hvt  ku0=-0.5354e-9
+ pku0=-0.5e-16             wku0=0                    lku0=-4.0055e-8
+ wu0=3.9574329e-010+dwu0p_hvt                        ua=-1.3409333e-010
+ wua=-4.6641173e-017       ub=1.2197146e-018         pub=0+dpubp_hvt
+ lub=0+dlubp_hvt           wub=-1.9224371e-025       uc=1.305307e-010
+ wuc=2.9940807e-017        vsat=75000+dvsatp_hvt     kvsat=0.5
+ a0=2.9483366+da0p_hvt-0.0135467*ff_flag_hvt+0.0112889*ss_flag_hvt-0.0108373*sf_flag_hvt+0.0108373*fs_flag_hvt
+ wa0=3.0027405e-007+dwa0p_hvt+1.35683e-07*ff_flag_hvt-1.1307e-07*ss_flag_hvt+1.08547e-07*sf_flag_hvt-1.08547e-07*fs_flag_hvt
+ ags=1.0112325+dagsp_hvt-0.0135467*ff_flag_hvt-0.0108373*sf_flag_hvt+0.0108373*fs_flag_hvt
+ wags=-1.3863826e-007+dwagsp_hvt+1.35683e-07*ff_flag_hvt+1.08547e-07*sf_flag_hvt-1.08547e-07*fs_flag_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.1                  dwg=0
+ dwb=0                     pclm=1.7880578+dpclmp_hvt pdiblc1=0
+ pdiblc2=0.001             pdiblcb=0                 drout=0.5
+ pvag=2.7713               delta=0.018               pscbe1=4.632e+008
+ pscbe2=5e-016             fprout=0                  pdits=1
+ pditsd=3                  pditsl=1300000            rsh=15.5
+ rsw=203+drdswp_hvt        rdw=203+drdswp_hvt        prwg=0
+ prwb=0                    wr=1                      alpha0=7.45e-009
+ alpha1=0                  beta0=12.21               agidl=1e-008
+ bgidl=2.17018e+009        cgidl=0.154               aigbacc=0.0125
+ bigbacc=0.004             cigbacc=0                 nigbacc=1
+ aigbinv=0.01134           bigbinv=0.003             cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0062447
+ bigc=0.000459788          cigc=-0.033313            aigsd=0.0047986
+ bigsd=0.00061108          cigsd=0.14                nigc=1
+ poxedge=1                 pigcd=3.0117              ntox=ntoxp_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_hvt
+ cgdo=cgop_hvt             cgbo=0                    cgdl=cglp_hvt
+ cgsl=cglp_hvt             clc=1e-007                cle=0.6
+ cf=cfp_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.3898
+ voffcv=-0.084627          kt1=-0.2171625            pkt1=0+dpkt1p_hvt
+ lkt1=0+dlkt1p_hvt         wkt1=-1.59004e-008        kt1l=0
+ kt2=-0.015096889          pkt2=0+dpkt2p_hvt         lkt2=0+dlkt2p_hvt
+ wkt2=-9.0455609e-009      ute=-1                    ua1=4.3989253e-009+dua1p_hvt
+ wua1=1.5349186e-016       ub1=-6e-018+dub1p_hvt     uc1=-2.1806222e-010+duc1p_hvt
+ wuc1=1.8091122e-016       prt=0                     at=150000+datp_hvt
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt
+ pvth0=0+dpvthp_hvt        lk2=0+dlk2p_hvt           pk2=0+dpk2p_hvt
+ lcit=0+dlcitp_hvt         pcit=0+dpcitp_hvt         lvoff=0+dlvoffp_hvt
+ pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt       peta0=0+dpeta0p_hvt
+ lu0=0+dlu0p_hvt           pu0=0+dpu0p_hvt           lvsat=0+dlvsatp_hvt
+ wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt       la0=0+dla0p_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pa0=0+dpa0p_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ lags=0+dlagsp_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pags=0+dpagsp_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt       ppclm=0+dppclmp_hvt
+ lub1=0+dlub1p_hvt         lua1=0+dlua1p_hvt         luc1=0+dluc1p_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_hvt            noib=noibp_hvt
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     7: type=p 
+ lmin=1.000003e-006-dxlp_hvt                         lmax=1e-005-dxlp_hvt
+ wmin=1e-006-dxwp_hvt      wmax=1e-005-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=2.134663e-08+ddlcp_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.3981+dvthp_hvt    k1=0.40676
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           k2=-0.011543545+dk2p_hvt  lk2=-5.6711549e-009+dlk2p_hvt
+ wk2=-1.7754037e-009+dwk2p_hvt                       pk2=-1.1200267e-015+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00044237487+dcitp_hvt                         lcit=6.824489e-010+dlcitp_hvt
+ wcit=9.7048705e-010+dwcitp_hvt                      pcit=-7.8514401e-016+dpcitp_hvt
+ voff=-0.16588537+dvoffp_hvt                         lvoff=2.7348133e-008+dlvoffp_hvt
+ wvoff=1.2440036e-008+dwvoffp_hvt                    pvoff=-1.240565e-014+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.15250025+deta0p_hvt
+ weta0=-5.8117729e-009+dweta0p_hvt                   etab=-0.14304283
+ wetab=5.0208516e-008      u0=0.0087828172+du0p_hvt  ku0=-0.5354e-9
+ pku0=-0.5e-16             wku0=0                    lku0=-4.0055e-8
+ lu0=-7.1940738e-010+dlu0p_hvt                       wu0=3.7429669e-010+dwu0p_hvt
+ pu0=2.1331664e-016+dpu0p_hvt                        ua=-1.3277677e-010
+ lua=-1.309506e-017        wua=-4.79788e-017         pua=1.3304581e-023
+ ub=1.2269124e-018         lub=-7.1592493e-26+dlubp_hvt
+ wub=-2.1446403e-025       pub=2.2101235e-31+dpubp_hvt
+ uc=1.4439061e-010         luc=-1.3785632e-016       wuc=3.5962802e-017
+ puc=-5.989724e-023        vsat=75000+dvsatp_hvt     kvsat=0.5
+ a0=3.0091863+da0p_hvt-0.0149712*ff_flag_hvt+0.012476*ss_flag_hvt-0.011977*sf_flag_hvt+0.011977*fs_flag_hvt
+ la0=-6.0523641e-007+dla0p_hvt+1.41689e-08*ff_flag_hvt-1.18074e-08*ss_flag_hvt+1.13351e-08*sf_flag_hvt-1.13351e-08*fs_flag_hvt
+ wa0=3.1573838e-007+dwa0p_hvt+1.49951e-07*ff_flag_hvt-1.2496e-07*ss_flag_hvt+1.19961e-07*sf_flag_hvt-1.19961e-07*fs_flag_hvt
+ pa0=-1.5381456e-013+dpa0p_hvt-1.41915e-13*ff_flag_hvt+1.18263e-13*ss_flag_hvt-1.13532e-13*sf_flag_hvt+1.13532e-13*fs_flag_hvt
+ ags=0.98756752+dagsp_hvt-0.0149712*ff_flag_hvt-0.011977*sf_flag_hvt+0.011977*fs_flag_hvt
+ lags=2.3538141e-007+dlagsp_hvt+1.41689e-08*ff_flag_hvt+1.13351e-08*sf_flag_hvt-1.13351e-08*fs_flag_hvt
+ wags=-1.5387485e-007+dwagsp_hvt+1.49951e-07*ff_flag_hvt+1.19961e-07*sf_flag_hvt-1.19961e-07*fs_flag_hvt
+ pags=1.5154938e-013+dpagsp_hvt-1.41915e-13*ff_flag_hvt-1.13532e-13*sf_flag_hvt+1.13532e-13*fs_flag_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.11309028           lketa=-1.3020125e-007
+ wketa=-2.6158028e-009     pketa=2.6017847e-014      dwg=0
+ dwb=0                     pclm=1.7880578+dpclmp_hvt pdiblc1=0
+ pdiblc2=0.001             pdiblcb=0                 drout=0.5
+ pvag=2.7713               delta=0.018               pscbe1=4.632e+008
+ pscbe2=5e-016             fprout=0                  pdits=1
+ pditsd=3                  pditsl=1300000            rsh=15.5
+ rsw=203+drdswp_hvt        rdw=203+drdswp_hvt        prwg=0
+ prwb=0                    wr=1                      alpha0=7.45e-009
+ alpha1=0                  beta0=12.21               agidl=1e-008
+ bgidl=2.17018e+009        cgidl=0.154               aigbacc=0.0125
+ bigbacc=0.004             cigbacc=0                 nigbacc=1
+ aigbinv=0.01134           bigbinv=0.003             cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0062447
+ bigc=0.000459788          cigc=-0.033313            aigsd=0.0047986
+ bigsd=0.00061108          cigsd=0.14                nigc=1
+ poxedge=1                 pigcd=3.0117              ntox=ntoxp_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_hvt
+ cgdo=cgop_hvt             cgbo=0                    cgdl=cglp_hvt
+ cgsl=cglp_hvt             clc=1e-007                cle=0.6
+ cf=cfp_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.3898
+ voffcv=-0.084627          kt1=-0.21389441           lkt1=-3.2505802e-08+dlkt1p_hvt
+ wkt1=-1.8352715e-008      pkt1=2.4391732e-14+dpkt1p_hvt
+ kt1l=0                    kt2=-0.011062897          lkt2=-4.0123735e-08+dlkt2p_hvt
+ wkt2=-9.4581449e-009      pkt2=4.1037302e-15+dpkt2p_hvt
+ ute=-1                    ua1=4.5596066e-009+dua1p_hvt
+ lua1=-1.598202e-015+dlua1p_hvt                      wua1=8.6328151e-017
+ pua1=6.680378e-022        ub1=-6.2481856e-018+dub1p_hvt
+ lub1=2.4685556e-024+dlub1p_hvt                      wub1=1.2288115e-025
+ pub1=-1.2222263e-030      uc1=-2.3014533e-010+duc1p_hvt
+ luc1=1.2018355e-016+dluc1p_hvt                      wuc1=1.9318766e-016
+ puc1=-1.2210649e-022      prt=0                     at=151027.82+datp_hvt
+ lat=-0.010223165          wat=0.00023780026         pat=-2.3652589e-009
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt
+ pvth0=0+dpvthp_hvt        lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt       peta0=0+dpeta0p_hvt
+ lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt
+ lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt       ppclm=0+dppclmp_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_hvt            noib=noibp_hvt
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     8: type=p 
+ lmin=2.39995e-007-dxlp_hvt                          lmax=1.000003e-006-dxlp_hvt
+ wmin=1e-006-dxwp_hvt      wmax=1e-005-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+dvthp_hvt    k1=0.40676                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ k2=-0.018464151+dk2p_hvt  lk2=8.7857572e-010+dlk2p_hvt
+ wk2=-2.8932024e-009+dwk2p_hvt                       pk2=-6.213081e-017+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00083420494+dcitp_hvt+2.00076e-05*ff_flag_hvt-1.00038e-05*ss_flag_hvt
+ lcit=3.1161701e-010+dlcitp_hvt-1.89354e-11*ff_flag_hvt+9.46768e-12*ss_flag_hvt
+ wcit=2.2957373e-010+dwcitp_hvt-2.00396e-10*ff_flag_hvt+1.00198e-10*ss_flag_hvt
+ pcit=-8.393624e-017+dpcitp_hvt+1.89657e-16*ff_flag_hvt-9.48283e-17*ss_flag_hvt
+ voff=-0.13871049+dvoffp_hvt                         lvoff=1.6295586e-009+dlvoffp_hvt
+ wvoff=-4.218807e-010+dwvoffp_hvt                    pvoff=-2.3300358e-016+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.15250025+deta0p_hvt
+ weta0=-5.8117729e-009+dweta0p_hvt                   etab=-0.14304283
+ wetab=5.0208516e-008      u0=0.0081573064+du0p_hvt  ku0=-0.5354e-9
+ pku0=-0.5e-16             wku0=0                    lku0=-4.0055e-8
+ lu0=-1.2741771e-010+dlu0p_hvt                       wu0=6.4100534e-010+dwu0p_hvt
+ pu0=-3.9099088e-017+dpu0p_hvt                       ua=-1.43326e-010
+ lua=-3.1111649e-018       wua=-3.7260784e-017       pua=3.1609435e-024
+ ub=1.2498521e-018         lub=-9.3302849e-26+dlubp_hvt
+ wub=4.6925438e-026        pub=-2.6369248e-32+dpubp_hvt
+ uc=1.0029941e-011         luc=-1.0696039e-017       wuc=-2.2179898e-017
+ puc=-4.870407e-024        vsat=75000+dvsatp_hvt+4931*fs_flag_hvt
+ kvsat=0.5                 a0=2.4174157+da0p_hvt+0.0100038*ff_flag_hvt+0.00800303*sf_flag_hvt-0.00800303*fs_flag_hvt
+ la0=-4.5178803e-008+dla0p_hvt-9.46768e-09*ff_flag_hvt-7.57415e-09*sf_flag_hvt+7.57415e-09*fs_flag_hvt
+ wa0=3.1491296e-007+dwa0p_hvt-1.00198e-07*ff_flag_hvt-8.01584e-08*sf_flag_hvt+8.01584e-08*fs_flag_hvt
+ pa0=-1.5303336e-013+dpa0p_hvt+9.48283e-14*ff_flag_hvt+7.58627e-14*sf_flag_hvt-7.58627e-14*fs_flag_hvt
+ ags=0.82390721+dagsp_hvt  lags=3.9027116e-007+dlagsp_hvt
+ wags=2.0507104e-007+dwagsp_hvt                      pags=-1.881606e-013+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.026908358         lketa=2.2948568e-009
+ wketa=4.3244909e-008      pketa=-1.7385189e-014     dwg=0
+ dwb=0                     pclm=1.7880571+dpclmp_hvt lpclm=6.8445627e-013+dlpclmp_hvt
+ wpclm=7.3478468e-013+dwpclmp_hvt                    ppclm=-6.9540757e-019+dppclmp_hvt
+ pdiblc1=0                 pdiblc2=0.00083980159     lpdiblc2=1.5161338e-010
+ wpdiblc2=1.2524739e-010   ppdiblc2=-1.1853538e-016  pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.24212393
+ lkt1=-5.789094e-09+dlkt1p_hvt                       wkt1=3.9251967e-009
+ pkt1=3.3076935e-15+dpkt1p_hvt                       kt1l=0
+ kt2=-0.052477814          lkt2=-9.2824377e-10+dlkt2p_hvt
+ wkt2=-6.868825e-009       pkt2=1.6531718e-15+dpkt2p_hvt
+ ute=-1                    ua1=3.2725213e-009+dua1p_hvt
+ lua1=-3.8009156e-016+dlua1p_hvt                     wua1=1.0595964e-015
+ pua1=-2.5307304e-022      ub1=-4.1394217e-018+dub1p_hvt
+ lub1=4.7280036e-025+dlub1p_hvt                      wub1=-1.5848871e-024
+ pub1=3.9402263e-031       uc1=4.5841925e-011+duc1p_hvt
+ luc1=-1.4101355e-016+dluc1p_hvt                     wuc1=-8.7215396e-017
+ puc1=1.4326976e-022       prt=0                     at=146136.73+datp_hvt
+ lat=-0.0055941806         wat=-0.0022934536         pat=3.0345058e-011
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt
+ pvth0=0+dpvthp_hvt        lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt       peta0=0+dpeta0p_hvt
+ lvsat=0+dlvsatp_hvt-0.00466675*fs_flag_hvt          wvsat=0+dwvsatp_hvt-0.0050099*fs_flag_hvt
+ pvsat=0+dpvsatp_hvt+4.74142e-09*fs_flag_hvt         wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0090             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-1.8e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_hvt            noib=noibp_hvt            noic=noicp_hvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     9: type=p 
+ lmin=9.99969e-008-dxlp_hvt                          lmax=2.39995e-007-dxlp_hvt
+ wmin=1e-006-dxwp_hvt      wmax=1e-005-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.39419819+dvthp_hvt                          kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ lvth0=-8.4205054e-010+dlvthp_hvt                    k1=0.40676
+ k2=-0.012198233+dk2p_hvt  lk2=-4.7367196e-010+dlk2p_hvt
+ wk2=-4.9606276e-009+dwk2p_hvt                       pk2=3.8404021e-016+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00050750812+dcitp_hvt-5.3903e-05*ff_flag_hvt+3.38667e-05*ss_flag_hvt
+ lcit=3.8212145e-010+dlcitp_hvt-2.98478e-12*ff_flag_hvt-2e-18*ss_flag_hvt
+ wcit=8.1413453e-010+dwcitp_hvt+5.39891e-10*ff_flag_hvt-3.39209e-10*ss_flag_hvt
+ pcit=-2.1009031e-016+dpcitp_hvt+2.98955e-17*ff_flag_hvt-4.6e-23*ss_flag_hvt
+ voff=-0.12276584+dvoffp_hvt                         lvoff=-1.8114554e-009+dlvoffp_hvt
+ wvoff=-4.1407731e-009+dwvoffp_hvt                   pvoff=5.6957059e-016+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.15249779+deta0p_hvt
+ leta0=5.301647e-013+dleta0p_hvt                     weta0=-5.8072119e-009+dweta0p_hvt
+ peta0=-9.8429957e-019+dpeta0p_hvt                   etab=-0.14303942
+ letab=-7.3561032e-013     wetab=5.0205053e-008      petab=7.4738008e-019
+ u0=0.0076286108+du0p_hvt  ku0=-0.5354e-9            pku0=-0.5e-16
+ wku0=0                    lku0=-4.0055e-8           lu0=-1.3319902e-011+dlu0p_hvt
+ wu0=5.3372157e-010+dwu0p_hvt                        pu0=-1.5946179e-017+dpu0p_hvt
+ ua=-1.3467214e-010        lua=-4.978754e-018        wua=5.3090322e-017
+ pua=-1.6337729e-023       ub=1.0214325e-018         lub=-4.4007619e-26+dlubp_hvt
+ wub=-1.5134863e-025       pub=1.6420278e-32+dpubp_hvt
+ uc=-8.4796565e-012        luc=-6.7014829e-018       wuc=-4.8997614e-017
+ puc=9.1712413e-025        vsat=75000+dvsatp_hvt-26919.1*fs_flag_hvt
+ kvsat=0.5                 a0=3.1179539+da0p_hvt-0.0753579*ff_flag_hvt-0.0207456*ss_flag_hvt-0.0602863*sf_flag_hvt+0.0602863*fs_flag_hvt
+ la0=-1.9636195e-007+dla0p_hvt+8.95422e-09*ff_flag_hvt+4.47711e-09*ss_flag_hvt+7.16338e-09*sf_flag_hvt-7.16338e-09*fs_flag_hvt
+ wa0=-1.1482194e-006+dwa0p_hvt+7.54785e-07*ff_flag_hvt+2.07788e-07*ss_flag_hvt+6.03827e-07*sf_flag_hvt-6.03827e-07*fs_flag_hvt
+ pa0=1.6272524e-013+dpa0p_hvt-8.96856e-14*ff_flag_hvt-4.48428e-14*ss_flag_hvt-7.17484e-14*sf_flag_hvt+7.17484e-14*fs_flag_hvt
+ ags=3.2444128+dagsp_hvt   lags=-1.3209816e-007+dlagsp_hvt
+ wags=-1.1791705e-006+dwagsp_hvt                     pags=1.1057255e-013+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.012684489         lketa=-7.7479634e-010
+ wketa=-4.8241658e-008     pketa=2.3585269e-015      dwg=0
+ dwb=0                     pclm=1.7785133+dpclmp_hvt+0.000691521*ss_flag_hvt
+ lpclm=2.0603365e-009+dlpclmp_hvt-1.49237e-10*ss_flag_hvt
+ wpclm=9.562019e-008+dwpclmp_hvt-6.92627e-09*ss_flag_hvt
+ ppclm=-2.063633e-014+dppclmp_hvt+1.49476e-15*ss_flag_hvt
+ pdiblc1=0                 pdiblc2=-0.0004463064     lpdiblc2=4.2916834e-010
+ wpdiblc2=1.0877561e-009   ppdiblc2=-3.2625439e-016  pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.2487196
+ lkt1=-4.3656835e-09+dlkt1p_hvt                      wkt1=2.5691269e-008
+ pkt1=-1.3896427e-15+dpkt1p_hvt                      kt1l=0
+ kt2=-0.055334524          lkt2=-3.1173726e-10+dlkt2p_hvt
+ wkt2=1.6301907e-009       pkt2=-1.8100073e-16+dpkt2p_hvt
+ ute=-1                    ua1=1.9149371e-009+dua1p_hvt
+ lua1=-8.7111326e-017+dlua1p_hvt                     wua1=-6.2810758e-016
+ pua1=1.1115037e-022       ub1=-2.537339e-018+dub1p_hvt
+ lub1=1.2705489e-025+dlub1p_hvt                      wub1=9.2525059e-025
+ pub1=-1.4769019e-031      uc1=-8.0361658e-010+duc1p_hvt
+ luc1=4.2308093e-017+dluc1p_hvt                      wuc1=7.7583444e-016
+ puc1=-4.2985022e-023      prt=0                     at=154492.52+datp_hvt
+ lat=-0.007397444          wat=0.01038095            pat=-2.704918e-009
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt
+ lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt
+ lvsat=0+dlvsatp_hvt+0.00220683*fs_flag_hvt          wvsat=0+dwvsatp_hvt+0.0273498*fs_flag_hvt
+ pvsat=0+dpvsatp_hvt-2.24214e-09*fs_flag_hvt         wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0090             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-1.8e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_hvt            noib=noibp_hvt            noic=noicp_hvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     10: type=p 
+ lmin=6e-08                lmax=9.99969e-008-dxlp_hvt
+ wmin=1e-006-dxwp_hvt      wmax=1e-005-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.38876369+dvthp_hvt-0.00897833*ff_flag_hvt-0.00384786*ss_flag_hvt-0.00718267*sf_flag_hvt+0.00718267*fs_flag_hvt
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           lvth0=-1.2875708e-009+dlvthp_hvt+7.36043e-10*ff_flag_hvt+3.15447e-10*ss_flag_hvt+5.88835e-10*sf_flag_hvt-5.88835e-10*fs_flag_hvt
+ k1=0.40676                k2=0.004960528+dk2p_hvt   lk2=-1.8803472e-009+dlk2p_hvt
+ wk2=-6.1540148e-009+dwk2p_hvt                       pk2=4.818741e-016+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0041756206+dcitp_hvt+0.00126945*ff_flag_hvt-0.000106669*ss_flag_hvt+0.00117109*sf_flag_hvt-0.00117109*fs_flag_hvt
+ lcit=8.1409581e-011+dlcitp_hvt-1.11474e-10*ff_flag_hvt+1.15211e-11*ss_flag_hvt-9.60055e-11*sf_flag_hvt+9.60055e-11*fs_flag_hvt
+ wcit=-4.1359515e-009+dwcitp_hvt+2.13889e-10*ff_flag_hvt-5.47711e-10*ss_flag_hvt-1.38653e-09*sf_flag_hvt+1.38653e-09*fs_flag_hvt
+ pcit=1.9571775e-016+dpcitp_hvt+5.66199e-17*ff_flag_hvt+1.7093e-17*ss_flag_hvt+1.13669e-16*sf_flag_hvt-1.13669e-16*fs_flag_hvt
+ voff=-0.099247874+dvoffp_hvt                        lvoff=-3.7394587e-009+dlvoffp_hvt
+ wvoff=-1.8364448e-008+dwvoffp_hvt                   pvoff=1.7356275e-015+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.074054655+deta0p_hvt+0.0179567*ff_flag_hvt+0.0143653*sf_flag_hvt-0.0143653*fs_flag_hvt
+ leta0=6.4312985e-009+dleta0p_hvt-1.47209e-09*ff_flag_hvt-1.17767e-09*sf_flag_hvt+1.17767e-09*fs_flag_hvt
+ weta0=1.2978415e-008+dweta0p_hvt-1.8244e-08*ff_flag_hvt-1.45952e-08*sf_flag_hvt+1.45952e-08*fs_flag_hvt
+ peta0=-1.54103e-015+dpeta0p_hvt+1.49564e-15*ff_flag_hvt+1.19651e-15*sf_flag_hvt-1.19651e-15*fs_flag_hvt
+ etab=-0.26580273          letab=1.00634e-008        wetab=9.9859571e-008
+ petab=-4.06993e-015       u0=0.0080032452+du0p_hvt  ku0=-0.5354e-9
+ pku0=-0.5e-16             wku0=0                    lku0=-4.0055e-8
+ lu0=-4.4032433e-011+dlu0p_hvt                       wu0=7.3006867e-010+dwu0p_hvt
+ pu0=-3.2042714e-017+dpu0p_hvt                       ua=5.3730978e-011
+ lua=-2.0424042e-017       wua=-2.1788888e-016       pua=5.8771464e-024
+ ub=4.932269e-019-1.17854e-20*ff_flag_hvt-3.3385e-20*ss_flag_hvt-9.42832e-21*sf_flag_hvt+9.42832e-21*fs_flag_hvt
+ lub=-7.0532253e-28+9.66161e-28*ff_flag_hvt+2.7369e-27*ss_flag_hvt+7.72929e-28*sf_flag_hvt-7.72929e-28*fs_flag_hvt+dlubp_hvt
+ wub=1.5909159e-025+2.60627e-27*ff_flag_hvt+5.73382e-26*ss_flag_hvt+2.085e-27*sf_flag_hvt-2.085e-27*fs_flag_hvt
+ pub=-9.0296111e-33-2.13659e-34*ff_flag_hvt-4.70058e-33*ss_flag_hvt-1.7093e-34*sf_flag_hvt+1.7093e-34*fs_flag_hvt+dpubp_hvt
+ uc=-5.3876054e-011        luc=-2.9798862e-018       wuc=-1.8901042e-017
+ puc=-1.5501929e-024       vsat=75000+dvsatp_hvt+416.339*ff_flag_hvt-156.127*ss_flag_hvt+333.071*sf_flag_hvt-333.071*fs_flag_hvt
+ kvsat=0.5                 a0=-2.6233733+da0p_hvt-1.45973*ff_flag_hvt+1.16405*ss_flag_hvt-1.16779*sf_flag_hvt+1.16779*fs_flag_hvt
+ la0=2.7431206e-007+dla0p_hvt+1.22446e-07*ff_flag_hvt-9.2652e-08*ss_flag_hvt+9.79561e-08*sf_flag_hvt-9.79561e-08*fs_flag_hvt
+ wa0=2.3265295e-007+dwa0p_hvt+7.68459e-07*ff_flag_hvt-2.42423e-06*ss_flag_hvt+6.14769e-07*sf_flag_hvt-6.14769e-07*fs_flag_hvt
+ pa0=4.9521319e-014+dpa0p_hvt-9.08066e-14*ff_flag_hvt+1.7093e-13*ss_flag_hvt-7.26452e-14*sf_flag_hvt+7.26452e-14*fs_flag_hvt
+ ags=2.1060611+dagsp_hvt   lags=-3.8776082e-008+dlagsp_hvt
+ wags=6.2560776e-007+dwagsp_hvt                      pags=-3.7383166e-014+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.024039051         lketa=1.560507e-010
+ wketa=-7.057235e-008      pketa=4.189197e-015       dwg=0
+ dwb=0                     pclm=1.7844617+dpclmp_hvt+0.00797853*ss_flag_hvt-0.0325265*ff_flag_hvt-0.0260212*sf_flag_hvt+0.0260212*fs_flag_hvt
+ lpclm=1.5726855e-009+dlpclmp_hvt-7.46625e-10*ss_flag_hvt+2.66652e-09*ff_flag_hvt+2.13322e-09*sf_flag_hvt-2.13322e-09*fs_flag_hvt
+ wpclm=3.6066266e-008+dwpclmp_hvt-7.99129e-08*ss_flag_hvt+3.25785e-07*ff_flag_hvt+2.60628e-07*sf_flag_hvt-2.60628e-07*fs_flag_hvt
+ ppclm=-1.5754099e-014+dppclmp_hvt+7.4782e-15*ss_flag_hvt-2.67079e-14*ff_flag_hvt-2.13663e-14*sf_flag_hvt+2.13663e-14*fs_flag_hvt
+ pdiblc1=0                 pdiblc2=0.0057363184      lpdiblc2=-7.768324e-011
+ wpdiblc2=-8.2772024e-009  ppdiblc2=4.4148491e-016   pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.31189964
+ lkt1=8.1381597e-10+dlkt1p_hvt                       wkt1=2.6821402e-008
+ pkt1=-1.4822909e-15+dpkt1p_hvt                      kt1l=0
+ kt2=-0.055159532          lkt2=-3.2608305e-10+dlkt2p_hvt
+ wkt2=3.4991257e-009       pkt2=-3.3421603e-16+dpkt2p_hvt
+ ute=-1                    ua1=9.8722473e-010+dua1p_hvt
+ lua1=-1.1057464e-017+dlua1p_hvt                     wua1=9.6366461e-016
+ pua1=-1.9343118e-023      ub1=-1.1581509e-018+dub1p_hvt
+ lub1=1.3989047e-026+dlub1p_hvt                      wub1=-1.1360804e-024
+ pub1=2.1297724e-032       uc1=-5.6786026e-010+duc1p_hvt
+ luc1=2.298079e-017+dluc1p_hvt                       wuc1=5.3630603e-016
+ puc1=-2.3348483e-023      prt=0                     at=112364.83+datp_hvt
+ lat=-0.0039438164         wat=-0.042808343          pat=1.6555402e-009
+ jss=1.45e-07              jsd=1.45e-07              jsws=1.57e-13
+ jswd=1.57e-13             jswgs=1.57e-13            jswgd=1.57e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.52                  bvd=9.52                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp_hvt               cjd=cjp_hvt               mjs=0.315
+ mjd=0.315                 pbsws=0.49                pbswd=0.49
+ cjsws=cjswp_hvt           cjswd=cjswp_hvt           mjsws=0.039
+ mjswd=0.039               pbswgs=1.05               pbswgd=1.05
+ cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt         mjswgs=0.98
+ mjswgd=0.98               tpb=1.68e-03              tcj=9.50e-04
+ tpbsw=2.10e-03            tcjsw=2.80e-04            tpbswg=1.50e-03
+ tcjswg=1.50e-03           xtis=3                    xtid=3
+ jtsswgs=1.0733e-006       jtsswgd=1.0733e-006       njtsswg=15.5268
+ xtsswgs=0.18              xtsswgd=0.18              tnjtsswg=0.811
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             wvth0=0+dwvthp_hvt+9.12199e-09*ff_flag_hvt+3.90942e-09*ss_flag_hvt+7.29759e-09*sf_flag_hvt-7.29759e-09*fs_flag_hvt
+ pvth0=0+dpvthp_hvt-7.4782e-16*ff_flag_hvt-3.20494e-16*ss_flag_hvt-5.98256e-16*sf_flag_hvt+5.98256e-16*fs_flag_hvt
+ lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt
+ lvsat=0+dlvsatp_hvt-3.41314e-05*ff_flag_hvt+1.27993e-05*ss_flag_hvt-2.73052e-05*sf_flag_hvt+2.73052e-05*fs_flag_hvt
+ wvsat=0+dwvsatp_hvt-0.00417005*ff_flag_hvt+0.00156377*ss_flag_hvt-0.00333604*sf_flag_hvt+0.00333604*fs_flag_hvt
+ pvsat=0+dpvsatp_hvt+3.41861e-10*ff_flag_hvt-1.28198e-10*ss_flag_hvt+2.73488e-10*sf_flag_hvt-2.73488e-10*fs_flag_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_hvt            noib=noibp_hvt
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     11: type=p 
+ lmin=1e-005-dxlp_hvt      lmax=2.00001e-05          wmin=6e-007-dxwp_hvt
+ wmax=1e-006-dxwp_hvt      version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_hvt             toxm=2.2e-009             dtox=3.219e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+dxlp_hvt     xw=1.6e-08+dxwp_hvt
+ dlc=2.134663e-08+ddlcp_hvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+dvthp_hvt    k1=0.40676                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ k2=-0.0074823797+dk2p_hvt wk2=-6.5934473e-009+dwk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0026027822+dcitp_hvt                          wcit=-1.2337138e-009+dwcitp_hvt
+ voff=-0.15273455+dvoffp_hvt                         wvoff=6.2509715e-010+dwvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.1912552+deta0p_hvt weta0=-4.5186803e-008+dweta0p_hvt
+ etab=-0.17327072          wetab=8.0920052e-008      u0=0.0079857188+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           wu0=1.1321097e-009+dwu0p_hvt
+ ua=-3.648e-010            wua=1.877568e-016         ub=1.145689e-018
+ pub=0+dpubp_hvt           lub=0+dlubp_hvt           wub=-1.1703371e-025
+ uc=2.118672e-010          wuc=-5.2697075e-017       vsat=75000+dvsatp_hvt
+ kvsat=0.5                 a0=2.8422626+da0p_hvt+0.3048*ff_flag_hvt-0.254*ss_flag_hvt+0.24384*sf_flag_hvt-0.24384*fs_flag_hvt
+ wa0=4.080452e-007+dwa0p_hvt-1.87757e-07*ff_flag_hvt+1.56464e-07*ss_flag_hvt-1.50205e-07*sf_flag_hvt+1.50205e-07*fs_flag_hvt
+ ags=0.8747775+dagsp_hvt+0.3048*ff_flag_hvt+0.24384*sf_flag_hvt-0.24384*fs_flag_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.1                  dwg=0
+ dwb=0                     pclm=1.7880578+dpclmp_hvt pdiblc1=0
+ pdiblc2=0.001             pdiblcb=0                 drout=0.5
+ pvag=2.7713               delta=0.018               pscbe1=4.632e+008
+ pscbe2=5e-016             fprout=0                  pdits=1
+ pditsd=3                  pditsl=1300000            rsh=15.5
+ rsw=203+drdswp_hvt        rdw=203+drdswp_hvt        prwg=0
+ prwb=0                    wr=1                      alpha0=7.45e-009
+ alpha1=0                  beta0=12.21               agidl=1e-008
+ bgidl=2.17018e+009        cgidl=0.154               aigbacc=0.0125
+ bigbacc=0.004             cigbacc=0                 nigbacc=1
+ aigbinv=0.01134           bigbinv=0.003             cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0062447
+ bigc=0.000459788          cigc=-0.033313            aigsd=0.0047986
+ bigsd=0.00061108          cigsd=0.14                nigc=1
+ poxedge=1                 pigcd=3.0117              ntox=ntoxp_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_hvt
+ cgdo=cgop_hvt             cgbo=0                    cgdl=cglp_hvt
+ cgsl=cglp_hvt             clc=1e-007                cle=0.6
+ cf=cfp_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.3898
+ voffcv=-0.084627          kt1=-0.24869375           pkt1=0+dpkt1p_hvt
+ lkt1=0+dlkt1p_hvt         wkt1=1.613535e-008        kt1l=0
+ kt2=-0.03632              pkt2=0+dpkt2p_hvt         lkt2=0+dlkt2p_hvt
+ wkt2=1.251712e-008        ute=-1                    ua1=4.49225e-009+dua1p_hvt
+ wua1=5.8674e-017          ub1=-6e-018+dub1p_hvt     uc1=-4e-011+duc1p_hvt
+ prt=0                     at=150000+datp_hvt        jss=1.45e-07
+ jsd=1.45e-07              jsws=1.57e-13             jswd=1.57e-13
+ jswgs=1.57e-13            jswgd=1.57e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.52
+ bvd=9.52                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_hvt
+ cjd=cjp_hvt               mjs=0.315                 mjd=0.315
+ pbsws=0.49                pbswd=0.49                cjsws=cjswp_hvt
+ cjswd=cjswp_hvt           mjsws=0.039               mjswd=0.039
+ pbswgs=1.05               pbswgd=1.05               cjswgs=cjswgp_hvt
+ cjswgd=cjswgp_hvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.68e-03              tcj=9.50e-04              tpbsw=2.10e-03
+ tcjsw=2.80e-04            tpbswg=1.50e-03           tcjswg=1.50e-03
+ xtis=3                    xtid=3                    jtsswgs=1.0733e-006
+ jtsswgd=1.0733e-006       njtsswg=15.5268           xtsswgs=0.18
+ xtsswgd=0.18              tnjtsswg=0.811            dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt
+ lk2=0+dlk2p_hvt           pk2=0+dpk2p_hvt           lcit=0+dlcitp_hvt
+ pcit=0+dpcitp_hvt         lvoff=0+dlvoffp_hvt       pvoff=0+dpvoffp_hvt
+ lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt
+ leta0=0+dleta0p_hvt       peta0=0+dpeta0p_hvt       lu0=0+dlu0p_hvt
+ pu0=0+dpu0p_hvt           lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt
+ pvsat=0+dpvsatp_hvt       la0=0+dla0p_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ pa0=0+dpa0p_hvt+0.0*ff_flag_hvt+0.0*ss_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ lags=0+dlagsp_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ wags=0+dwagsp_hvt-1.87757e-07*ff_flag_hvt-1.50205e-07*sf_flag_hvt+1.50205e-07*fs_flag_hvt
+ pags=0+dpagsp_hvt+0.0*ff_flag_hvt+0.0*sf_flag_hvt+0.0*fs_flag_hvt
+ lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt       ppclm=0+dppclmp_hvt
+ lub1=0+dlub1p_hvt         lua1=0+dlua1p_hvt         luc1=0+dluc1p_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_hvt            noib=noibp_hvt
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     12: type=p 
+ lmin=1.000003e-006-dxlp_hvt                         lmax=1e-005-dxlp_hvt
+ wmin=6e-007-dxwp_hvt      wmax=1e-006-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=2.134663e-08+ddlcp_hvt
+ dwc=0                     xpart=1                   toxref=3e-009
+ dlcig=2.5e-009            vth0=-0.3981+dvthp_hvt    k1=0.40676
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0.0e-8
+ lkvth0=-4.33e-8           k2=-0.0068569784+dk2p_hvt lk2=-6.220497e-009+dlk2p_hvt
+ wk2=-6.536955e-009+dwk2p_hvt                        pk2=-5.6189515e-016+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0027245692+dcitp_hvt                          lcit=-1.2113434e-009+dlcitp_hvt
+ wcit=-1.3482224e-009+dwcitp_hvt                     pcit=1.138949e-015+dpcitp_hvt
+ voff=-0.15418124+dvoffp_hvt                         lvoff=1.438937e-008+dlvoffp_hvt
+ wvoff=5.486421e-010+dwvoffp_hvt                     pvoff=7.6045324e-016+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.1912552+deta0p_hvt weta0=-4.5186803e-008+dweta0p_hvt
+ etab=-0.17327072          wetab=8.0920052e-008      u0=0.0079806871+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           lu0=5.0047633e-011+dlu0p_hvt
+ wu0=1.1892609e-009+dwu0p_hvt                        pu0=-5.6844965e-016+dpu0p_hvt
+ ua=-3.8423295e-010        lua=1.9328811e-016        wua=2.0750068e-016
+ pua=-1.9638072e-022       ub=1.1496543e-018         lub=-3.9440486e-26+dlubp_hvt
+ wub=-1.3596978e-025       pub=1.8834592e-31+dpubp_hvt
+ uc=2.3465083e-010         luc=-2.2661536e-016       wuc=-5.5741585e-017
+ puc=3.0281946e-023        vsat=75000+dvsatp_hvt     kvsat=0.5
+ a0=2.8672776+da0p_hvt+0.336852*ff_flag_hvt-0.28071*ss_flag_hvt+0.269481*sf_flag_hvt-0.269481*fs_flag_hvt
+ la0=-2.4880969e-007+dla0p_hvt-3.188e-07*ff_flag_hvt+2.65666e-07*ss_flag_hvt-2.5504e-07*sf_flag_hvt+2.5504e-07*fs_flag_hvt
+ wa0=4.599176e-007+dwa0p_hvt-2.07501e-07*ff_flag_hvt+1.72917e-07*ss_flag_hvt-1.66001e-07*sf_flag_hvt+1.66001e-07*fs_flag_hvt
+ pa0=-5.159441e-013+dpa0p_hvt+1.96381e-13*ff_flag_hvt-1.63651e-13*ss_flag_hvt+1.57105e-13*sf_flag_hvt-1.57105e-13*fs_flag_hvt
+ ags=0.8212051+dagsp_hvt+0.336852*ff_flag_hvt+0.269481*sf_flag_hvt-0.269481*fs_flag_hvt
+ lags=5.3285306e-007+dlagsp_hvt-3.188e-07*ff_flag_hvt-2.5504e-07*sf_flag_hvt+2.5504e-07*fs_flag_hvt
+ wags=1.5149367e-008+dwagsp_hvt-2.07501e-07*ff_flag_hvt-1.66001e-07*sf_flag_hvt+1.66001e-07*fs_flag_hvt
+ pags=-1.5068181e-013+dpagsp_hvt+1.96381e-13*ff_flag_hvt+1.57105e-13*sf_flag_hvt-1.57105e-13*fs_flag_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.11111242           lketa=-1.1052869e-007
+ wketa=-6.0630162e-010     pketa=6.0305245e-015      dwg=0
+ dwb=0                     pclm=1.7880578+dpclmp_hvt pdiblc1=0
+ pdiblc2=0.001             pdiblcb=0                 drout=0.5
+ pvag=2.7713               delta=0.018               pscbe1=4.632e+008
+ pscbe2=5e-016             fprout=0                  pdits=1
+ pditsd=3                  pditsl=1300000            rsh=15.5
+ rsw=203+drdswp_hvt        rdw=203+drdswp_hvt        prwg=0
+ prwb=0                    wr=1                      alpha0=7.45e-009
+ alpha1=0                  beta0=12.21               agidl=1e-008
+ bgidl=2.17018e+009        cgidl=0.154               aigbacc=0.0125
+ bigbacc=0.004             cigbacc=0                 nigbacc=1
+ aigbinv=0.01134           bigbinv=0.003             cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0062447
+ bigc=0.000459788          cigc=-0.033313            aigsd=0.0047986
+ bigsd=0.00061108          cigsd=0.14                nigc=1
+ poxedge=1                 pigcd=3.0117              ntox=ntoxp_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_hvt
+ cgdo=cgop_hvt             cgbo=0                    cgdl=cglp_hvt
+ cgsl=cglp_hvt             clc=1e-007                cle=0.6
+ cf=cfp_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.3898
+ voffcv=-0.084627          kt1=-0.24915512           lkt1=4.5890237e-09+dlkt1p_hvt
+ wkt1=1.7472175e-008       pkt1=-1.3296611e-14+dpkt1p_hvt
+ kt1l=0                    kt2=-0.034104224          lkt2=-2.2039019e-08+dlkt2p_hvt
+ wkt2=1.3951843e-008       pkt2=-1.4270341e-14+dpkt2p_hvt
+ ute=-1                    ua1=4.434807e-009+dua1p_hvt
+ lua1=5.7135201e-016+dlua1p_hvt                      wua1=2.1312461e-016
+ pua1=-1.5362291e-021      ub1=-5.8665749e-018+dub1p_hvt
+ lub1=-1.3271012e-024+dlub1p_hvt                     wub1=-2.6483535e-025
+ pub1=2.6341609e-030       uc1=-4e-011+duc1p_hvt     prt=0
+ at=153205.18+datp_hvt     lat=-0.031879987          wat=-0.0019743879
+ pat=1.9638072e-008        jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_hvt
+ wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt        lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt
+ peta0=0+dpeta0p_hvt       lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt
+ pvsat=0+dpvsatp_hvt       lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       luc1=0+dluc1p_hvt         wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0090             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-1.8e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_hvt            noib=noibp_hvt            noic=noicp_hvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     13: type=p 
+ lmin=2.39995e-007-dxlp_hvt                          lmax=1.000003e-006-dxlp_hvt
+ wmin=6e-007-dxwp_hvt      wmax=1e-006-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+dvthp_hvt    k1=0.40676                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ k2=-0.013636938+dk2p_hvt  lk2=1.9612454e-010+dlk2p_hvt
+ wk2=-7.7976504e-009+dwk2p_hvt                       pk2=6.3123959e-016+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0011705033+dcitp_hvt-0.000450171*ff_flag_hvt+0.000225085*ss_flag_hvt
+ lcit=2.5944006e-010+dlcitp_hvt+4.26046e-10*ff_flag_hvt-2.13023e-10*ss_flag_hvt
+ wcit=-1.1210543e-010+dwcitp_hvt+2.77305e-10*ff_flag_hvt-1.38653e-10*ss_flag_hvt
+ pcit=-3.0924459e-017+dpcitp_hvt-2.62444e-16*ff_flag_hvt+1.31222e-16*ss_flag_hvt
+ voff=-0.14149377+dvoffp_hvt                         lvoff=2.381818e-009+dlvoffp_hvt
+ wvoff=2.4059263e-009+dwvoffp_hvt                    pvoff=-9.9729914e-016+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.1912552+deta0p_hvt weta0=-4.5186803e-008+dweta0p_hvt
+ etab=-0.17327072          wetab=8.0920052e-008      u0=0.0080288685+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           lu0=4.448281e-012+dlu0p_hvt
+ wu0=7.7149829e-010+dwu0p_hvt                        pu0=-1.7307494e-016+dpu0p_hvt
+ ua=-1.936469e-010         lua=1.2915559e-017        wua=1.3865246e-017
+ pua=-1.3122207e-023       ub=1.1777065e-018         lub=-6.598935e-26+dlubp_hvt
+ wub=1.202254e-025         pub=-5.4119763e-32+dpubp_hvt
+ uc=1.8280774e-011         luc=-2.1840572e-017       wuc=-3.0562744e-017
+ puc=6.4524388e-024        vsat=75000+dvsatp_hvt     kvsat=0.5
+ a0=2.8562962+da0p_hvt-0.225085*ff_flag_hvt-0.180068*sf_flag_hvt+0.180068*fs_flag_hvt
+ la0=-2.3841679e-007+dla0p_hvt+2.13023e-07*ff_flag_hvt+1.70418e-07*sf_flag_hvt-1.70418e-07*fs_flag_hvt
+ wa0=-1.3098965e-007+dwa0p_hvt+1.38653e-07*ff_flag_hvt+1.10922e-07*sf_flag_hvt-1.10922e-07*fs_flag_hvt
+ pa0=4.3296426e-014+dpa0p_hvt-1.31222e-13*ff_flag_hvt-1.04978e-13*sf_flag_hvt+1.04978e-13*fs_flag_hvt
+ ags=1.0556745+dagsp_hvt   lags=3.1094887e-007+dlagsp_hvt
+ wags=-3.0404522e-008+dwagsp_hvt                     pags=-1.0756916e-013+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=0.0076877238         lketa=-1.2646521e-008
+ wketa=8.0952908e-009      pketa=-2.2047496e-015     dwg=0
+ dwb=0                     pclm=1.7880578+dpclmp_hvt pdiblc1=0
+ pdiblc2=0.0019979662      lpdiblc2=-9.4448516e-010  wpdiblc2=-1.0514478e-009
+ ppdiblc2=9.9510074e-016   pdiblcb=0                 drout=0.5
+ pvag=2.7713               delta=0.018               pscbe1=4.632e+008
+ pscbe2=5e-016             fprout=0                  pdits=1
+ pditsd=3                  pditsl=1300000            rsh=15.5
+ rsw=203+drdswp_hvt        rdw=203+drdswp_hvt        prwg=0
+ prwb=0                    wr=1                      alpha0=7.45e-009
+ alpha1=0                  beta0=12.21               agidl=1e-008
+ bgidl=2.17018e+009        cgidl=0.154               aigbacc=0.0125
+ bigbacc=0.004             cigbacc=0                 nigbacc=1
+ aigbinv=0.01134           bigbinv=0.003             cigbinv=0.006
+ eigbinv=1.1               nigbinv=1                 aigc=0.0062447
+ bigc=0.000459788          cigc=-0.033313            aigsd=0.0047986
+ bigsd=0.00061108          cigsd=0.14                nigc=1
+ poxedge=1                 pigcd=3.0117              ntox=ntoxp_hvt
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop_hvt
+ cgdo=cgop_hvt             cgbo=0                    cgdl=cglp_hvt
+ cgsl=cglp_hvt             clc=1e-007                cle=0.6
+ cf=cfp_hvt                ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=5                    noff=2.3898
+ voffcv=-0.084627          kt1=-0.24118692           lkt1=-2.9521696e-09+dlkt1p_hvt
+ wkt1=2.9731849e-009       pkt1=4.2537823e-16+dpkt1p_hvt
+ kt1l=0                    kt2=-0.059461776          lkt2=1.9596222e-09+dlkt2p_hvt
+ wkt2=2.2688073e-010       pkt2=-1.2809e-15+dpkt2p_hvt
+ ute=-1                    ua1=6.1030921e-009+dua1p_hvt
+ lua1=-1.0075297e-015+dlua1p_hvt                     wua1=-1.8162635e-015
+ pua1=3.8440413e-022       ub1=-8.9008325e-018+dub1p_hvt
+ lub1=1.5445505e-024+dlub1p_hvt                      wub1=3.2527062e-024
+ pub1=-6.9487556e-031      uc1=-4e-011+duc1p_hvt     prt=0
+ at=119896.96+datp_hvt     lat=-0.00035676016        wat=0.024366147
+ pat=-5.2908741e-009       jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp_hvt
+ wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt        lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt
+ peta0=0+dpeta0p_hvt       lvsat=0+dlvsatp_hvt       wvsat=0+dwvsatp_hvt
+ pvsat=0+dpvsatp_hvt       lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       luc1=0+dluc1p_hvt         wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0038           pkvth0we=0.5e-17          wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0090             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-1.8e-10           k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    fnoimod=1
+ af=1                      kf=0                      tnoimod=0
+ noia=noiap_hvt            noib=noibp_hvt            noic=noicp_hvt
+ em=3e+7                   ef=1.1                    lintnoi=-1e-8
+ minr=1e-3
 
 
     14: type=p 
+ lmin=9.99969e-008-dxlp_hvt                          lmax=2.39995e-007-dxlp_hvt
+ wmin=6e-007-dxwp_hvt      wmax=1e-006-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.39870478+dvthp_hvt                          kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ lvth0=1.3051783e-010+dlvthp_hvt                     wvth0=4.578701e-009+dwvthp_hvt
+ pvth0=-9.8812947e-016+dpvthp_hvt                    k1=0.40676
+ k2=-0.012726127+dk2p_hvt  lk2=-4.3761854e-013+dlk2p_hvt
+ wk2=-4.4242874e-009+dwk2p_hvt                       pk2=-9.6765886e-017+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0017937715+dcitp_hvt+0.00121281*ff_flag_hvt-0.000762*ss_flag_hvt
+ lcit=1.2493256e-010+dlcitp_hvt+6.7157e-11*ff_flag_hvt+2e-17*ss_flag_hvt
+ wcit=-4.9270902e-010+dwcitp_hvt-7.47095e-10*ff_flag_hvt+4.69392e-10*ss_flag_hvt
+ pcit=5.1213601e-017+dpcitp_hvt-4.13685e-17*ff_flag_hvt+2.8e-23*ss_flag_hvt
+ voff=-0.12581101+dvoffp_hvt                         lvoff=-1.0026771e-009+dlvoffp_hvt
+ wvoff=-1.0468837e-009+dwvoffp_hvt                   pvoff=-2.5214821e-016+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.19126349+deta0p_hvt
+ leta0=-1.7898307e-012+dleta0p_hvt                   weta0=-4.5193164e-008+dweta0p_hvt
+ peta0=1.3728157e-018+dpeta0p_hvt                    etab=-0.17327084
+ letab=2.544818e-014       wetab=8.0920171e-008      petab=-2.5855351e-020
+ u0=0.0082095682+du0p_hvt  ku0=-0.5354e-9            pku0=-0.5e-16
+ wku0=0                    lku0=-4.0055e-8           lu0=-3.4548519e-011+dlu0p_hvt
+ wu0=-5.6531134e-011+dwu0p_hvt                       pu0=5.6220951e-018+dpu0p_hvt
+ ua=8.5596324e-013         lua=-2.9060103e-017       wua=-8.4606233e-017
+ pua=8.1289224e-024        ub=1.0263255e-018         lub=-3.3319831e-26+dlubp_hvt
+ wub=-1.5631994e-025       pub=5.5614861e-33+dpubp_hvt
+ uc=-7.8820502e-011        luc=-8.8514608e-019       wuc=2.2468685e-017
+ puc=-4.9922741e-024       vsat=75000+dvsatp_hvt     kvsat=0.5
+ a0=1.8920328+da0p_hvt+1.69555*ff_flag_hvt+0.466776*ss_flag_hvt+1.35644*sf_flag_hvt-1.35644*fs_flag_hvt
+ la0=-3.0319107e-008+dla0p_hvt-2.0147e-07*ff_flag_hvt-1.00735e-07*ss_flag_hvt-1.61176e-07*sf_flag_hvt+1.61176e-07*fs_flag_hvt
+ wa0=9.7316333e-008+dwa0p_hvt-1.04446e-06*ff_flag_hvt-2.87534e-07*ss_flag_hvt-8.35568e-07*sf_flag_hvt+8.35568e-07*fs_flag_hvt
+ pa0=-5.9742885e-015+dpa0p_hvt+1.24106e-13*ff_flag_hvt+6.20528e-14*ss_flag_hvt+9.92844e-14*sf_flag_hvt-9.92844e-14*fs_flag_hvt
+ ags=2.7109311+dagsp_hvt   lags=-4.6272063e-008+dlagsp_hvt
+ wags=-6.3715302e-007+dwagsp_hvt                     pags=2.3373238e-014+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.071468474         lketa=4.4361784e-009
+ wketa=1.1482872e-008      pketa=-2.9358234e-015     dwg=0
+ dwb=0                     pclm=2.0028651+dpclmp_hvt-0.0155592*ss_flag_hvt
+ lpclm=-4.635757e-008+dlpclmp_hvt+3.35783e-09*ss_flag_hvt
+ wpclm=-1.3232132e-007+dwpclmp_hvt+9.58448e-09*ss_flag_hvt
+ ppclm=2.8556263e-014+dppclmp_hvt-2.06843e-15*ss_flag_hvt
+ pdiblc1=0                 pdiblc2=-0.003461557      lpdiblc2=2.3373453e-010
+ wpdiblc2=4.1512507e-009   ppdiblc2=-1.2769363e-016  pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.23232862
+ lkt1=-4.8638777e-09+dlkt1p_hvt                      wkt1=9.0380363e-009
+ pkt1=-8.8347735e-16+dpkt1p_hvt                      kt1l=0
+ kt2=-0.046448141          lkt2=-8.4885044e-10+dlkt2p_hvt
+ wkt2=-7.398374e-009       pkt2=3.6470626e-16+dpkt2p_hvt
+ ute=-1                    ua1=1.1932985e-009+dua1p_hvt
+ lua1=5.2052832e-017+dlua1p_hvt                      wua1=1.0507726e-016
+ pua1=-3.0240419e-023      ub1=-1.3769362e-018+dub1p_hvt
+ lub1=-7.9181518e-026+dlub1p_hvt                     wub1=-2.5371872e-025
+ pub1=6.1846e-032          uc1=-4e-011+duc1p_hvt     prt=0
+ at=168721.81+datp_hvt     lat=-0.010893651          wat=-0.0040760112
+ pat=8.4722815e-010        jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt lvsat=0+dlvsatp_hvt
+ wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt       luc1=0+dluc1p_hvt
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0038           pkvth0we=0.5e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0090
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-1.8e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noiap_hvt            noib=noibp_hvt
+ noic=noicp_hvt            em=3e+7                   ef=1.1
+ lintnoi=-1e-8             minr=1e-3
 
 
     15: type=p 
+ lmin=6e-08                lmax=9.99969e-008-dxlp_hvt
+ wmin=6e-007-dxwp_hvt      wmax=1e-006-dxwp_hvt      version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag_hvt     permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=toxp_hvt             toxm=2.2e-009
+ dtox=3.219e-010           epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+dxlp_hvt
+ xw=1.6e-08+dxwp_hvt       dlc=1.25625e-09+ddlcp_hvt dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.37292967+dvthp_hvt                          kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ lvth0=-1.9825258e-009+dlvthp_hvt                    wvth0=-1.608736e-008+dwvthp_hvt
+ pvth0=7.0607425e-016+dpvthp_hvt                     k1=0.40676
+ k2=0.018002445+dk2p_hvt   lk2=-2.519566e-009+dlk2p_hvt
+ wk2=-1.9404603e-008+dwk2p_hvt                       pk2=1.1313204e-015+dpk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0014380809+dcitp_hvt+0.00358167*ff_flag_hvt-0.00063379*sf_flag_hvt+0.00063379*fs_flag_hvt-0.00164022*ss_flag_hvt
+ lcit=3.8987982e-010+dlcitp_hvt-1.27042e-10*ff_flag_hvt+5.19581e-11*sf_flag_hvt-5.19581e-11*fs_flag_hvt+7.1996e-11*ss_flag_hvt
+ wcit=1.5675692e-009+dwcitp_hvt-2.13531e-09*ff_flag_hvt+4.47211e-10*sf_flag_hvt-4.47211e-10*fs_flag_hvt+1.01037e-09*ss_flag_hvt
+ pcit=-1.1768801e-016+dpcitp_hvt+7.24376e-17*ff_flag_hvt-3.66623e-17*sf_flag_hvt+3.66623e-17*fs_flag_hvt-4.43496e-17*ss_flag_hvt
+ voff=-0.10836515+dvoffp_hvt                         lvoff=-2.432889e-009+dlvoffp_hvt
+ wvoff=-9.1012978e-009+dwvoffp_hvt                   pvoff=4.0815266e-016+dpvoffp_hvt
+ nfactor=0.7+dnfactorp_hvt eta0=0.16807867+deta0p_hvt-0.0186361*ff_flag_hvt+0.0115367*ss_flag_hvt-0.0149089*sf_flag_hvt+0.0149089*fs_flag_hvt
+ leta0=1.8989023e-009+dleta0p_hvt+1.52779e-09*ff_flag_hvt-9.45775e-10*ss_flag_hvt+1.22223e-09*sf_flag_hvt-1.22223e-09*fs_flag_hvt
+ weta0=-8.254998e-008+dweta0p_hvt+1.89343e-08*ff_flag_hvt-1.17212e-08*ss_flag_hvt+1.51475e-08*sf_flag_hvt-1.51475e-08*fs_flag_hvt
+ peta0=3.0638846e-015+dpeta0p_hvt-1.55223e-15*ff_flag_hvt+9.60907e-16*ss_flag_hvt-1.24179e-15*sf_flag_hvt+1.24179e-15*fs_flag_hvt
+ etab=-0.33473784          letab=1.323709e-008       wetab=1.6989764e-007
+ petab=-7.294399e-015      u0=0.0086962951+du0p_hvt  ku0=-0.5354e-9
+ pku0=-0.5e-16             wku0=0                    lku0=-4.0055e-8
+ lu0=-7.4450393e-011+dlu0p_hvt                       wu0=2.5929975e-011+dwu0p_hvt
+ pu0=-1.1380666e-018+dpu0p_hvt                       ua=-2.1945502e-010
+ lua=-1.0999009e-017       wua=5.9668094e-017        pua=-3.6986869e-024
+ ub=7.5972458e-019-4.82673e-20*ff_flag_hvt+1.29543e-19*ss_flag_hvt-3.86138e-20*sf_flag_hvt+3.86138e-20*fs_flag_hvt
+ lub=-1.1463885e-26+3.95694e-27*ff_flag_hvt-1.06199e-26*ss_flag_hvt+3.16556e-27*sf_flag_hvt-3.16556e-27*fs_flag_hvt+dlubp_hvt
+ wub=-1.1167005e-025+3.96719e-26*ff_flag_hvt-1.08196e-25*ss_flag_hvt+3.17375e-26*sf_flag_hvt-3.17375e-26*fs_flag_hvt
+ pub=1.9010885e-33-3.2523e-33*ff_flag_hvt+8.86991e-33*ss_flag_hvt-2.60184e-33*sf_flag_hvt+2.60184e-33*fs_flag_hvt+dpubp_hvt
+ uc=-4.9136287e-012        luc=-6.9440316e-018       wuc=-6.8646866e-017
+ puc=2.4773788e-024        vsat=75000+dvsatp_hvt+7062.6*ss_flag_hvt-11142.5*ff_flag_hvt-8914*sf_flag_hvt+8914*fs_flag_hvt
+ kvsat=0.5                 a0=-1.5431939+da0p_hvt-1.52035*ff_flag_hvt-3.45888*ss_flag_hvt-1.21628*sf_flag_hvt+1.21628*fs_flag_hvt
+ la0=2.5130078e-007+dla0p_hvt+6.21698e-08*ff_flag_hvt+2.2109e-07*ss_flag_hvt+4.97358e-08*sf_flag_hvt-4.97358e-08*fs_flag_hvt
+ wa0=-8.6480939e-007+dwa0p_hvt+8.30046e-07*ff_flag_hvt+2.27266e-06*ss_flag_hvt+6.64036e-07*sf_flag_hvt-6.64036e-07*fs_flag_hvt
+ pa0=7.2900779e-014+dpa0p_hvt-2.95664e-14*ff_flag_hvt-1.47832e-13*ss_flag_hvt-2.3653e-14*sf_flag_hvt+2.3653e-14*fs_flag_hvt
+ ags=4.4879145+dagsp_hvt   lags=-1.9194916e-007+dlagsp_hvt
+ wags=-1.7943554e-006+dwagsp_hvt                     pags=1.1824069e-013+dpagsp_hvt
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.040188411         lketa=1.8718388e-009
+ wketa=-5.4164601e-008     pketa=2.4459564e-015      dwg=0
+ dwb=0                     pclm=1.3579315+dpclmp_hvt-0.179517*ss_flag_hvt+0.731846*ff_flag_hvt+0.585477*sf_flag_hvt-0.585477*fs_flag_hvt
+ lpclm=6.514087e-009+dlpclmp_hvt+1.67991e-08*ss_flag_hvt-5.99967e-08*ff_flag_hvt-4.79974e-08*sf_flag_hvt+4.79974e-08*fs_flag_hvt
+ wpclm=4.694209e-007+dwpclmp_hvt+1.10582e-07*ss_flag_hvt-4.50817e-07*ff_flag_hvt-3.60654e-07*sf_flag_hvt+3.60654e-07*fs_flag_hvt
+ ppclm=-2.0774563e-014+dppclmp_hvt-1.03482e-14*ss_flag_hvt+3.6958e-14*ff_flag_hvt+2.95664e-14*sf_flag_hvt-2.95664e-14*fs_flag_hvt
+ pdiblc1=0                 pdiblc2=-0.010527974      lpdiblc2=8.1303937e-010
+ wpdiblc2=8.2473184e-009   ppdiblc2=-4.6348926e-016  pdiblcb=0
+ drout=0.5                 pvag=2.7713               delta=0.018
+ pscbe1=4.632e+008         pscbe2=5e-016             fprout=0
+ pdits=1                   pditsd=3                  pditsl=1300000
+ rsh=15.5                  rsw=203+drdswp_hvt        rdw=203+drdswp_hvt
+ prwg=0                    prwb=0                    wr=1
+ alpha0=7.45e-009          alpha1=0                  beta0=12.21
+ agidl=1e-008              bgidl=2.17018e+009        cgidl=0.154
+ aigbacc=0.0125            bigbacc=0.004             cigbacc=0
+ nigbacc=1                 aigbinv=0.01134           bigbinv=0.003
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1
+ aigc=0.0062447            bigc=0.000459788          cigc=-0.033313
+ aigsd=0.0047986           bigsd=0.00061108          cigsd=0.14
+ nigc=1                    poxedge=1                 pigcd=3.0117
+ ntox=ntoxp_hvt            xrcrg1=12                 xrcrg2=1
+ cgso=cgop_hvt             cgdo=cgop_hvt             cgbo=0
+ cgdl=cglp_hvt             cgsl=cglp_hvt             clc=1e-007
+ cle=0.6                   cf=cfp_hvt                ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=5
+ noff=2.3898               voffcv=-0.084627          kt1=-0.28016368
+ lkt1=-9.4236004e-10+dlkt1p_hvt                      wkt1=-5.4223352e-009
+ pkt1=3.019839e-16+dpkt1p_hvt                        kt1l=0
+ kt2=-0.025636505          lkt2=-2.5549884e-09+dlkt2p_hvt
+ wkt2=-2.649627e-008       pkt2=1.9303518e-15+dpkt2p_hvt
+ ute=-1                    ua1=2.1737087e-009+dua1p_hvt
+ lua1=-2.8321192e-017+dlua1p_hvt                     wua1=-2.4180306e-016
+ pua1=-1.8031704e-024      ub1=-2.6626704e-018+dub1p_hvt
+ lub1=2.6222976e-026+dlub1p_hvt                      wub1=3.9251145e-025
+ pub1=8.8680514e-033       uc1=-4e-011+duc1p_hvt     prt=0
+ at=68506.881+datp_hvt     lat=-0.0026780309         wat=0.001751337
+ pat=3.6950214e-010        jss=1.45e-07              jsd=1.45e-07
+ jsws=1.57e-13             jswd=1.57e-13             jswgs=1.57e-13
+ jswgd=1.57e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.52                  bvd=9.52
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp_hvt               cjd=cjp_hvt
+ mjs=0.315                 mjd=0.315                 pbsws=0.49
+ pbswd=0.49                cjsws=cjswp_hvt           cjswd=cjswp_hvt
+ mjsws=0.039               mjswd=0.039               pbswgs=1.05
+ pbswgd=1.05               cjswgs=cjswgp_hvt         cjswgd=cjswgp_hvt
+ mjswgs=0.98               mjswgd=0.98               tpb=1.68e-03
+ tcj=9.50e-04              tpbsw=2.10e-03            tcjsw=2.80e-04
+ tpbswg=1.50e-03           tcjswg=1.50e-03           xtis=3
+ xtid=3                    jtsswgs=1.0733e-006       jtsswgd=1.0733e-006
+ njtsswg=15.5268           xtsswgs=0.18              xtsswgd=0.18
+ tnjtsswg=0.811            dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lnfactor=0+dlnfactorp_hvt
+ wnfactor=0+dwnfactorp_hvt pnfactor=0+dpnfactorp_hvt lvsat=0+dlvsatp_hvt-0.000578992*ss_flag_hvt+0.000913462*ff_flag_hvt+0.000730769*sf_flag_hvt-0.000730769*fs_flag_hvt
+ wvsat=0+dwvsatp_hvt-0.00577046*ss_flag_hvt+0.00757373*ff_flag_hvt+0.00605898*sf_flag_hvt-0.00605898*fs_flag_hvt
+ pvsat=0+dpvsatp_hvt+4.73062e-10*ss_flag_hvt-6.20894e-10*ff_flag_hvt-4.96715e-10*sf_flag_hvt+4.96715e-10*fs_flag_hvt
+ luc1=0+dluc1p_hvt         wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0090             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-1.8e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noiap_hvt
+ noib=noibp_hvt            noic=noicp_hvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     16: type=p 
+ lmin=1e-005-dxlp_hvt      lmax=2.00001e-05          wmin=3e-007-dxwp_hvt
+ wmax=6e-007-dxwp_hvt      version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag_hvt     permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxp_hvt             toxm=2.2e-009             dtox=3.219e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+dxlp_hvt     xw=1.6e-08+dxwp_hvt
+ dlc=2.134663e-08+ddlcp_hvt                          dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.3981+dvthp_hvt    k1=0.40676                kvth0=-0.8e-10
+ pkvth0=-1e-17             wkvth0=0.0e-8             lkvth0=-4.33e-8
+ k2=-0.020634865+dk2p_hvt  wk2=1.5084836e-009+dwk2p_hvt
+ k3=-2.86346               k3b=3.10778               w0=0
+ dvt0=1.0197               dvt1=1.1537658            dvt2=0.02
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.515                minv=0                    voffl=0
+ dvtp0=5.65227e-009        dvtp1=0.3                 lpe0=1.35409e-008
+ lpeb=0                    xj=1.1e-007               ngate=2.0207e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0006+dcitp_hvt      voff=-0.16559799+dvoffp_hvt
+ wvoff=8.5489788e-009+dwvoffp_hvt                    nfactor=0.7+dnfactorp_hvt
+ eta0=0.094716133+deta0p_hvt                         weta0=1.4281262e-008+dweta0p_hvt
+ etab=0.05640376           wetab=-6.0559428e-008     u0=0.0095838492+du0p_hvt
+ ku0=-0.5354e-9            pku0=-0.5e-16             wku0=0
+ lku0=-4.0055e-8           wu0=1.4766137e-010+dwu0p_hvt
+ ua=4.744e-011             wua=-6.618304e-017        ub=1.0280126e-018
+ pub=0+dpubp_hvt           lub=0+dlubp_hvt           wub=-4.4545079e-026
+ uc=1.0888952e-010         wuc=1.0737173e-017        vsat=75000+dvsatp_hvt
+ a0=3.0943327+da0p_hvt     kvsat=0.5                 wa0=2.5277004e-007+dwa0p_hvt
+ ags=0.8747775+dagsp_hvt   a1=0                      a2=1
+ b0=0                      b1=0                      keta=0.11474667
+ wketa=-9.0839467e-009     dwg=0                     dwb=0
+ pclm=1.7880578+dpclmp_hvt pdiblc1=0                 pdiblc2=0.001
+ pdiblcb=0                 drout=0.5                 pvag=2.7713
+ delta=0.018               pscbe1=4.632e+008         pscbe2=5e-016
+ fprout=0                  pdits=1                   pditsd=3
+ pditsl=1300000            rsh=15.5                  rsw=203+drdswp_hvt
+ rdw=203+drdswp_hvt        prwg=0                    prwb=0
+ wr=1                      alpha0=7.45e-009          alpha1=0
+ beta0=12.21               agidl=1e-008              bgidl=2.17018e+009
+ cgidl=0.154               aigbacc=0.0125            bigbacc=0.004
+ cigbacc=0                 nigbacc=1                 aigbinv=0.01134
+ bigbinv=0.003             cigbinv=0.006             eigbinv=1.1
+ nigbinv=1                 aigc=0.0062447            bigc=0.000459788
+ cigc=-0.033313            aigsd=0.0047986           bigsd=0.00061108
+ cigsd=0.14                nigc=1                    poxedge=1
+ pigcd=3.0117              ntox=ntoxp_hvt            xrcrg1=12
+ xrcrg2=1                  cgso=cgop_hvt             cgdo=cgop_hvt
+ cgbo=0                    cgdl=cglp_hvt             cgsl=cglp_hvt
+ clc=1e-007                cle=0.6                   cf=cfp_hvt
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=5                    noff=2.3898               voffcv=-0.084627
+ kt1=-0.21653813           pkt1=0+dpkt1p_hvt         lkt1=0+dlkt1p_hvt
+ wkt1=-3.6725099e-009      kt1l=0                    kt2=-0.017053333
+ pkt2=0+dpkt2p_hvt         lkt2=0+dlkt2p_hvt         wkt2=6.4885333e-010
+ ute=-1                    ua1=4.5216667e-009+dua1p_hvt
+ wua1=4.0553333e-017       ub1=-6e-018+dub1p_hvt     uc1=-4e-011+duc1p_hvt
+ prt=0                     at=150000+datp_hvt        jss=1.45e-07
+ jsd=1.45e-07              jsws=1.57e-13             jswd=1.57e-13
+ jswgs=1.57e-13            jswgd=1.57e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.52
+ bvd=9.52                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp_hvt
+ cjd=cjp_hvt               mjs=0.315                 mjd=0.315
+ pbsws=0.49                pbswd=0.49                cjsws=cjswp_hvt
+ cjswd=cjswp_hvt           mjsws=0.039               mjswd=0.039
+ pbswgs=1.05               pbswgd=1.05               cjswgs=cjswgp_hvt
+ cjswgd=cjswgp_hvt         mjswgs=0.98               mjswgd=0.98
+ tpb=1.68e-03              tcj=9.50e-04              tpbsw=2.10e-03
+ tcjsw=2.80e-04            tpbswg=1.50e-03           tcjswg=1.50e-03
+ xtis=3                    xtid=3                    jtsswgs=1.0733e-006
+ jtsswgd=1.0733e-006       njtsswg=15.5268           xtsswgs=0.18
+ xtsswgd=0.18              tnjtsswg=0.811            dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp_hvt        wvth0=0+dwvthp_hvt        pvth0=0+dpvthp_hvt
+ lk2=0+dlk2p_hvt           pk2=0+dpk2p_hvt           lcit=0+dlcitp_hvt
+ wcit=0+dwcitp_hvt         pcit=0+dpcitp_hvt         lvoff=0+dlvoffp_hvt
+ pvoff=0+dpvoffp_hvt       lnfactor=0+dlnfactorp_hvt wnfactor=0+dwnfactorp_hvt
+ pnfactor=0+dpnfactorp_hvt leta0=0+dleta0p_hvt       peta0=0+dpeta0p_hvt
+ lu0=0+dlu0p_hvt           pu0=0+dpu0p_hvt           lvsat=0+dlvsatp_hvt
+ wvsat=0+dwvsatp_hvt       pvsat=0+dpvsatp_hvt       la0=0+dla0p_hvt
+ pa0=0+dpa0p_hvt           lags=0+dlagsp_hvt         wags=0+dwagsp_hvt
+ pags=0+dpagsp_hvt         lpclm=0+dlpclmp_hvt       wpclm=0+dwpclmp_hvt
+ ppclm=0+dppclmp_hvt       lub1=0+dlub1p_hvt         lua1=0+dlua1p_hvt
+ luc1=0+dluc1p_hvt         wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0038
+ pkvth0we=0.5e-17          wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0090             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-1.8e-10           k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    fnoimod=1                 af=1
+ kf=0                      tnoimod=0                 noia=noiap_hvt
+ noib=noibp_hvt            noic=noicp_hvt            em=3e+7
+ ef=1.1                    lintnoi=-1e-8             minr=1e-3
 
 
     17: type=p 
+ lmin=1.000003e-006-dxlp_hvt                         lmax=1e-005-dxlp_hvt

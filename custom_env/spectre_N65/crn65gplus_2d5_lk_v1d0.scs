+ beta0=5.808               agidl=1.5797e-008         bgidl=1.4527e+009
+ cgidl=1.4892              egidl=0.81976             aigbacc=0.013432
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010744
+ bigc=0.000824385          cigc=-0.087762            aigsd=0.0093701
+ bigsd=0.0012397           cigsd=0.081703            nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=7.6133               noff=2.4067
+ voffcv=-0.12779           kt1=-0.25786522+dkt1n     lkt1=-6.5778293e-009+dlkt1n
+ kt1l=0                    kt2=-0.03488813+dkt2n     lkt2=-1.7130186e-009+dlkt2n
+ ute=-1                    ua1=3.7564104e-009+dua1n  lua1=-1.5828643e-016+dlua1n
+ ub1=-4.2233008e-018+dub1n lub1=2.0548668e-025+dlub1n
+ uc1=3.894454e-12          luc1=2.2086659e-020       prt=0
+ at=121372.55+datn         lat=-0.0031189299+dlatn   jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn
+ wvth0=0+dwvthn            pvth0=0+dpvthn            wk2=0+dwk2n
+ pk2=0+dpk2n               wcit=0+dwcitn             pcit=0+dpcitn
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ weta0=0+dweta0n           peta0=0+dpeta0n           wu0=0+dwu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           wvsat=0+dwvsatn
+ pvsat=0+dpvsatn           pags=0+dpagsn             ppclm=0+dppclmn
+ pat=0+dpatn               wvoff=0+dwvoffn           pvoff=0+dpvoffn
+ wa0=0+dwa0n               pa0=0+dpa0n               wkt1=0+dwkt1n
+ pkt1=0+dpkt1n             wkt2=0+dwkt2n             pkt2=0+dpkt2n
+ wua1=0+dwua1n             pua1=0+dpua1n             wub1=0+dwub1n
+ pub1=0+dpub1n             wat=0+dwatn               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.15e-17         wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0017             pku0we=-1.4e-17
+ wku0we=-2.0e-10           lku0we=1.88e-10           k2we=0.00045
+ pk2we=-0.26e-17           wk2we=0.4e-10             lk2we=0.1e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noian                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn                rnoib=0
+ noic=noicn                em=3e+8                   ef=0.9
+ lintnoi=-1e-8             minr=1e-3
 
 
     5: type=n 
+ lmin=6e-08                lmax=1e-007-(dxln+dlmisn) wmin=1e-005-(dxwn+dwmisn)
+ wmax=0.0009000001         version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn+toxmisn)       toxm=2e-009               dtox=2.4905e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)+0.00110289*ff_flag-0.000882314*sf_flag+0.000882314*fs_flag
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=0.051218642+dk2n
+ lk2=-2.5021548e-009+dlk2n k3=-3.98252               k3b=2.24786
+ w0=0                      dvt0=1.08116              dvt1=1.18773
+ dvt2=0.015579             dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.5                  minv=-0.46494
+ voffl=0                   dvtp0=4.20003e-007        dvtp1=0
+ lpe0=6.10104e-009         lpeb=4.55849e-008         xj=1.1e-007
+ ngate=3.1592e+020         ndep=6.3687e+017          nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0023279787          lcit=2.537653e-010+dlcitn
+ voff=-0.14378378+dvoffn   lvoff=-1.4247011e-009+dlvoffn
+ nfactor=0.6+dnfactorn     eta0=0.11019929+deta0n    leta0=1.4910897e-009+dleta0n
+ etab=-0.074081686         letab=1.2785077e-009      u0=0.02120608+du0n+0.000187492*ff_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.7244929e-010+dlu0n-1.46562e-11*ff_flag
+ ua=-2.0343596e-009        lua=1.5030836e-017        ub=2.2949305e-018-2.20579e-20*ff_flag
+ pub=0+0.0*ff_flag         wub=0+0.0*ff_flag         lub=-1.0622849e-026+1.72426e-27*ff_flag
+ uc=1.6e-10                vsat=101530+dvsatn        kvsat=1
+ a0=0.46397988+da0n        la0=6.5682484e-010+dla0n  ags=3.3273428+dagsn
+ lags=-4.0391182e-008+dlagsn                         a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.27593121          lketa=1.3752543e-008      dwg=0
+ dwb=0                     pclm=0.36870752+dpclmn+0.0330868*sf_flag-0.0441157*fs_flag
+ wpclm=0+0.0*sf_flag+0.0*fs_flag                     lpclm=2.9420193e-009-2.58639e-09*sf_flag+3.44851e-09*fs_flag
+ pdiblc1=0                 pdiblc2=-0.0075663681     lpdiblc2=9.540016e-010
+ pdiblcb=-0.03716          drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.44984             pditsd=1
+ pditsl=264000             rsh=16                    rsw=45+drdswn
+ rdw=45+drdswn             prwg=0                    prwb=0
+ wr=1                      alpha0=3.3929e-010        alpha1=0.0034
+ beta0=5.808               agidl=1.5797e-008         bgidl=1.4527e+009
+ cgidl=1.4892              egidl=0.81976             aigbacc=0.013432
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010744
+ bigc=0.000824385          cigc=-0.087762            aigsd=0.0093701
+ bigsd=0.0012397           cigsd=0.081703            nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=7.6133               noff=2.4067
+ voffcv=-0.12779           kt1=-0.31427052+dkt1n     lkt1=-2.1686268e-009+dlkt1n
+ kt1l=0                    kt2=-0.054428533+dkt2n    lkt2=-1.8554526e-010+dlkt2n
+ ute=-1                    ua1=1.8068687e-009+dua1n  lua1=-5.8907625e-018+dlua1n
+ ub1=-1.6663442e-018+dub1n lub1=5.6093821e-027+dlub1n
+ uc1=-6.009913e-11         luc1=5.0244652e-018       prt=0
+ at=103425.08+datn         lat=-0.0017159755+dlatn   jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn-8.62128e-11*ff_flag+6.89703e-11*sf_flag-6.89703e-11*fs_flag
+ wvth0=0+dwvthn+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag  pvth0=0+dpvthn+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ wk2=0+dwk2n               pk2=0+dpk2n               wcit=0+dwcitn
+ pcit=0+dpcitn             lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn
+ pnfactor=0+dpnfactorn     weta0=0+dweta0n           peta0=0+dpeta0n
+ wu0=0+dwu0n+0.0*ff_flag   pu0=0+dpu0n+0.0*ff_flag   lvsat=0+dlvsatn
+ wvsat=0+dwvsatn           pvsat=0+dpvsatn           pags=0+dpagsn
+ ppclm=0+dppclmn+0.0*sf_flag+0.0*fs_flag             pat=0+dpatn
+ wvoff=0+dwvoffn           pvoff=0+dpvoffn           wa0=0+dwa0n
+ pa0=0+dpa0n               wkt1=0+dwkt1n             pkt1=0+dpkt1n
+ wkt2=0+dwkt2n             pkt2=0+dpkt2n             wua1=0+dwua1n
+ pua1=0+dpua1n             wub1=0+dwub1n             pub1=0+dpub1n
+ wat=0+dwatn               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.0036
+ pkvth0we=0.15e-17         wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0017             pku0we=-1.4e-17           wku0we=-2.0e-10
+ lku0we=1.88e-10           k2we=0.00045              pk2we=-0.26e-17
+ wk2we=0.4e-10             lk2we=0.1e-12             fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn                rnoib=0                   noic=noicn
+ em=3e+8                   ef=0.9                    lintnoi=-1e-8
+ minr=1e-3
 
 
     6: type=n 
+ lmin=9.999997e-006-(dxln+dlmisn)                    lmax=2.00001e-05
+ wmin=1e-006-(dxwn+dwmisn) wmax=1e-005-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31800742+(dvthn+vthmisn)                     k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0075683019+dk2n     wk2=-1.0366101e-009+dwk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00054338288         wcit=2.9463898e-010+dwcitn
+ voff=-0.13904335+dvoffn   wvoff=-7.4208425e-010+dwvoffn
+ nfactor=0.6+dnfactorn     eta0=0.12703028+deta0n    weta0=2.2432991e-008+dweta0n
+ etab=-0.064804675         wetab=7.0900011e-008      u0=0.021912987+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-3.1981655e-009+dwu0n ua=-1.7257384e-009
+ wua=-3.9119235e-017       ub=2.0228642e-18          pub=0
+ lub=0                     wub=-4.31757e-27          uc=4.626158e-11
+ puc=0                     luc=0                     wuc=-3.5707288e-17
+ vsat=101530+dvsatn        a0=3.3794843+da0n         wa0=-6.17314e-08+dwa0n
+ kvsat=1                   ags=0.64130173+dagsn+0.0338667*ff_flag-0.0338667*ss_flag
+ wags=1.409809e-07-3.39209e-07*ff_flag+3.39209e-07*ss_flag
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.034074782         wketa=-6.4440683e-009
+ dwg=0                     dwb=0                     pclm=0.053744812+dpclmn
+ wpclm=1.9108747e-013      pdiblc1=0                 pdiblc2=0.00092275906
+ wpdiblc2=5.8899216e-010   pdiblcb=-0.03716          drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.44984
+ pditsd=1                  pditsl=264000             rsh=16
+ rsw=45+drdswn             rdw=45+drdswn             prwg=0
+ prwb=0                    wr=1                      alpha0=3.3929e-010
+ alpha1=0.0034             beta0=5.808               agidl=1.5797e-008
+ bgidl=1.4527e+009         cgidl=1.4892              egidl=0.81976
+ aigbacc=0.013432          bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010744             bigc=0.000824385          cigc=-0.087762
+ aigsd=0.0093701           bigsd=0.0012397           cigsd=0.081703
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn                xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=7.6133
+ noff=2.4067               voffcv=-0.12779           kt1=-0.23073722+dkt1n
+ wkt1=-6.3844643e-009+dwkt1n                         kt1l=0
+ kt2=-0.036788684+dkt2n    wkt2=-3.9923944e-009+dwkt2n
+ ute=-1                    ua1=3.0124892e-09+dua1n   wua1=-6.7518098e-16+dwua1n
+ ub1=-1.206109e-018+dub1n  wub1=-1.9253722e-025+dwub1n
+ uc1=3.0495745e-10         puc1=0                    luc1=0
+ wuc1=-9.174607e-17        prt=0                     at=200000+datn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=2.26139e-10+dwvthn  pvth0=0+dpvthn
+ lk2=0+dlk2n               pk2=0+dpk2n               lcit=0+dlcitn
+ pcit=0+dpcitn             lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn
+ pnfactor=0+dpnfactorn     leta0=0+dleta0n           peta0=0+dpeta0n
+ lu0=0+dlu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ wvsat=0+dwvsatn           pvsat=0+dpvsatn           lags=0+dlagsn+0.0*ff_flag+0.0*ss_flag
+ pags=0+dpagsn+0.0*ff_flag+0.0*ss_flag               ppclm=0+dppclmn
+ lkt1=0+dlkt1n             pat=0+dpatn               lat=0+dlatn
+ lvoff=0+dlvoffn           pvoff=0+dpvoffn           la0=0+dla0n
+ pa0=0+dpa0n               pkt1=0+dpkt1n             lkt2=0+dlkt2n
+ pkt2=0+dpkt2n             lua1=0+dlua1n             pua1=0+dpua1n
+ lub1=0+dlub1n             pub1=0+dpub1n             wat=0+dwatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     7: type=n 
+ lmin=9.999973e-007-(dxln+dlmisn)                    lmax=9.999997e-006-(dxln+dlmisn)
+ wmin=1e-006-(dxwn+dwmisn) wmax=1e-005-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31810997+(dvthn+vthmisn)                     k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0079814068+dk2n     lk2=4.1080062e-009+dlk2n
+ wk2=-1.2848541e-009+dwk2n pk2=2.4685931e-015+dpk2n  k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00052333036
+ lcit=1.9940668e-010+dlcitn                          wcit=2.9090379e-010+dwcitn
+ pcit=3.7143538e-017+dpcitn                          voff=-0.13953477+dvoffn
+ lvoff=4.8867333e-009+dlvoffn                        wvoff=-8.2156382e-010+dwvoffn
+ pvoff=7.9036239e-016+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.12703028+deta0n    weta0=2.2432991e-008+dweta0n
+ etab=-0.064804675         wetab=7.0900011e-008      u0=0.021923199+du0n+2.36871e-06*ss_flag-1.77653e-06*ff_flag+1.42123e-06*sf_flag-1.42123e-06*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.0155589e-010+dlu0n-2.3555e-11*ss_flag+1.76662e-11*ff_flag-1.4133e-11*sf_flag+1.4133e-11*fs_flag
+ wu0=-3.3007896e-009+dwu0n-2.3725e-11*ss_flag+1.77937e-11*ff_flag-1.4235e-11*sf_flag+1.4235e-11*fs_flag
+ pu0=1.0205172e-015+dpu0n+2.35927e-16*ss_flag-1.76945e-16*ff_flag+1.41556e-16*sf_flag-1.41556e-16*fs_flag
+ ua=-1.7488009e-009        lua=2.2933818e-016        wua=-4.0637602e-017
+ pua=1.5098972e-023        ub=2.0075344e-18          lub=1.524436e-25
+ wub=-2.24953e-27          pub=-2.05651e-32          uc=4.0208647e-11
+ luc=6.0191683e-17         wuc=-3.7857606e-17        puc=2.1383236e-23
+ vsat=101530+dvsatn-23.6871*ss_flag-23.6871*ff_flag+18.9497*sf_flag-18.9497*fs_flag
+ kvsat=1                   a0=3.4619214+da0n+0.00236871*ff_flag
+ la0=-8.1977191e-07+dla0n-2.3555e-08*ff_flag         wa0=-7.03314e-08+dwa0n-2.3725e-08*ff_flag
+ pa0=8.55202e-14+dpa0n+2.35927e-13*ff_flag           ags=0.51829236+dagsn+0.0374197*ff_flag-0.0374197*ss_flag
+ lags=1.2232313e-06+dlagsn-3.53325e-08*ff_flag+3.53325e-08*ss_flag
+ wags=1.656315e-07-3.74796e-07*ff_flag+3.74796e-07*ss_flag
+ pags=-2.451308e-13+dpagsn+3.5389e-13*ff_flag-3.5389e-13*ss_flag
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.027158347         lketa=-6.8778545e-008
+ wketa=-7.120137e-009      pketa=6.7229758e-015      dwg=0
+ dwb=0                     pclm=0.05374479+dpclmn    lpclm=2.1612244e-013
+ wpclm=2.3118272e-013      ppclm=-3.9871596e-019+dppclmn
+ pdiblc1=0                 pdiblc2=0.00054630852     lpdiblc2=3.743507e-009
+ wpdiblc2=5.3154454e-010   ppdiblc2=5.7127174e-016   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.22933778+dkt1n     lkt1=-1.3916337e-008+dlkt1n
+ wkt1=-6.3774404e-009+dwkt1n                         pkt1=-6.9847251e-017+dpkt1n
+ kt1l=0                    kt2=-0.036586581+dkt2n    lkt2=-2.0097606e-009+dlkt2n
+ wkt2=-5.0850098e-009+dwkt2n                         pkt2=1.0865207e-014+dpkt2n
+ ute=-1                    ua1=3.0802128e-09+dua1n   lua1=-6.7345807e-16+dlua1n
+ wua1=-7.4895608e-16+dwua1n                          pua1=7.3363589e-22+dpua1n
+ ub1=-1.1292762e-018+dub1n lub1=-7.6404237e-025+dlub1n
+ wub1=-2.190466e-025+dwub1n                          pub1=2.6361515e-031+dpub1n
+ uc1=3.3182461e-10         luc1=-2.6717287e-16       wuc1=-9.876257e-17
+ puc1=6.977364e-23         prt=0                     at=200000+datn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=-1.0197263e-09+dlvthn                         wvth0=2.49864e-10+dwvthn
+ pvth0=-2.359266e-16+dpvthn                          lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     leta0=0+dleta0n
+ peta0=0+dpeta0n           lvsat=0+dlvsatn+0.00023555*ss_flag+0.00023555*ff_flag-0.00018844*sf_flag+0.00018844*fs_flag
+ wvsat=0+dwvsatn+0.00023725*ss_flag+0.00023725*ff_flag-0.0001898*sf_flag+0.0001898*fs_flag
+ pvsat=0+dpvsatn-2.35927e-09*ss_flag-2.35927e-09*ff_flag+1.88741e-09*sf_flag-1.88741e-09*fs_flag
+ pat=0+dpatn               lat=0+dlatn               wat=0+dwatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     8: type=n 
+ lmin=2.399969e-007-(dxln+dlmisn)                    lmax=9.999973e-007-(dxln+dlmisn)
+ wmin=1e-006-(dxwn+dwmisn) wmax=1e-005-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=3.259685e-09+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0059651147+dk2n     lk2=2.2041828e-009+dlk2n
+ wk2=2.0282283e-009+dwk2n  pk2=-6.5968563e-016+dpk2n k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00035635917
+ lcit=3.5706421e-010+dlcitn                          wcit=3.6962412e-010+dwcitn
+ pcit=-3.7185769e-017+dpcitn                         voff=-0.13220088+dvoffn
+ lvoff=-2.0380694e-009+dlvoffn                       wvoff=-1.1910681e-009+dwvoffn
+ pvoff=1.1392557e-015+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.12703028+deta0n    weta0=2.2432991e-008+dweta0n
+ etab=-0.064804675         wetab=7.0900011e-008      u0=0.021976956+du0n-2.90062e-05*ss_flag+2.17546e-05*ff_flag-1.74037e-05*sf_flag+1.74037e-05*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.5231393e-010+dlu0n+6.06983e-12*ss_flag-4.55238e-12*ff_flag+3.6419e-12*sf_flag-3.6419e-12*fs_flag
+ wu0=-2.1114046e-009+dwu0n+2.90526e-10*ss_flag-2.17894e-10*ff_flag+1.74316e-10*sf_flag-1.74316e-10*fs_flag
+ pu0=-1.0252399e-016+dpu0n-6.07955e-17*ss_flag+4.55966e-17*ff_flag-3.64773e-17*sf_flag+3.64773e-17*fs_flag
+ ua=-1.4714753e-009        lua=-3.2518226e-017       wua=-3.6706412e-017
+ pua=1.1387065e-023        ub=2.1849631e-018         lub=-1.5088135e-026
+ wub=1.2488297e-026        pub=-3.4480844e-032       uc=1.0133582e-10
+ luc=2.4741843e-018        wuc=-9.5018438e-018       puc=-5.390842e-024
+ vsat=101530+dvsatn+290.062*ss_flag+290.062*ff_flag-232.049*sf_flag+232.049*fs_flag
+ kvsat=1                   a0=3.2227346+da0n-0.0290062*ff_flag
+ la0=-5.9392698e-007+dla0n+6.06983e-09*ff_flag       wa0=-1.8171776e-008+dwa0n+2.90526e-07*ff_flag
+ pa0=3.6269975e-014+dpa0n-6.07955e-14*ff_flag        ags=0.86281578+dagsn
+ lags=8.9792544e-007+dlagsn                          wags=4.1596146e-007
+ pags=-4.8149738e-013+dpagsn                         a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.1                 dwg=0                     dwb=0
+ pclm=0.045944057+dpclmn   lpclm=7.3658248e-009      wpclm=3.5012789e-010
+ ppclm=-3.3077818e-016+dppclmn                       pdiblc1=0
+ pdiblc2=0.0020037103      lpdiblc2=2.3673991e-009   wpdiblc2=1.1510082e-009
+ ppdiblc2=-1.3638266e-017  pdiblcb=-0.03716          drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.44984
+ pditsd=1                  pditsl=264000             rsh=16
+ rsw=45+drdswn             rdw=45+drdswn             prwg=0
+ prwb=0                    wr=1                      alpha0=3.3929e-010
+ alpha1=0.0034             beta0=5.808               agidl=1.5797e-008
+ bgidl=1.4527e+009         cgidl=1.4892              egidl=0.81976
+ aigbacc=0.013432          bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010744             bigc=0.000824385          cigc=-0.087762
+ aigsd=0.0093701           bigsd=0.0012397           cigsd=0.081703
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn                xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=7.6133
+ noff=2.4067               voffcv=-0.12779           kt1=-0.23136759+dkt1n
+ lkt1=-1.1999746e-008+dlkt1n                         wkt1=-6.612354e-009+dwkt1n
+ pkt1=1.5196284e-016+dpkt1n                          kt1l=0
+ kt2=-0.037485693+dkt2n    lkt2=-1.1608012e-009+dlkt2n
+ wkt2=8.3684721e-009+dwkt2n                          pkt2=-1.8378392e-015+dpkt2n
+ ute=-1                    ua1=2.1656308e-09+dua1n   lua1=1.9010847e-16+dlua1n
+ wua1=2.4734484e-16+dwua1n pua1=-2.0709135e-22+dpua1n
+ ub1=-1.5421893e-018+dub1n lub1=-3.7416161e-025+dlub1n
+ wub1=-1.7619944e-025+dwub1n                         pub1=2.23158e-031+dpub1n
+ uc1=6.2292646e-11         luc1=-1.2675412e-017      wuc1=-3.8449052e-017
+ puc1=1.2824409e-023       prt=0                     at=226568.84+datn
+ lat=-0.025086829+dlatn    wat=0.00061973913+dwatn   pat=-5.8517008e-010+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=0+dwvthn            pvth0=0+dpvthn
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lvsat=0+dlvsatn-6.06983e-05*ss_flag-6.06983e-05*ff_flag+4.85587e-05*sf_flag-4.85587e-05*fs_flag
+ wvsat=0+dwvsatn-0.00290526*ss_flag-0.00290526*ff_flag+0.00232421*sf_flag-0.00232421*fs_flag
+ pvsat=0+dpvsatn+6.07955e-10*ss_flag+6.07955e-10*ff_flag-4.86364e-10*sf_flag+4.86364e-10*fs_flag
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     9: type=n 
+ lmin=1e-007-(dxln+dlmisn) lmax=2.399969e-007-(dxln+dlmisn)
+ wmin=1e-006-(dxwn+dwmisn) wmax=1e-005-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ k2=-0.0041123731+dk2n     kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lk2=1.8164781e-009+dlk2n
+ wk2=-2.2983394e-009+dwk2n pk2=2.4569193e-016+dpk2n  k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.00014804749
+ lcit=4.6261635e-010+dlcitn                          wcit=1.4753784e-009+dwcitn
+ pcit=-2.6857591e-016+dpcitn                         voff=-0.12931886+dvoffn
+ lvoff=-2.6411604e-009+dlvoffn                       wvoff=2.3858227e-010+dwvoffn
+ pvoff=8.400871e-016+dpvoffn                         nfactor=0.6+dnfactorn
+ eta0=0.12702749+deta0n    leta0=5.8414043e-013+dleta0n
+ weta0=2.2435567e-008+dweta0n                        peta0=-5.3897131e-019+dpeta0n
+ etab=-0.06480454          letab=-2.8262198e-014     wetab=7.08999e-008
+ petab=2.3109453e-020      u0=0.022320968+du0n       lu0=-2.24302e-010+dlu0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-1.4555707e-009+dwu0n pu0=-2.3976379e-016+dpu0n
+ ua=-1.4967634e-009        lua=-2.7226435e-017       wua=1.0438898e-017
+ pua=1.521437e-024         ub=2.0634228e-018         lub=1.0345374e-026
+ wub=-2.3715874e-026       pub=-2.6904759e-032       uc=7.91364e-11
+ luc=7.1196346e-018        wuc=4.720788e-018         puc=-8.3670699e-024
+ vsat=101530+dvsatn        a0=0.40094308+da0n        la0=-3.4388967e-009+dla0n
+ kvsat=1                   wa0=-4.4175841e-007+dwa0n pa0=1.2490971e-013+dpa0n
+ ags=6.478622+dagsn        lags=-2.7723817e-007+dlagsn
+ wags=-2.2840519e-006      pags=8.3507413e-014+dpagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.1                 dwg=0
+ dwb=0                     pclm=-0.12099972+dpclmn+0.00201949*ss_flag-0.00269265*ff_flag+0.00215412*sf_flag-0.00215412*fs_flag
+ lpclm=4.230048e-008-4.22598e-10*ss_flag+5.63463e-10*ff_flag-4.50771e-10*sf_flag+4.50771e-10*fs_flag
+ wpclm=8.0404227e-008-2.02272e-08*ss_flag+2.69696e-08*ff_flag-2.15756e-08*sf_flag+2.15756e-08*fs_flag
+ ppclm=-1.7082899e-014+dppclmn+4.23274e-15*ss_flag-5.64365e-15*ff_flag+4.51492e-15*sf_flag-4.51492e-15*fs_flag
+ pdiblc1=0                 pdiblc2=0.018624584       lpdiblc2=-1.110685e-009
+ wpdiblc2=4.0846591e-010   ppdiblc2=1.4174614e-016   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.25635598+dkt1n     lkt1=-6.7706745e-009+dlkt1n
+ wkt1=-1.5116486e-008+dwkt1n                         pkt1=1.9315376e-015+dpkt1n
+ kt1l=0                    kt2=-0.035543769+dkt2n    lkt2=-1.567168e-009+dlkt2n
+ wkt2=6.566886e-009+dwkt2n pkt2=-1.4608393e-015+dpkt2n
+ ute=-1                    ua1=3.8485974e-009+dua1n  lua1=-1.6206912e-016+dlua1n
+ wua1=-9.2334584e-016+dwua1n                         pua1=3.7887376e-023+dpua1n
+ ub1=-4.343838e-018+dub1n  lub1=2.1211141e-025+dlub1n
+ wub1=1.2073009e-024+dwub1n                          pub1=-6.6353287e-032+dpub1n
+ uc1=4.932709e-12          luc1=-6.7227147e-019      wuc1=-1.0399171e-017
+ puc1=6.9546911e-024       prt=0                     at=120004.69+datn
+ lat=-0.0027872146+dlatn   wat=0.013700549+dwatn     pat=-3.3224603e-009+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=0+dwvthn            pvth0=0+dpvthn
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ lvsat=0+dlvsatn           wvsat=0+dwvsatn           pvsat=0+dpvsatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     10: type=n 
+ lmin=6e-08                lmax=1e-007-(dxln+dlmisn) wmin=1e-006-(dxwn+dwmisn)
+ wmax=1e-005-(dxwn+dwmisn) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn+toxmisn)       toxm=2e-009               dtox=2.4905e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)+0.000709675*ss_flag+0.000791639*ff_flag-0.000633306*sf_flag+0.000633306*fs_flag
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=0.051791765+dk2n
+ lk2=-2.5535483e-009+dlk2n wk2=-5.7403941e-009+dwk2n pk2=5.1475735e-016+dpk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.002708028-1.24504e-05*ss_flag                 lcit=2.3935693e-010+dlcitn+9.73247e-13*ss_flag
+ wcit=-3.8065734e-009+dwcitn+1.24704e-10*ss_flag     pcit=1.4431426e-016+dpcitn-9.74804e-18*ss_flag
+ voff=-0.14466798+dvoffn   lvoff=-1.4413201e-009+dlvoffn
+ wvoff=8.8560978e-009+dwvoffn                        pvoff=1.6645591e-016+dpvoffn
+ nfactor=0.6+dnfactorn     eta0=0.10605999+deta0n+0.000124504*ff_flag-9.96034e-05*sf_flag+9.96034e-05*fs_flag
+ leta0=1.6396139e-009+dleta0n-9.73251e-12*ff_flag+7.78603e-12*sf_flag-7.78603e-12*fs_flag
+ weta0=4.1459229e-008+dweta0n-1.24704e-09*ff_flag+9.97635e-10*sf_flag-9.97635e-10*fs_flag
+ peta0=-1.4876186e-015+dpeta0n+9.74803e-17*ff_flag-7.7984e-17*sf_flag+7.7984e-17*fs_flag
+ etab=-0.087221494         letab=1.752305e-009       wetab=1.3160831e-007
+ petab=-4.7455535e-015     u0=0.021510701+du0n+0.000171306*ff_flag+2.9881e-05*sf_flag-2.9881e-05*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-1.609634e-010+dlu0n-1.3391e-11*ff_flag-2.33579e-12*sf_flag+2.33579e-12*fs_flag
+ wu0=-3.051082e-009+dwu0n+1.62115e-10*ff_flag-2.99288e-10*sf_flag+2.99288e-10*fs_flag
+ pu0=-1.1504266e-016+dpu0n-1.26724e-17*ff_flag+2.33953e-17*sf_flag-2.33953e-17*fs_flag
+ ua=-2.0412421e-009        lua=1.5335468e-017        wua=6.8934927e-017
+ pua=-3.0511976e-024       ub=2.3110717e-018-2.49009e-21*ss_flag-2.01903e-20*ff_flag-3.48612e-21*sf_flag+3.48612e-21*fs_flag
+ lub=-9.0133403e-027+1.94649e-28*ss_flag+1.57828e-27*ff_flag+2.72509e-28*sf_flag-2.72509e-28*fs_flag
+ wub=-1.6167054e-025+2.49407e-26*ss_flag-1.87056e-26*ff_flag+3.4917e-26*sf_flag-3.4917e-26*fs_flag
+ pub=-1.6120843e-032-1.94961e-33*ss_flag+1.4622e-33*ff_flag-2.72945e-33*sf_flag+2.72945e-33*fs_flag
+ uc=1.6388909e-10          luc=4.9451673e-019        wuc=-3.8953131e-017
+ puc=-4.9530796e-024       vsat=101530+dvsatn        a0=0.22660787+da0n
+ la0=1.0188887e-008+dla0n  kvsat=1                   wa0=2.3775181e-006+dwa0n
+ pa0=-9.5473132e-014+dpa0n ags=3.5070566+dagsn       lags=-4.4950898e-008+dlagsn
+ wags=-1.8000132e-006      pags=4.5670112e-014+dpagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.28290012          lketa=1.4297302e-008
+ wketa=6.9800554e-008      pketa=-5.4563093e-015     dwg=0
+ dwb=0                     pclm=0.37727644+dpclmn-0.013347*ss_flag+0.0157209*ff_flag+0.0242451*sf_flag-0.0365191*fs_flag
+ lpclm=3.3502325e-009+7.78598e-10*ss_flag-8.75923e-10*ff_flag-2.17762e-09*sf_flag+3.13707e-09*fs_flag
+ wpclm=-8.5826247e-008+1.33684e-07*ss_flag-1.57461e-07*ff_flag+8.85579e-08*sf_flag-7.60876e-08*fs_flag
+ ppclm=-4.0886629e-015+dppclmn-7.79843e-15*ss_flag+8.77324e-15*ff_flag-4.09418e-15*sf_flag+3.11937e-15*fs_flag
+ pdiblc1=0                 pdiblc2=-0.0083299598     lpdiblc2=9.9635172e-010
+ wpdiblc2=7.6481352e-009   ppdiblc2=-4.2417881e-016  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.3174617+dkt1n      lkt1=-1.9940404e-009+dlkt1n
+ wkt1=3.196289e-008+dwkt1n pkt1=-1.7486573e-015+dpkt1n
+ kt1l=0                    kt2=-0.053058659+dkt2n    lkt2=-1.9802909e-010+dlkt2n
+ wkt2=-1.3720658e-008+dwkt2n                         pkt2=1.2503807e-016+dpkt2n
+ ute=-1                    ua1=1.8203262e-009+dua1n  lua1=-3.5191531e-018+dlua1n
+ wua1=-1.3478993e-016+dwua1n                         pua1=-2.3754039e-023+dpua1n
+ ub1=-1.6749506e-018+dub1n lub1=3.4844744e-027+dlub1n
+ wub1=8.620125e-026+dwub1n pub1=2.1283076e-032+dpub1n
+ uc1=-7.249804e-11         luc1=5.3804901e-018       wuc1=1.2418745e-016
+ puc1=-3.5659453e-024      prt=0                     at=108778.84+datn
+ lat=-0.0019096901+dlatn   wat=-0.053623302+dwatn    pat=1.9402451e-009+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn-5.54751e-11*ss_flag-6.18816e-11*ff_flag+4.95053e-11*sf_flag-4.95053e-11*fs_flag
+ wvth0=0+dwvthn-7.1081e-09*ss_flag+3.11758e-09*ff_flag-2.49407e-09*sf_flag+2.49407e-09*fs_flag
+ pvth0=0+dpvthn+5.55638e-16*ss_flag-2.43701e-16*ff_flag+1.94961e-16*sf_flag-1.94961e-16*fs_flag
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ lvsat=0+dlvsatn           wvsat=0+dwvsatn           pvsat=0+dpvsatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     11: type=n 
+ lmin=9.999997e-006-(dxln+dlmisn)                    lmax=2.00001e-05
+ wmin=6e-007-(dxwn+dwmisn) wmax=1e-006-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.322234+(dvthn+vthmisn)                       k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.004825167+dk2n      wk2=-3.8236351e-009+dwk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.0010437175         wcit=1.907133e-009+dwcitn voff=-0.14073014+dvoffn
+ wvoff=9.7169151e-010+dwvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.2008078+deta0n     weta0=-5.2524965e-008+dweta0n
+ etab=-0.027104328         wetab=3.2596458e-008      u0=0.019073472+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-3.1321902e-10+dwu0n  ua=-1.8729168e-009
+ wua=1.1041403e-016        ub=2.1428177e-18          pub=0
+ lub=0                     wub=-1.261903e-25         uc=1.2688199e-11
+ puc=0                     luc=0                     wuc=-1.596737e-18
+ vsat=101530+dvsatn        a0=1.4872698+da0n         wa0=1.8607586e-06+dwa0n
+ kvsat=1                   ags=0.6558303+dagsn-0.762*ff_flag+0.762*ss_flag
+ wags=1.262198e-07+4.69392e-07*ff_flag-4.69392e-07*ss_flag
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.046627605         wketa=6.3096004e-009
+ dwg=0                     dwb=0                     pclm=0.053745+dpclmn
+ pdiblc1=0                 pdiblc2=0.00018390811     wpdiblc2=1.3396647e-009
+ pdiblcb=-0.03716          drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.44984             pditsd=1
+ pditsl=264000             rsh=16                    rsw=45+drdswn
+ rdw=45+drdswn             prwg=0                    prwb=0
+ wr=1                      alpha0=3.3929e-010        alpha1=0.0034
+ beta0=5.808               agidl=1.5797e-008         bgidl=1.4527e+009
+ cgidl=1.4892              egidl=0.81976             aigbacc=0.013432
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010744
+ bigc=0.000824385          cigc=-0.087762            aigsd=0.0093701
+ bigsd=0.0012397           cigsd=0.081703            nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=7.6133               noff=2.4067
+ voffcv=-0.12779           kt1=-0.23336496+dkt1n     wkt1=-3.7146713e-009+dwkt1n
+ kt1l=0                    kt2=-0.046672302+dkt2n    wkt2=6.0493609e-009+dwkt2n
+ ute=-1                    ua1=1.6234841e-09+dua1n   wua1=7.3604826e-16+dwua1n
+ ub1=-1.7822821e-018+dub1n wub1=3.9285458e-025+dwub1n
+ uc1=2.5860118e-10         puc1=0                    luc1=0
+ wuc1=-4.46481e-17         prt=0                     at=200000+datn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=-4.068064e-09+dwvthn
+ pvth0=0+dpvthn            lk2=0+dlk2n               pk2=0+dpk2n
+ lcit=0+dlcitn             pcit=0+dpcitn             lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     leta0=0+dleta0n
+ peta0=0+dpeta0n           lu0=0+dlu0n               pu0=0+dpu0n
+ lvsat=0+dlvsatn           wvsat=0+dwvsatn           pvsat=0+dpvsatn
+ lags=0+dlagsn+0.0*ff_flag+0.0*ss_flag               pags=0+dpagsn+0.0*ff_flag+0.0*ss_flag
+ ppclm=0+dppclmn           lkt1=0+dlkt1n             pat=0+dpatn
+ lat=0+dlatn               lvoff=0+dlvoffn           pvoff=0+dpvoffn
+ la0=0+dla0n               pa0=0+dpa0n               pkt1=0+dpkt1n
+ lkt2=0+dlkt2n             pkt2=0+dpkt2n             lua1=0+dlua1n
+ pua1=0+dpua1n             lub1=0+dlub1n             pub1=0+dpub1n
+ wat=0+dwatn               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.0036
+ pkvth0we=0.15e-17         wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0017             pku0we=-1.4e-17           wku0we=-2.0e-10
+ lku0we=1.88e-10           k2we=0.00045              pk2we=-0.26e-17
+ wk2we=0.4e-10             lk2we=0.1e-12             fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn                rnoib=0                   noic=noicn
+ em=3e+8                   ef=0.9                    lintnoi=-1e-8
+ minr=1e-3
 
 
     12: type=n 
+ lmin=9.999973e-007-(dxln+dlmisn)                    lmax=9.999997e-006-(dxln+dlmisn)
+ wmin=6e-007-(dxwn+dwmisn) wmax=1e-006-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.32277997+(dvthn+vthmisn)                     k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0051700064+dk2n     lk2=3.4291582e-009+dlk2n
+ wk2=-4.141237e-009+dwk2n  pk2=3.1583027e-015+dpk2n  k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-0.001258194
+ lcit=2.1328017e-009+dlcitn                          wcit=2.1009326e-009+dwcitn
+ pcit=-1.9271858e-015+dpcitn                         voff=-0.14181272+dvoffn
+ lvoff=1.0765439e-008+dlvoffn                        wvoff=1.4928387e-009+dwvoffn
+ pvoff=-5.1824022e-015+dpvoffn                       nfactor=0.6+dnfactorn
+ eta0=0.2008078+deta0n     weta0=-5.2524965e-008+dweta0n
+ etab=-0.027104328         wetab=3.2596458e-008      u0=0.018620494+du0n-5.3296e-05*ss_flag+3.9972e-05*ff_flag-3.19776e-05*sf_flag+3.19776e-05*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=4.5045135e-09+dlu0n+5.29987e-10*ss_flag-3.9749e-10*ff_flag+3.17992e-10*sf_flag-3.17992e-10*fs_flag
+ wu0=5.475848e-11+dwu0n+3.28303e-11*ss_flag-2.46227e-11*ff_flag+1.96982e-11*sf_flag-1.96982e-11*fs_flag
+ pu0=-3.6592493e-15+dpu0n-3.26472e-16*ss_flag+2.44854e-16*ff_flag-1.95883e-16*sf_flag+1.95883e-16*fs_flag
+ ua=-1.9320158e-009        lua=5.8769326e-016        wua=1.4550877e-016
+ pua=-3.4898978e-022       ub=2.1431359e-18          lub=-3.1642e-27
+ wub=-1.400207e-25         pub=1.375324e-31          uc=8.38697e-13
+ luc=1.1783411e-16         wuc=2.142266e-18          puc=-3.7181467e-23
+ vsat=101530+dvsatn+532.96*ss_flag+532.96*ff_flag-426.368*sf_flag+426.368*fs_flag
+ kvsat=1                   a0=1.3178763+da0n-0.053296*ff_flag
+ la0=1.684486e-06+dla0n+5.29987e-07*ff_flag          wa0=2.1080184e-06+dwa0n+3.28303e-08*ff_flag
+ pa0=-2.4588058e-12+dpa0n-3.26472e-13*ff_flag        ags=0.5305611+dagsn-0.841944*ff_flag+0.841944*ss_flag
+ lags=1.2457051e-06+dlagsn+7.9498e-07*ff_flag-7.9498e-07*ss_flag
+ wags=1.531665e-07+5.18637e-07*ff_flag-5.18637e-07*ss_flag
+ pags=-2.679642e-13+dpagsn-4.89708e-13*ff_flag+4.89708e-13*ss_flag
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.038168302         lketa=-8.4121177e-008
+ wketa=4.0659765e-009      pketa=2.231109e-014       dwg=0
+ dwb=0                     pclm=0.053745045+dpclmn   lpclm=-4.4783892e-013
+ wpclm=-2.774162e-014      ppclm=2.7586877e-019+dppclmn
+ pdiblc1=0                 pdiblc2=-0.00035171068    lpdiblc2=5.3263111e-009
+ wpdiblc2=1.443932e-009    ppdiblc2=-1.0368573e-015  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.23150005+dkt1n     lkt1=-1.8545098e-008+dlkt1n
+ wkt1=-4.1805675e-009+dwkt1n                         pkt1=4.6329745e-015+dpkt1n
+ kt1l=0                    kt2=-0.049031199+dkt2n    lkt2=2.3457396e-008+dlkt2n
+ wkt2=7.5587224e-009+dwkt2n                          pkt2=-1.5009423e-014+dpkt2n
+ ute=-1                    ua1=1.4845093e-09+dua1n   lua1=1.3819958e-15+dlua1n
+ wua1=8.7227872e-16+dwua1n pua1=-1.3547052e-21+dpua1n
+ ub1=-1.7591889e-018+dub1n lub1=-2.2964325e-025+dlub1n
+ wub1=4.2094471e-025+dwub1n                          pub1=-2.7933435e-031+dpub1n
+ uc1=2.8601084e-10         luc1=-2.7256764e-16       wuc1=-5.221578e-17
+ puc1=7.525472e-23         prt=0                     at=200000+datn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=-5.4292356e-09+dlvthn                         wvth0=-4.4948581e-09+dwvthn
+ pvth0=4.2441349e-15+dpvthn                          lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     leta0=0+dleta0n
+ peta0=0+dpeta0n           lvsat=0+dlvsatn-0.00529987*ss_flag-0.00529987*ff_flag+0.0042399*sf_flag-0.0042399*fs_flag
+ wvsat=0+dwvsatn-0.000328303*ss_flag-0.000328303*ff_flag+0.000262643*sf_flag-0.000262643*fs_flag
+ pvsat=0+dpvsatn+3.26472e-09*ss_flag+3.26472e-09*ff_flag-2.61178e-09*sf_flag+2.61178e-09*fs_flag
+ pat=0+dpatn               lat=0+dlatn               wat=0+dwatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     13: type=n 
+ lmin=2.399969e-007-(dxln+dlmisn)                    lmax=9.999973e-007-(dxln+dlmisn)
+ wmin=6e-007-(dxwn+dwmisn) wmax=1e-006-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=3.259685e-09+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0027073579+dk2n     lk2=1.1038762e-009+dlk2n
+ wk2=-1.2816526e-009+dwk2n pk2=4.5822587e-016+dpk2n  k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00067570541
+ lcit=3.0677512e-010+dlcitn                          wcit=4.516833e-011+dwcitn
+ pcit=1.3907947e-017+dpcitn                          voff=-0.12896172+dvoffn
+ lvoff=-1.3687307e-009+dlvoffn                       wvoff=-4.4820504e-009+dwvoffn
+ pvoff=4.5920761e-016+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.2008078+deta0n     weta0=-5.2524965e-008+dweta0n
+ etab=-0.027104328         wetab=3.2596458e-008      u0=0.024072411+du0n+0.000652639*ss_flag-0.000489479*ff_flag+0.000391584*sf_flag-0.000391584*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-6.43295e-010+dlu0n-1.36571e-10*ss_flag+1.02428e-10*ff_flag-8.19428e-11*sf_flag+8.19428e-11*fs_flag
+ wu0=-4.2403868e-009+dwu0n-4.02026e-10*ss_flag+3.01519e-10*ff_flag-2.41215e-10*sf_flag+2.41215e-10*fs_flag
+ pu0=3.9631278e-016+dpu0n+8.41279e-17*ss_flag-6.30959e-17*ff_flag+5.04767e-17*sf_flag-5.04767e-17*fs_flag
+ ua=-1.2367313e-009        lua=-6.8808271e-017       wua=-2.7520625e-016
+ pua=4.825775e-023         ub=2.1774694e-018         lub=-3.5582547e-026
+ wub=2.010186e-026         pub=-1.3658521e-032       uc=1.2739605e-10
+ luc=-1.6638843e-018       wuc=-3.5979041e-017       puc=-1.1865642e-024
+ vsat=101530+dvsatn-6526.39*ss_flag-6526.39*ff_flag+5221.11*sf_flag-5221.11*fs_flag
+ kvsat=1                   a0=3.9180842+da0n+0.652639*ff_flag
+ la0=-7.7068226e-007+dla0n-1.36571e-07*ff_flag       wa0=-7.2464698e-007+dwa0n-4.02026e-07*ff_flag
+ pa0=2.1585334e-013+dpa0n+8.41279e-14*ff_flag        ags=0.71503897+dagsn
+ lags=1.0715174e-006+dlagsn                          wags=5.661027e-007
+ pags=-6.5786681e-013+dpagsn                         a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.13502021          lketa=7.3283284e-009      wketa=3.558053e-008
+ pketa=-7.4455817e-015     dwg=0                     dwb=0
+ pclm=0.083323805+dpclmn   lpclm=-2.7929305e-008     wpclm=-3.7627697e-008
+ ppclm=3.5529074e-014+dppclmn                        pdiblc1=0
+ pdiblc2=0.0023162562      lpdiblc2=2.8071634e-009   wpdiblc2=8.3346157e-010
+ ppdiblc2=-4.6043883e-016  pdiblcb=-0.03716          drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.44984
+ pditsd=1                  pditsl=264000             rsh=16
+ rsw=45+drdswn             rdw=45+drdswn             prwg=0
+ prwb=0                    wr=1                      alpha0=3.3929e-010
+ alpha1=0.0034             beta0=5.808               agidl=1.5797e-008
+ bgidl=1.4527e+009         cgidl=1.4892              egidl=0.81976
+ aigbacc=0.013432          bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010744             bigc=0.000824385          cigc=-0.087762
+ aigsd=0.0093701           bigsd=0.0012397           cigsd=0.081703
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn                xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=7.6133
+ noff=2.4067               voffcv=-0.12779           kt1=-0.24034943+dkt1n
+ lkt1=-1.0189337e-008+dlkt1n                         wkt1=2.5131977e-009+dwkt1n
+ pkt1=-1.6874125e-015+dpkt1n                         kt1l=0
+ kt2=-0.019166857+dkt2n    lkt2=-4.7411139e-009+dlkt2n
+ wkt2=-1.0243465e-008+dwkt2n                         pkt2=1.7997585e-015+dpkt2n
+ ute=-1                    ua1=2.9906584e-09+dua1n   lua1=-4.0140313e-17+dlua1n
+ wua1=-5.9088316e-16+dwua1n                          pua1=2.684142e-23+dpua1n
+ ub1=-1.7263702e-018+dub1n lub1=-2.606313e-025+dlub1n
+ wub1=1.092844e-026+dwub1n pub1=1.078112e-031+dpub1n uc1=-4.56395e-12
+ luc1=1.7988875e-018       wuc1=2.947725e-017        puc1=-1.8814788e-024
+ prt=0                     at=227862.85+datn         lat=-0.026308656+dlatn
+ wat=-0.00069497258+dwatn  pat=6.5620701e-010+dpatn  jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn
+ wvth0=0+dwvthn            pvth0=0+dpvthn            lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     leta0=0+dleta0n
+ peta0=0+dpeta0n           lvsat=0+dlvsatn+0.00136571*ss_flag+0.00136571*ff_flag-0.00109257*sf_flag+0.00109257*fs_flag
+ wvsat=0+dwvsatn+0.00402026*ss_flag+0.00402026*ff_flag-0.00321621*sf_flag+0.00321621*fs_flag
+ pvsat=0+dpvsatn-8.41279e-10*ss_flag-8.41279e-10*ff_flag+6.73023e-10*sf_flag-6.73023e-10*fs_flag
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     14: type=n 
+ lmin=1e-007-(dxln+dlmisn) lmax=2.399969e-007-(dxln+dlmisn)
+ wmin=6e-007-(dxwn+dwmisn) wmax=1e-006-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ k2=-0.014768139+dk2n      kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lk2=3.6277153e-009+dlk2n
+ wk2=8.527919e-009+dwk2n   pk2=-1.5945251e-015+dpk2n k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0013372461
+ lcit=1.6834112e-010+dlcitn                          wcit=-3.3679872e-011+dwcitn
+ pcit=3.0407722e-017+dpcitn                          voff=-0.12262774+dvoffn
+ lvoff=-2.6941796e-009+dlvoffn                       wvoff=-6.5595952e-009+dwvoffn
+ pvoff=8.9395462e-016+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.20080854+deta0n    leta0=-1.5388287e-013+dleta0n
+ weta0=-5.2525972e-008+dweta0n                       peta0=2.1086036e-019+dpeta0n
+ etab=-0.027104036         letab=-6.1150773e-014     wetab=3.2596188e-008
+ petab=5.6524245e-020      u0=0.026585273+du0n       lu0=-1.1691365e-009+dlu0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-5.7881041e-009+dwu0n pu0=7.2018811e-016+dpu0n
+ ua=-1.2552238e-009        lua=-6.4938528e-017       wua=-2.3496527e-016
+ pua=3.9836923e-023        ub=2.1312214e-018         lub=-2.5904691e-026
+ wub=-9.2599217e-026       pub=9.9253067e-033        uc=1.1830572e-10
+ luc=2.3835917e-019        wuc=-3.5075238e-017       puc=-1.3756941e-024
+ vsat=101530+dvsatn        a0=0.46907808+da0n        la0=-4.8943247e-008+dla0n
+ kvsat=1                   wa0=-5.1098357e-007+dwa0n pa0=1.7114213e-013+dpa0n
+ ags=8.2030148+dagsn       lags=-4.9541641e-007+dlagsn
+ wags=-4.036035e-006       pags=3.0517651e-013+dpagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.068142305         lketa=-6.6665412e-009
+ wketa=-3.2367418e-008     pketa=6.7732059e-015      dwg=0
+ dwb=0                     pclm=-0.13577445+dpclmn-0.0454384*ss_flag+0.0605846*ff_flag-0.0484676*sf_flag+0.0484676*fs_flag
+ lpclm=1.7919195e-008+9.50844e-09*ss_flag-1.26779e-08*ff_flag+1.01423e-08*sf_flag-1.01423e-08*fs_flag
+ wpclm=9.5415348e-008+2.79901e-08*ss_flag-3.73201e-08*ff_flag+2.98561e-08*sf_flag-2.98561e-08*fs_flag
+ ppclm=7.688486e-015+dppclmn-5.8572e-15*ss_flag+7.8096e-15*ff_flag-6.24768e-15*sf_flag+6.24768e-15*fs_flag
+ pdiblc1=0                 pdiblc2=0.020037921       lpdiblc2=-9.0127218e-010
+ wpdiblc2=-1.0274844e-009  ppdiblc2=-7.1017271e-017  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.27109399+dkt1n     lkt1=-3.7557307e-009+dlkt1n
+ wkt1=-1.4267116e-010+dwkt1n                         pkt1=-1.1316454e-015+dpkt1n
+ kt1l=0                    kt2=-0.036680085+dkt2n    lkt2=-1.0762958e-009+dlkt2n
+ wkt2=7.7213822e-009+dwkt2n                          pkt2=-1.9595654e-015+dpkt2n
+ ute=-1                    ua1=3.7096358e-009+dua1n  lua1=-1.9059356e-016+dlua1n
+ wua1=-7.8216086e-016+dwua1n                         pua1=6.6868207e-023+dpua1n
+ ub1=-3.8934903e-018+dub1n lub1=1.9286024e-025+dlub1n
+ wub1=7.4974764e-025+dwub1n                          pub1=-4.6794101e-032+dpub1n
+ uc1=1.0314234e-11         luc1=-1.3145216e-018      wuc1=-1.58668e-017
+ puc1=7.6072172e-024       prt=0                     at=140905.08+datn
+ lat=-0.0081118748+dlatn   wat=-0.0075342512+dwatn   pat=2.0873945e-009+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=0+dwvthn            pvth0=0+dpvthn
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ lvsat=0+dlvsatn           wvsat=0+dwvsatn           pvsat=0+dpvsatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     15: type=n 
+ lmin=6e-08                lmax=1e-007-(dxln+dlmisn) wmin=6e-007-(dxwn+dwmisn)
+ wmax=1e-006-(dxwn+dwmisn) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn+toxmisn)       toxm=2e-009               dtox=2.4905e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)-0.015628*ss_flag+0.00810627*ff_flag-0.00648501*sf_flag+0.00648501*fs_flag
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=0.072603863+dk2n
+ lk2=-3.202154e-009+dlk2n  wk2=-2.6885486e-008+dwk2n pk2=1.1737408e-015+dpk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.002846634+0.000280135*ss_flag+0.000339691*ff_flag-0.000271753*sf_flag+0.000271753*fs_flag
+ lcit=4.9539502e-010+dlcitn-2.18981e-11*ss_flag-2.65536e-11*ff_flag+2.12428e-11*sf_flag-2.12428e-11*fs_flag
+ wcit=1.8369632e-009+dwcitn-1.72563e-10*ss_flag-3.45126e-10*ff_flag+2.76101e-10*sf_flag-2.76101e-10*fs_flag
+ pcit=-1.1582045e-016+dpcitn+1.34892e-17*ss_flag+2.69784e-17*ff_flag-2.15827e-17*sf_flag+2.15827e-17*fs_flag
+ voff=-0.13551187+dvoffn+0.00254768*ff_flag-0.00203815*sf_flag+0.00203815*fs_flag
+ lvoff=-1.6870275e-009+dlvoffn-1.99152e-10*ff_flag+1.59321e-10*sf_flag-1.59321e-10*fs_flag
+ wvoff=-4.4650916e-010+dwvoffn-2.58844e-09*ff_flag+2.07076e-09*sf_flag-2.07076e-09*fs_flag
+ pvoff=4.1609469e-016+dpvoffn+2.02338e-16*ff_flag-1.6187e-16*sf_flag+1.6187e-16*fs_flag
+ nfactor=0.6+dnfactorn     eta0=0.24672953+deta0n-0.00280135*ff_flag+0.00224108*sf_flag-0.00224108*fs_flag
+ leta0=-3.5897984e-009+dleta0n+2.18981e-10*ff_flag-1.75184e-10*sf_flag+1.75184e-10*fs_flag
+ weta0=-1.0146103e-007+dweta0n+1.72563e-09*ff_flag-1.3805e-09*sf_flag+1.3805e-09*fs_flag
+ peta0=3.8254642e-015+dpeta0n-1.34892e-16*ff_flag+1.07914e-16*sf_flag-1.07914e-16*fs_flag
+ etab=-0.01777963          letab=-7.2894994e-010     wetab=6.105538e-008
+ petab=-2.2245985e-015     u0=0.016820001+du0n+0.000500713*ff_flag-0.00040057*sf_flag+0.00040057*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-4.0578524e-010+dlu0n-3.91406e-11*ff_flag+3.13125e-11*sf_flag-3.13125e-11*fs_flag
+ wu0=1.7146691e-009+dwu0n-1.72563e-10*ff_flag+1.3805e-10*sf_flag-1.3805e-10*fs_flag
+ pu0=1.3369633e-016+dpu0n+1.34892e-17*ff_flag-1.07914e-17*sf_flag+1.07914e-17*fs_flag
+ ua=-1.7856988e-009        lua=-2.3471301e-017       wua=-1.9069709e-016
+ pua=3.637648e-023         ub=1.6750463e-018+2.20578e-20*ss_flag-3.0109e-20*ff_flag+2.40872e-20*sf_flag-2.40872e-20*fs_flag
+ lub=9.754519e-027-1.72425e-27*ss_flag+2.35362e-27*ff_flag-1.88288e-27*sf_flag+1.88288e-27*fs_flag
+ wub=4.8453132e-025-2e-33*ss_flag-8.6282e-27*ff_flag+6.90256e-27*sf_flag-6.90256e-27*fs_flag
+ pub=-3.5188988e-032-1.1e-39*ss_flag+6.74462e-34*ff_flag-5.39566e-34*sf_flag+5.39566e-34*fs_flag
+ uc=2.7329344e-10          luc=-1.1877031e-017       wuc=-1.5010795e-016
+ puc=7.6164132e-024        vsat=101530+dvsatn+2547.68*ff_flag-2038.15*sf_flag+2038.15*fs_flag
+ kvsat=1                   a0=2.1586468+da0n         la0=-1.8101683e-007+dla0n
+ wa0=4.145666e-007+dwa0n   pa0=9.8791877e-014+dpa0n  ags=1.8653352+dagsn
+ wags=-1.3202432e-007      a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.24125007
+ lketa=6.8652929e-009      wketa=2.7484109e-008      pketa=2.094612e-015
+ dwg=0                     dwb=0                     pclm=-0.055739068+dpclmn+0.300307*ss_flag-0.353721*ff_flag+0.282977*sf_flag-0.282977*fs_flag
+ lpclm=1.166283e-008-1.75185e-08*ss_flag+1.97083e-08*ff_flag-1.57666e-08*sf_flag+1.57666e-08*fs_flag
+ wpclm=3.541175e-007-1.8499e-07*ss_flag+2.17892e-07*ff_flag-1.74314e-07*sf_flag+1.74314e-07*fs_flag
+ ppclm=-1.2534262e-014+dppclmn+1.07914e-14*ss_flag-1.21403e-14*ff_flag+9.71223e-15*sf_flag-9.71223e-15*fs_flag
+ pdiblc1=0                 pdiblc2=-0.0045152805     lpdiblc2=1.0180516e-009
+ wpdiblc2=3.772421e-009    ppdiblc2=-4.4622588e-016  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.22643511+dkt1n     lkt1=-7.2467155e-009+dlkt1n
+ wkt1=-6.0520131e-008+dwkt1n                         pkt1=3.5880607e-015+dpkt1n
+ kt1l=0                    kt2=-0.015457962+dkt2n    lkt2=-2.7352291e-009+dlkt2n
+ wkt2=-5.1922967e-008+dwkt2n                         pkt2=2.7028333e-015+dpkt2n
+ ute=-1                    ua1=1.8067429e-009+dua1n  lua1=-4.1844414e-017+dlua1n
+ wua1=-1.2098929e-016+dwua1n                         pua1=1.5184425e-023+dpua1n
+ ub1=-2.3420305e-018+dub1n lub1=7.158263e-026+dlub1n wub1=7.6395449e-025+dwub1n
+ pub1=-4.790465e-032+dpub1n                          uc1=-2.5743983e-10
+ luc1=1.9615814e-017       wuc1=3.1208831e-016       puc1=-1.8029034e-023
+ prt=0                     at=33885.293+datn         lat=0.00025386213+dlatn
+ wat=0.022468542+dwatn     pat=-2.5792393e-010+dpatn jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn+1.22164e-09*ss_flag-6.33665e-10*ff_flag+5.06931e-10*sf_flag-5.06931e-10*fs_flag
+ wvth0=0+dwvthn+9.49096e-09*ss_flag-4.31407e-09*ff_flag+3.45126e-09*sf_flag-3.45126e-09*fs_flag
+ pvth0=0+dpvthn-7.41907e-16*ss_flag+3.3723e-16*ff_flag-2.69784e-16*sf_flag+2.69784e-16*fs_flag
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ lvsat=0+dlvsatn-0.000199152*ff_flag+0.000159321*sf_flag-0.000159321*fs_flag
+ wvsat=0+dwvsatn-0.00258844*ff_flag+0.00207076*sf_flag-0.00207076*fs_flag
+ pvsat=0+dpvsatn+2.02338e-10*ff_flag-1.6187e-10*sf_flag+1.6187e-10*fs_flag
+ lags=0+dlagsn             pags=0+dpagsn             saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.15e-17         wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0017             pku0we=-1.4e-17
+ wku0we=-2.0e-10           lku0we=1.88e-10           k2we=0.00045
+ pk2we=-0.26e-17           wk2we=0.4e-10             lk2we=0.1e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noian                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn                rnoib=0
+ noic=noicn                em=3e+8                   ef=0.9
+ lintnoi=-1e-8             minr=1e-3
 
 
     16: type=n 
+ lmin=9.999997e-006-(dxln+dlmisn)                    lmax=2.00001e-05
+ wmin=3e-007-(dxwn+dwmisn) wmax=6e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31805266+(dvthn+vthmisn)                     k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.011238485+dk2n      wk2=1.2696905e-010+dwk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0027509393          wcit=-4.303756e-010+dwcitn
+ voff=-0.13562629+dvoffn   wvoff=-2.1722831e-009+dwvoffn
+ nfactor=0.6+dnfactorn     eta0=0.083034133+deta0n   weta0=2.0023614e-008+dweta0n
+ etab=0.067993787          wetab=-2.5983981e-008     u0=0.019407666+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               ua=-1.7730755e-009        wua=4.8911758e-017
+ ub=2.0690415e-18          pub=0                     lub=0
+ wub=-8.074416e-26         uc=2.550781e-11           puc=0
+ luc=0                     wuc=-9.493617e-18         vsat=101530+dvsatn
+ a0=3.5780748+da0n         wa0=5.728226e-07+dwa0n    kvsat=1
+ ags=0.7663665+dagsn       wags=5.81295e-08          a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.039134165         wketa=1.6936413e-009      dwg=0
+ dwb=0                     pclm=0.053745+dpclmn      pdiblc1=0
+ pdiblc2=0.0034473372      wpdiblc2=-6.706076e-010   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.2475892+dkt1n      wkt1=5.0474567e-009+dwkt1n
+ kt1l=0                    kt2=-0.034857955+dkt2n    wkt2=-1.2282766e-009+dwkt2n
+ ute=-1                    ua1=2.7994037e-009+dua1n  wua1=1.1681741e-017+dwua1n
+ ub1=-9.9461799e-019+dub1n wub1=-9.2346487e-026+dwub1n
+ uc1=1.5041376e-10         puc1=0                    luc1=0
+ wuc1=2.1995349e-17        prt=0                     at=200000+datn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=-1.4923626e-09+dwvthn
+ pvth0=0+dpvthn            lk2=0+dlk2n               pk2=0+dpk2n
+ lcit=0+dlcitn             pcit=0+dpcitn             lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     leta0=0+dleta0n
+ peta0=0+dpeta0n           lu0=0+dlu0n               wu0=-5.1908266e-10+dwu0n
+ pu0=0+dpu0n               lvsat=0+dlvsatn           wvsat=0+dwvsatn
+ pvsat=0+dpvsatn           lags=0+dlagsn             pags=0+dpagsn
+ ppclm=0+dppclmn           lkt1=0+dlkt1n             pat=0+dpatn
+ lat=0+dlatn               lvoff=0+dlvoffn           pvoff=0+dpvoffn
+ la0=0+dla0n               pa0=0+dpa0n               pkt1=0+dpkt1n
+ lkt2=0+dlkt2n             pkt2=0+dpkt2n             lua1=0+dlua1n
+ pua1=0+dpua1n             lub1=0+dlub1n             pub1=0+dpub1n
+ wat=0+dwatn               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.0036
+ pkvth0we=0.15e-17         wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0017             pku0we=-1.4e-17           wku0we=-2.0e-10
+ lku0we=1.88e-10           k2we=0.00045              pk2we=-0.26e-17
+ wk2we=0.4e-10             lk2we=0.1e-12             fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn                rnoib=0                   noic=noicn
+ em=3e+8                   ef=0.9                    lintnoi=-1e-8
+ minr=1e-3
 
 
     17: type=n 
+ lmin=9.999973e-007-(dxln+dlmisn)                    lmax=9.999997e-006-(dxln+dlmisn)
+ wmin=3e-007-(dxwn+dwmisn) wmax=6e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31815996+(dvthn+vthmisn)                     k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.012174692+dk2n      lk2=9.309841e-009+dlk2n
+ wk2=1.7364922e-010+dwk2n  pk2=-4.6419794e-016+dpk2n k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0028912099
+ lcit=-1.3948823e-009+dlcitn                         wcit=-4.5510027e-010+dwcitn
+ pcit=2.4586756e-016+dpcitn                          voff=-0.13570633+dvoffn
+ lvoff=7.9601266e-010+dlvoffn                        wvoff=-2.2686973e-009+dwvoffn
+ pvoff=9.5876416e-016+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.083034133+deta0n   weta0=2.0023614e-008+dweta0n
+ etab=0.067993787          wetab=-2.5983981e-008     u0=0.019814652+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-4.0471529e-09+dlu0n  wu0=-6.8084268e-10+dwu0n
+ pu0=1.6085772e-15+dpu0n   ua=-1.7600191e-009        lua=-1.2983542e-016
+ wua=3.9558799e-017        pua=9.3007884e-023        ub=2.0568179e-18
+ lub=1.21554e-25           wub=-8.68488e-26          pub=6.070596e-32
+ uc=1.8973717e-11          luc=6.4976423e-17         wuc=-9.028912e-18
+ puc=-4.62113e-24          vsat=101530+dvsatn        a0=3.7326393+da0n
+ la0=-1.5370237e-06+dla0n  kvsat=1                   wa0=6.205243e-07+dwa0n
+ pa0=-4.743559e-13+dpa0n   ags=0.6902388+dagsn       lags=7.570309e-07+dlagsn
+ wags=5.48051e-08          pags=3.305904e-14+dpagsn  a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.035620933         lketa=-3.4936356e-008     wketa=2.4967973e-009
+ pketa=-7.9867599e-015     dwg=0                     dwb=0
+ pclm=0.053745+dpclmn      pdiblc1=0                 pdiblc2=0.0031858249
+ lpdiblc2=2.6005362e-009   wpdiblc2=-7.3518985e-010  ppdiblc2=6.4222008e-016
+ pdiblcb=-0.03716          drout=0.5                 pvag=0.7
+ delta=0.01                pscbe1=4.24e+008          pscbe2=1e-020
+ fprout=0                  pdits=0.44984             pditsd=1
+ pditsl=264000             rsh=16                    rsw=45+drdswn
+ rdw=45+drdswn             prwg=0                    prwb=0
+ wr=1                      alpha0=3.3929e-010        alpha1=0.0034
+ beta0=5.808               agidl=1.5797e-008         bgidl=1.4527e+009
+ cgidl=1.4892              egidl=0.81976             aigbacc=0.013432
+ bigbacc=0.0065981         cigbacc=0.39315           nigbacc=4.8
+ aigbinv=0.024468          bigbinv=0.012141          cigbinv=0.0855
+ eigbinv=1.1               nigbinv=3.8771            aigc=0.010744
+ bigc=0.000824385          cigc=-0.087762            aigsd=0.0093701
+ bigsd=0.0012397           cigsd=0.081703            nigc=1.5
+ poxedge=1                 pigcd=3.11                ntox=ntoxn
+ xrcrg1=12                 xrcrg2=1                  cgso=cgon
+ cgdo=cgon                 cgbo=0                    cgdl=cgln
+ cgsl=cgln                 clc=1e-007                cle=0.6
+ cf=cfn                    ckappas=0.6               ckappad=0.6
+ acde=0.6                  moin=7.6133               noff=2.4067
+ voffcv=-0.12779           kt1=-0.24689908+dkt1n     lkt1=-6.8626731e-009+dlkt1n
+ wkt1=5.3052345e-009+dwkt1n                          pkt1=-2.5633996e-015+dpkt1n
+ kt1l=0                    kt2=-0.033254126+dkt2n    lkt2=-1.594883e-008+dlkt2n
+ wkt2=-2.1599546e-009+dwkt2n                         pkt2=9.2648115e-015+dpkt2n
+ ute=-1                    ua1=2.8814175e-009+dua1n  lua1=-8.1556329e-016+dlua1n
+ wua1=1.178319e-017+dwua1n pua1=-1.0088317e-024+dpua1n
+ ub1=-9.1138915e-019+dub1n lub1=-8.2764591e-025+dlub1n
+ wub1=-1.0129996e-025+dwub1n                         pub1=8.9035289e-032+dpub1n
+ uc1=1.5973966e-10         luc1=-9.273865e-17        wuc1=2.5567268e-17
+ puc1=-3.5519943e-23       prt=0                     at=200000+datn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=-1.066929e-09+dlvthn                          wvth0=-1.6489314e-09+dwvthn
+ pvth0=1.556954e-15+dpvthn lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn
+ pnfactor=0+dpnfactorn     leta0=0+dleta0n           peta0=0+dpeta0n
+ lvsat=0+dlvsatn           wvsat=0+dwvsatn           pvsat=0+dpvsatn
+ ppclm=0+dppclmn           pat=0+dpatn               lat=0+dlatn
+ wat=0+dwatn               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.0036
+ pkvth0we=0.15e-17         wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0017             pku0we=-1.4e-17           wku0we=-2.0e-10
+ lku0we=1.88e-10           k2we=0.00045              pk2we=-0.26e-17
+ wk2we=0.4e-10             lk2we=0.1e-12             fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn                rnoib=0                   noic=noicn
+ em=3e+8                   ef=0.9                    lintnoi=-1e-8
+ minr=1e-3
 
 
     18: type=n 
+ lmin=2.399969e-007-(dxln+dlmisn)                    lmax=9.999973e-007-(dxln+dlmisn)
+ wmin=3e-007-(dxwn+dwmisn) wmax=6e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=3.259685e-09+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.0041278116+dk2n     lk2=1.7118158e-009+dlk2n
+ wk2=-4.0665307e-010+dwk2n pk2=8.3735094e-017+dpk2n  k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0011314918
+ lcit=2.6667871e-010+dlcitn                          wcit=-2.355961e-010+dwcitn
+ pcit=3.8607338e-017+dpcitn                          voff=-0.13322297+dvoffn
+ lvoff=-1.5488315e-009+dlvoffn                       wvoff=-1.8571253e-009+dwvoffn
+ pvoff=5.7014968e-016+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.083034133+deta0n   weta0=2.0023614e-008+dweta0n
+ etab=0.067993787          wetab=-2.5983981e-008     u0=0.015370683+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=1.4893161e-010+dlu0n  wu0=1.1198775e-009+dwu0n
+ pu0=-9.1698812e-017+dpu0n ua=-1.9103681e-009        lua=1.2127104e-017
+ wua=1.3975401e-016        pua=-1.5984407e-024       ub=2.2328243e-018
+ lub=-4.4634668e-026       wub=-1.3996736e-026       pub=-8.0824143e-033
+ uc=8.322625e-11           luc=4.3078963e-018        wuc=-8.7704434e-018
+ puc=-4.8651811e-024       vsat=101530+dvsatn        a0=2.4114429+da0n
+ la0=-2.8952362e-007+dla0n kvsat=1                   wa0=2.0344405e-007+dwa0n
+ pa0=-8.0540385e-014+dpa0n ags=2.2694312+dagsn       lags=-7.3407408e-007+dlagsn
+ wags=-3.9140291e-007      pags=4.5437754e-013+dpagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.064825777         lketa=-7.3605579e-009
+ wketa=-7.6592386e-009     pketa=1.6027723e-015      dwg=0
+ dwb=0                     pclm=0.0045786853+dpclmn  lpclm=4.6423818e-008
+ wpclm=1.0879297e-008      ppclm=-1.027245e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.0044034073      lpdiblc2=1.4508705e-009
+ wpdiblc2=-4.5222352e-010  ppdiblc2=3.7503762e-016   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.23948205+dkt1n     lkt1=-1.3865984e-008+dlkt1n
+ wkt1=1.9788895e-009+dwkt1n                          pkt1=5.7740196e-016+dpkt1n
+ kt1l=0                    kt2=-0.055996923+dkt2n    lkt2=5.5253747e-009+dlkt2n
+ wkt2=1.2443856e-008+dwkt2n                          pkt2=-4.5243984e-015+dpkt2n
+ ute=-1                    ua1=2.0046216e-009+dua1n  lua1=1.2324921e-017+dlua1n
+ wua1=1.651549e-017+dwua1n pua1=-5.4771637e-024+dpua1n
+ ub1=-1.6964628e-018+dub1n lub1=-8.6363706e-026+dlub1n
+ wub1=-7.4945718e-027+dwub1n                         pub1=4.6236659e-034+dpub1n
+ uc1=7.385307e-11          luc1=-1.1642819e-017      wuc1=-1.8827635e-017
+ puc1=6.3986122e-024       prt=0                     at=226670.14+datn
+ lat=-0.025182477+dlatn    wat=3.97361e-005+dwatn    pat=-3.751962e-011+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=0+dwvthn            pvth0=0+dpvthn
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lvsat=0+dlvsatn
+ wvsat=0+dwvsatn           pvsat=0+dpvsatn           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.15e-17         wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0017             pku0we=-1.4e-17
+ wku0we=-2.0e-10           lku0we=1.88e-10           k2we=0.00045
+ pk2we=-0.26e-17           wk2we=0.4e-10             lk2we=0.1e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noian                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn                rnoib=0
+ noic=noicn                em=3e+8                   ef=0.9
+ lintnoi=-1e-8             minr=1e-3
 
 
     19: type=n 
+ lmin=1e-007-(dxln+dlmisn) lmax=2.399969e-007-(dxln+dlmisn)
+ wmin=3e-007-(dxwn+dwmisn) wmax=6e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ k2=0.00062384702+dk2n     kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lk2=7.1748373e-010+dlk2n
+ wk2=-9.5354455e-010+dwk2n pk2=1.981776e-016+dpk2n   k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0013037102
+ lcit=2.3064029e-010+dlcitn                          wcit=-1.3021758e-011+dwcitn
+ pcit=-7.9685686e-018+dpcitn                         voff=-0.13154597+dvoffn
+ lvoff=-1.8997604e-009+dlvoffn                       wvoff=-1.0659694e-009+dwvoffn
+ pvoff=4.0459238e-016+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.08303473+deta0n    leta0=-1.2479503e-013+dleta0n
+ weta0=2.0022692e-008+dweta0n                        peta0=1.9294226e-019+dpeta0n
+ etab=0.067993659          letab=2.6705641e-014      wetab=-2.5983992e-008
+ petab=2.4046937e-021      u0=0.015441075+du0n       lu0=1.3420134e-010+dlu0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=1.0767217e-009+dwu0n  pu0=-8.2668024e-017+dpu0n
+ ua=-1.860197e-009         lua=1.6282925e-018        wua=1.3769819e-016
+ pua=-1.1682382e-024       ub=2.0672961e-018         lub=-9.9962492e-027
+ wub=-5.3221245e-026       pub=1.2570637e-034        uc=1.6001997e-10
+ luc=-1.1761958e-017       wuc=-6.0771218e-017       puc=6.016501e-024
+ vsat=101530+dvsatn        a0=-0.87862451+da0n       la0=3.9895589e-007+dla0n
+ kvsat=1                   wa0=3.1920123e-007+dwa0n  pa0=-1.0476373e-013+dpa0n
+ ags=-2.8016216+dagsn      lags=3.2709442e-007+dlagsn
+ wags=2.7428211e-006       pags=-2.0149017e-013+dpagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.12838974          lketa=5.9408376e-009
+ wketa=4.7450036e-009      pketa=-9.9293945e-016     dwg=0
+ dwb=0                     pclm=-0.024971357+dpclmn  lpclm=5.260746e-008
+ wpclm=2.7160645e-008      ppclm=-1.3679485e-014+dppclmn
+ pdiblc1=0                 pdiblc2=0.016950098       lpdiblc2=-1.17465e-009
+ wpdiblc2=8.7461451e-010   ppdiblc2=9.7383492e-017   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.27499492+dkt1n     lkt1=-6.4345598e-009+dlkt1n
+ wkt1=2.2603032e-009+dwkt1n                          pkt1=5.1851333e-016+dpkt1n
+ kt1l=0                    kt2=0.011325414+dkt2n     lkt2=-8.5624977e-009+dlkt2n
+ wkt2=-2.1850005e-008+dwkt2n                         pkt2=2.6519349e-015+dpkt2n
+ ute=-1                    ua1=2.4597816e-009+dua1n  lua1=-8.2921852e-017+dlua1n
+ wua1=-1.2250643e-017+dwua1n                         pua1=5.4243736e-025+dpua1n
+ ub1=-2.7303742e-018+dub1n lub1=1.299926e-025+dlub1n wub1=3.326811e-026+dwub1n
+ pub1=-8.0676323e-033+dpub1n                         uc1=-9.884397e-11
+ luc1=2.4495763e-017       wuc1=5.1374651e-017       puc1=-8.2919181e-024
+ prt=0                     at=120927.59+datn         lat=-0.0030547912+dlatn
+ wat=0.0047718848+dwatn    pat=-1.0277691e-009+dpatn jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn
+ wvth0=0+dwvthn            pvth0=0+dpvthn            lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     lvsat=0+dlvsatn
+ wvsat=0+dwvsatn           pvsat=0+dpvsatn           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.15e-17         wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0017             pku0we=-1.4e-17
+ wku0we=-2.0e-10           lku0we=1.88e-10           k2we=0.00045
+ pk2we=-0.26e-17           wk2we=0.4e-10             lk2we=0.1e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noian                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibn                rnoib=0
+ noic=noicn                em=3e+8                   ef=0.9
+ lintnoi=-1e-8             minr=1e-3
 
 
     20: type=n 
+ lmin=6e-08                lmax=1e-007-(dxln+dlmisn) wmin=3e-007-(dxwn+dwmisn)
+ wmax=6e-007-(dxwn+dwmisn) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn+toxmisn)       toxm=2e-009               dtox=2.4905e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)+0.00163816*ss_flag+0.00052204*ff_flag-0.000417624*sf_flag+0.000417624*fs_flag
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=0.024780002+dk2n
+ lk2=-1.1708029e-009+dlk2n wk2=2.5740124e-009+dwk2n  pk2=-7.7571521e-017+dpk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00062716584+0.000127936*ff_flag-0.000102348*sf_flag+0.000102348*fs_flag
+ lcit=2.8352576e-010+dlcitn-1.00007e-11*ff_flag+8.00054e-12*sf_flag-8.00054e-12*fs_flag
+ wcit=-3.0289751e-010+dwcitn-2.14685e-10*ff_flag+1.71748e-10*sf_flag-1.71748e-10*fs_flag
+ pcit=1.4691019e-017+dpcitn+1.67818e-17*ff_flag-1.34255e-17*sf_flag+1.34255e-17*fs_flag
+ voff=-0.14333378+dvoffn-0.00513948*ff_flag+0.00411159*sf_flag-0.00411159*fs_flag
+ lvoff=-9.7830692e-010+dlvoffn+4.01752e-10*ff_flag-3.21401e-10*sf_flag+3.21401e-10*fs_flag
+ wvoff=4.3717893e-009+dwvoffn+2.14684e-09*ff_flag-1.71748e-09*sf_flag+1.71748e-09*fs_flag
+ pvoff=-2.0477215e-017+dpvoffn-1.67818e-16*ff_flag+1.34255e-16*sf_flag-1.34255e-16*fs_flag
+ nfactor=0.6+dnfactorn     eta0=0.01439234+deta0n    leta0=5.3656508e-009+dleta0n
+ weta0=4.1658683e-008+dweta0n                        peta0=-1.6910925e-015+dpeta0n
+ etab=0.17507993           letab=-8.3709067e-009     wetab=-5.7746106e-008
+ petab=2.4828469e-015      u0=0.02211626+du0n+0.000232343*ss_flag-0.000244107*ff_flag+0.000195286*sf_flag-0.000195286*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=-3.8759789e-010+dlu0n-1.81622e-11*ss_flag+1.90818e-11*ff_flag-1.52654e-11*sf_flag+1.52654e-11*fs_flag
+ wu0=-1.5478267e-009+dwu0n-1.43123e-10*ss_flag+2.86246e-10*ff_flag-2.28997e-10*sf_flag+2.28997e-10*fs_flag
+ pu0=1.2249292e-016+dpu0n+1.11879e-17*ss_flag-2.23758e-17*ff_flag+1.79006e-17*sf_flag-1.79006e-17*fs_flag
+ ua=-2.2802053e-009        lua=3.4460341e-017        wua=1.139189e-016
+ pua=6.9058809e-025        ub=2.844392e-018+2.20578e-20*ss_flag-5.57328e-20*ff_flag+4.45863e-20*sf_flag-4.45863e-20*fs_flag
+ lub=-7.0741836e-026-1.72425e-27*ss_flag+4.35662e-27*ff_flag-3.4853e-27*sf_flag+3.4853e-27*fs_flag
+ wub=-2.3578566e-025+1.1e-32*ss_flag+7.15613e-27*ff_flag-5.72493e-27*sf_flag+5.72493e-27*fs_flag
+ pub=1.4396767e-032+3e-40*ss_flag-5.59395e-34*ff_flag+4.47512e-34*sf_flag-4.47512e-34*fs_flag
+ uc=2.0272642e-11          luc=-8.3790894e-019       wuc=5.7528607e-018
+ puc=8.1631381e-025        vsat=101530+dvsatn-1654.34*ff_flag+1323.47*sf_flag-1323.47*fs_flag
+ kvsat=1                   a0=4.1921544+da0n         la0=2.5731011e-009+dla0n
+ wa0=-8.3807408e-007+dwa0n pa0=-1.4299521e-014+dpa0n ags=1.3827748+dagsn
+ lags=1.5894076e-013+dlagsn                          wags=1.6523289e-007
+ pags=-9.7907508e-020+dpagsn                         a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.17098041          lketa=9.2701501e-009      wketa=-1.5802002e-008
+ pketa=6.1321997e-016      dwg=0                     dwb=0
+ pclm=0.90728777+dpclmn    lpclm=-2.0267237e-008     wpclm=-2.3910703e-007
+ ppclm=7.1346592e-015+dppclmn                        pdiblc1=0
+ pdiblc2=-0.011295786      lpdiblc2=1.0333307e-009   wpdiblc2=7.9492124e-009
+ ppdiblc2=-4.5563783e-016  pdiblcb=-0.03716          drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.44984
+ pditsd=1                  pditsl=264000             rsh=16
+ rsw=45+drdswn             rdw=45+drdswn             prwg=0
+ prwb=0                    wr=1                      alpha0=3.3929e-010
+ alpha1=0.0034             beta0=5.808               agidl=1.5797e-008
+ bgidl=1.4527e+009         cgidl=1.4892              egidl=0.81976
+ aigbacc=0.013432          bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010744             bigc=0.000824385          cigc=-0.087762
+ aigsd=0.0093701           bigsd=0.0012397           cigsd=0.081703
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn                xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=7.6133
+ noff=2.4067               voffcv=-0.12779           kt1=-0.34850997+dkt1n
+ lkt1=-6.8788826e-010+dlkt1n                         wkt1=1.4677986e-008+dwkt1n
+ pkt1=-4.5217693e-016+dpkt1n                         kt1l=0
+ kt2=-0.14583739+dkt2n     lkt2=3.7229188e-009+dlkt2n
+ wkt2=2.8390761e-008+dwkt2n                          pkt2=-1.2753858e-015+dpkt2n
+ ute=-1                    ua1=1.635858e-009+dua1n   lua1=-1.8515743e-017+dlua1n
+ wua1=-1.5724189e-017+dwua1n                         pua1=8.1396442e-025+dpua1n
+ ub1=-6.1241244e-019+dub1n lub1=-3.5568472e-026+dlub1n
+ wub1=-3.0149025e-025+dwub1n                         pub1=1.8100428e-032+dpub1n
+ uc1=4.9608964e-10         luc1=-2.2010197e-017      wuc1=-1.5208584e-016
+ puc1=7.6125885e-024       prt=0                     at=80978.696+datn
+ lat=6.8013725e-005+dlatn  wat=-0.0065409941+dwatn   pat=-1.4344131e-010+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn-1.28055e-10*ss_flag-4.08077e-11*ff_flag+3.2646e-11*sf_flag-3.2646e-11*fs_flag
+ wvth0=0+dwvthn-1.14499e-09*ss_flag+3.57807e-10*ff_flag-2.86247e-10*sf_flag+2.86247e-10*fs_flag
+ pvth0=0+dpvthn+8.95032e-17*ss_flag-2.79697e-17*ff_flag+2.23758e-17*sf_flag-2.23758e-17*fs_flag
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ lvsat=0+dlvsatn+0.00012932*ff_flag-0.000103455*sf_flag+0.000103455*fs_flag
+ wvsat=0+dwvsatn-3.3e-09*ff_flag-3.4e-10*sf_flag+3.4e-10*fs_flag
+ pvsat=0+dpvsatn+3e-17*ff_flag+1.6e-17*sf_flag-1.6e-17*fs_flag
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     21: type=n 
+ lmin=9.999997e-006-(dxln+dlmisn)                    lmax=2.00001e-05
+ wmin=1.2e-07              wmax=3e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.30600111+(dvthn+vthmisn)                     k1=0.24753
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k2=-0.01236467+dk2n       wk2=4.8284345e-010+dwk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0014449266          wcit=-1.7675606e-011+dwcitn
+ voff=-0.14538275+dvoffn   wvoff=9.1076052e-010+dwvoffn
+ nfactor=0.6+dnfactorn     eta0=0.17749867+deta0n    weta0=-9.8271787e-009+dweta0n
+ etab=-0.023722418         wetab=2.99834e-009        u0=0.010209444+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               ua=-1.5494952e-009        wua=-2.1739624e-017
+ ub=1.0067323e-18          pub=0                     lub=0
+ wub=2.5494555e-25         uc=1.0484911e-11          puc=0
+ luc=0                     wuc=-4.7463808e-18        vsat=101530+dvsatn
+ a0=6.1807869+da0n         wa0=-2.4963438e-07+dwa0n  kvsat=1
+ ags=1.189492+dagsn        wags=-7.557812e-08        a1=0
+ a2=1                      b0=0                      b1=0
+ keta=-0.023232075         wketa=-3.3314193e-009     dwg=0
+ dwb=0                     pclm=0.053745+dpclmn      pdiblc1=0
+ pdiblc2=0.0021622515      wpdiblc2=-2.6452053e-010  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.23460183+dkt1n     wkt1=9.4344807e-010+dwkt1n
+ kt1l=0                    kt2=-0.036381806+dkt2n    wkt2=-7.4673971e-010+dwkt2n
+ ute=-1                    ua1=2.767759e-009+dua1n   wua1=2.1681485e-017+dwua1n
+ ub1=-1.7729224e-18+dub1n  wub1=1.5359769e-25+dwub1n uc1=1.7544114e-10
+ puc1=0                    luc1=0                    wuc1=1.4086697e-17
+ prt=0                     at=200000+datn            jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn
+ wvth0=2.3159289e-09+dwvthn                          pvth0=0+dpvthn
+ lk2=0+dlk2n               pk2=0+dpk2n               lcit=0+dlcitn
+ pcit=0+dpcitn             lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn
+ pnfactor=0+dpnfactorn     leta0=0+dleta0n           peta0=0+dpeta0n
+ lu0=0+dlu0n               wu0=2.3875556e-09+dwu0n   pu0=0+dpu0n
+ lvsat=0+dlvsatn           wvsat=0+dwvsatn           pvsat=0+dpvsatn
+ lags=0+dlagsn             pags=0+dpagsn             ppclm=0+dppclmn
+ lkt1=0+dlkt1n             pat=0+dpatn               lat=0+dlatn
+ lvoff=0+dlvoffn           pvoff=0+dpvoffn           la0=0+dla0n
+ pa0=0+dpa0n               pkt1=0+dpkt1n             lkt2=0+dlkt2n
+ pkt2=0+dpkt2n             lua1=0+dlua1n             pua1=0+dpua1n
+ lub1=0+dlub1n             pub1=0+dpub1n             wat=0+dwatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     22: type=n 
+ lmin=9.999973e-007-(dxln+dlmisn)                    lmax=9.999997e-006-(dxln+dlmisn)
+ wmin=1.2e-07              wmax=3e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.058866e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.058866e-08+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.30484403+(dvthn+vthmisn)-7.92679e-05*ff_flag+6.34143e-05*sf_flag-6.34143e-05*fs_flag
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=-0.012533906+dk2n
+ lk2=1.6829196e-009+dlk2n  wk2=2.8716102e-010+dwk2n  pk2=1.9459092e-015+dpk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0014892202          lcit=-4.4046543e-010+dlcitn
+ wcit=-1.207153e-011+dwcitn                          pcit=-5.5728171e-017+dpcitn
+ voff=-0.14588305+dvoffn-0.000237804*ff_flag+0.000190243*sf_flag-0.000190243*fs_flag
+ lvoff=4.9750969e-009+dlvoffn+2.36477e-09*ff_flag-1.89182e-09*sf_flag+1.89182e-09*fs_flag
+ wvoff=9.4714613e-010+dwvoffn+7.51459e-11*ff_flag-6.01167e-11*sf_flag+6.01167e-11*fs_flag
+ pvoff=-3.6182647e-016+dpvoffn-7.47268e-16*ff_flag+5.97814e-16*sf_flag-5.97814e-16*fs_flag
+ nfactor=0.6+dnfactorn     eta0=0.17749867+deta0n    weta0=-9.8271787e-009+dweta0n
+ etab=-0.023722418         wetab=2.99834e-009        u0=0.0093118523+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               ua=-1.5704049e-009        lua=2.0793103e-016
+ wua=-2.0359294e-017       pua=-1.3726314e-023       ub=9.135065e-19
+ lub=9.2705777e-25         wub=2.744376e-25          pub=-1.9383322e-31
+ uc=7.49086e-12            luc=2.9773499e-17         wuc=-5.4003278e-18
+ puc=6.5029926e-24         vsat=101530+dvsatn+237.804*ff_flag-190.243*sf_flag+190.243*fs_flag
+ kvsat=1                   a0=6.5745429+da0n         la0=-3.9155948e-06+dla0n
+ wa0=-2.7751721e-07+dwa0n  pa0=2.7727252e-13+dpa0n   ags=1.1567926+dagsn
+ lags=3.251689e-07+dlagsn  wags=-9.262594e-08        pags=1.6952744e-13+dpagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.016745927         lketa=-6.4499681e-008
+ wketa=-3.4677045e-009     pketa=1.3552507e-015      dwg=0
+ dwb=0                     pclm=0.053745+dpclmn      pdiblc1=0
+ pdiblc2=0.0018568353      lpdiblc2=3.0371266e-009   wpdiblc2=-3.1522914e-010
+ ppdiblc2=5.0425752e-016   pdiblcb=-0.03716          drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.44984
+ pditsd=1                  pditsl=264000             rsh=16
+ rsw=45+drdswn             rdw=45+drdswn             prwg=0
+ prwb=0                    wr=1                      alpha0=3.3929e-010
+ alpha1=0.0034             beta0=5.808               agidl=1.5797e-008
+ bgidl=1.4527e+009         cgidl=1.4892              egidl=0.81976
+ aigbacc=0.013432          bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010744             bigc=0.000824385          cigc=-0.087762
+ aigsd=0.0093701           bigsd=0.0012397           cigsd=0.081703
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn                xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=7.6133
+ noff=2.4067               voffcv=-0.12779           kt1=-0.23294264+dkt1n
+ lkt1=-1.6499303e-008+dlkt1n                         wkt1=8.9500029e-010+dwkt1n
+ pkt1=4.8177538e-016+dpkt1n                          kt1l=0
+ kt2=-0.037644776+dkt2n    lkt2=1.2559257e-008+dlkt2n
+ wkt2=-7.7250906e-010+dwkt2n                         pkt2=2.5625617e-016+dpkt2n
+ ute=-1                    ua1=2.8330988e-009+dua1n  lua1=-6.4975371e-016+dlua1n
+ wua1=2.7051907e-017+dwua1n                          pua1=-5.3404659e-023+dpua1n
+ ub1=-1.7638877e-18+dub1n  lub1=-8.984237e-26+dlub1n wub1=1.6808959e-25+dwub1n
+ pub1=-1.4411063e-31+dpub1n                          uc1=1.9454141e-10
+ luc1=-1.8993726e-16       wuc1=1.456991e-17         puc1=-4.80518e-24
+ prt=0                     at=200000+datn            jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=1.1506233e-08+dlvthn+7.88257e-10*ff_flag-6.30606e-10*sf_flag+6.30606e-10*fs_flag
+ wvth0=2.5589007e-09+dwvthn+2.50486e-11*ff_flag-2.00389e-11*sf_flag+2.00389e-11*fs_flag
+ pvth0=-2.4161652e-15+dpvthn-2.49089e-16*ff_flag+1.99271e-16*sf_flag-1.99271e-16*fs_flag
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lu0=8.9258507e-09+dlu0n
+ wu0=2.638042e-09+dwu0n    pu0=-2.4908919e-15+dpu0n  lvsat=0+dlvsatn-0.00236477*ff_flag+0.00189182*sf_flag-0.00189182*fs_flag
+ wvsat=0+dwvsatn-7.51459e-05*ff_flag+6.01167e-05*sf_flag-6.01167e-05*fs_flag
+ pvsat=0+dpvsatn+7.47268e-10*ff_flag-5.97814e-10*sf_flag+5.97814e-10*fs_flag
+ ppclm=0+dppclmn           pat=0+dpatn               lat=0+dlatn
+ wat=0+dwatn               saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   llodku0=1
+ wlodku0=1                 lodeta0=1                 steta0=0e-10
+ tku0=0                    wec=-3010                 web=-210
+ scref=1e-6                wpemod=1                  kvth0we=0.0036
+ pkvth0we=0.15e-17         wkvth0we=-9.5e-11         lkvth0we=-5.6e-11
+ ku0we=-0.0017             pku0we=-1.4e-17           wku0we=-2.0e-10
+ lku0we=1.88e-10           k2we=0.00045              pk2we=-0.26e-17
+ wk2we=0.4e-10             lk2we=0.1e-12             fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noian                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibn                rnoib=0                   noic=noicn
+ em=3e+8                   ef=0.9                    lintnoi=-1e-8
+ minr=1e-3
 
 
     23: type=n 
+ lmin=2.399969e-007-(dxln+dlmisn)                    lmax=9.999973e-007-(dxln+dlmisn)
+ wmin=1.2e-07              wmax=3e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=3.259685e-09         ll=0.00287292             wl=0
+ lln=-0.869                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.00287292
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=3.259685e-09+ddlcn    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)+0.00097068*ff_flag-0.000776544*sf_flag+0.000776544*fs_flag
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=-0.013959129+dk2n
+ lk2=3.0286432e-009+dlk2n  wk2=2.7000432e-009+dwk2n  pk2=-3.3238237e-016+dpk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00052335027         lcit=4.7152832e-010+dlcitn
+ wcit=-4.3423366e-011+dwcitn                         pcit=-2.612514e-017+dpcitn
+ voff=-0.14323412+dvoffn+0.00291204*ff_flag-0.00232963*sf_flag+0.00232963*fs_flag
+ lvoff=2.4739216e-009+dlvoffn-6.09373e-10*ff_flag+4.87498e-10*sf_flag-4.87498e-10*fs_flag
+ wvoff=1.3063991e-009+dwvoffn-9.20204e-10*ff_flag+7.36163e-10*sf_flag-7.36163e-10*fs_flag
+ pvoff=-7.0104029e-016+dpvoffn+1.92562e-16*ff_flag-1.5405e-16*sf_flag+1.5405e-16*fs_flag
+ nfactor=0.6+dnfactorn     eta0=0.17749867+deta0n    weta0=-9.8271787e-009+dweta0n
+ etab=-0.023722418         wetab=2.99834e-009        u0=0.018196048+du0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=5.3721555e-010+dlu0n  wu0=2.2706206e-010+dwu0n
+ pu0=-2.1439654e-016+dpu0n ua=-1.3860572e-009        lua=3.3866276e-017
+ wua=-2.5928224e-017       pua=-8.4680192e-024       ub=1.9272298e-018
+ lub=-3.0120039e-026       wub=8.2571102e-026        pub=-1.2669037e-032
+ uc=4.5636795e-11          luc=-6.2446548e-018       wuc=3.1078245e-018
+ puc=-1.5305749e-024       vsat=101530+dvsatn-2912.04*ff_flag+2329.63*sf_flag-2329.63*fs_flag
+ kvsat=1                   a0=3.5929554+da0n         la0=-1.1003204e-006+dla0n
+ wa0=-1.699139e-007+dwa0n  pa0=1.7567139e-013+dpa0n  ags=0.84196165+dagsn
+ lags=6.2243865e-007+dlagsn                          wags=5.9677463e-008
+ pags=2.571952e-014+dpagsn a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.080801023
+ lketa=-4.0175779e-009     wketa=-2.6110608e-009     pketa=5.4639059e-016
+ dwg=0                     dwb=0                     pclm=0.038304459+dpclmn
+ lpclm=1.4579268e-008      wpclm=2.2195268e-010      ppclm=-2.0957216e-016+dppclmn
+ pdiblc1=0                 pdiblc2=0.0024963396      lpdiblc2=2.4332939e-009
+ wpdiblc2=1.5040989e-010   ppdiblc2=6.4591836e-017   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.24117431+dkt1n     lkt1=-8.7268031e-009+dlkt1n
+ wkt1=2.5136426e-009+dwkt1n                          pkt1=-1.0465791e-015+dpkt1n
+ kt1l=0                    kt2=-0.0168844+dkt2n      lkt2=-7.0431058e-009+dlkt2n
+ wkt2=8.4298432e-011+dwkt2n                          pkt2=-5.5275861e-016+dpkt2n
+ ute=-1                    ua1=2.0630662e-009+dua1n  lua1=7.7326451e-017+dlua1n
+ wua1=-1.9529987e-018+dwua1n                         pua1=-2.6017647e-023+dpua1n
+ ub1=-1.6566655e-018+dub1n lub1=-1.9108366e-025+dlub1n
+ wub1=-2.0070491e-026+dwub1n                         pub1=3.3553871e-032+dpub1n
+ uc1=-6.53542e-12          luc1=-7.649725e-020       wuc1=6.5751271e-018
+ puc1=2.7436546e-024       prt=0                     at=229866.34+datn
+ lat=-0.028200399+dlatn    wat=-0.00097026518+dwatn  pat=9.1614379e-010+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn-2.03124e-10*ff_flag+1.62499e-10*sf_flag-1.62499e-10*fs_flag
+ wvth0=0+dwvthn-3.06735e-10*ff_flag+2.45388e-10*sf_flag-2.45388e-10*fs_flag
+ pvth0=0+dpvthn+6.41873e-17*ff_flag-5.13498e-17*sf_flag+5.13498e-17*fs_flag
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ leta0=0+dleta0n           peta0=0+dpeta0n           lvsat=0+dlvsatn+0.000609373*ff_flag-0.000487498*sf_flag+0.000487498*fs_flag
+ wvsat=0+dwvsatn+0.000920204*ff_flag-0.000736163*sf_flag+0.000736163*fs_flag
+ pvsat=0+dpvsatn-1.92562e-10*ff_flag+1.5405e-10*sf_flag-1.5405e-10*fs_flag
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     24: type=n 
+ lmin=1e-007-(dxln+dlmisn) lmax=2.399969e-007-(dxln+dlmisn)
+ wmin=1.2e-07              wmax=3e-007-(dxwn+dwmisn) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.953               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxn+toxmisn)       toxm=2e-009
+ dtox=2.4905e-010          epsrox=3.9                wint=0
+ lint=2.8625e-10           ll=0.0050965              wl=0
+ lln=-0.875                wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)                        k1=0.24753
+ k2=-0.0087251118+dk2n     kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            lk2=1.9333728e-009+dlk2n
+ wk2=2.0007264e-009+dwk2n  pk2=-1.8604335e-016+dpk2n k3=-3.98252
+ k3b=2.24786               w0=0                      dvt0=1.08116
+ dvt1=1.18773              dvt2=0.015579             dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.46494             voffl=0                   dvtp0=4.20003e-007
+ dvtp1=0                   lpe0=6.10104e-009         lpeb=4.55849e-008
+ xj=1.1e-007               ngate=3.1592e+020         ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0018577436
+ lcit=1.9229318e-010+dlcitn                          wcit=-1.8809631e-010+dwcitn
+ pcit=4.1491196e-018+dpcitn                          voff=-0.125313+dvoffn
+ lvoff=-1.2762528e-009+dlvoffn                       wvoff=-3.0355883e-009+dwvoffn
+ pvoff=2.0756399e-016+dpvoffn                        nfactor=0.6+dnfactorn
+ eta0=0.17749547+deta0n    leta0=6.6849788e-013+dleta0n
+ weta0=-9.8269028e-009+dweta0n                       peta0=-5.7738305e-020+dpeta0n
+ etab=-0.023722699         letab=5.8948171e-014      wetab=2.9983772e-009
+ petab=-7.7839458e-021     u0=0.021831936+du0n       lu0=-2.2363024e-010+dlu0n
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               wu0=-9.4279025e-010+dwu0n pu0=3.0406755e-017+dpu0n
+ ua=-1.1583833e-009        lua=-1.3776772e-017       wua=-8.4074937e-017
+ pua=3.6997621e-024        ub=1.820562e-018          lub=-7.7987193e-027
+ wub=2.474675e-026         pub=-5.6871307e-034       uc=-3.7966866e-11
+ luc=1.1250247e-017        wuc=1.7926221e-018        puc=-1.2553557e-024
+ vsat=101530+dvsatn        a0=-3.4716699+da0n        la0=3.780231e-007+dla0n
+ kvsat=1                   wa0=1.1386036e-006+dwa0n  pa0=-9.8148973e-014+dpa0n
+ ags=4.9232391+dagsn       lags=-2.3160946e-007+dlagsn
+ wags=3.0176509e-007       pags=-2.4939737e-014+dpagsn
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.12347864          lketa=4.9131401e-009
+ wketa=3.193095e-009       pketa=-6.6818705e-016     dwg=0
+ dwb=0                     pclm=0.093967323+dpclmn   lpclm=2.9312566e-009
+ wpclm=-1.0423978e-008     ppclm=2.0181952e-015+dppclmn
+ pdiblc1=0                 pdiblc2=0.01818526        lpdiblc2=-8.4976964e-010
+ wpdiblc2=4.8430337e-010   ppdiblc2=-5.2787132e-018  pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.25218326+dkt1n     lkt1=-6.42307e-009+dlkt1n wkt1=-4.9481831e-009+dwkt1n
+ pkt1=5.1488255e-016+dpkt1n                          kt1l=0
+ kt2=-0.046345989+dkt2n    lkt2=-8.7797364e-010+dlkt2n
+ wkt2=-3.6258417e-009+dwkt2n                         pkt2=2.2362531e-016+dpkt2n
+ ute=-1                    ua1=2.9663074e-009+dua1n  lua1=-1.116858e-016+dlua1n
+ wua1=-1.7231279e-016+dwua1n                         pua1=9.6318435e-024+dpua1n
+ ub1=-3.270421e-018+dub1n  lub1=1.4661082e-025+dlub1n
+ wub1=2.0392292e-025+dwub1n                          pub1=-1.331899e-032+dpub1n
+ uc1=-7.45092e-12          luc1=1.1508162e-019       wuc1=2.249445e-017
+ puc1=-5.8762281e-025      prt=0                     at=117005.15+datn
+ lat=-0.0045830649+dlatn   wat=0.0060113766+dwatn    pat=-5.4483456e-010+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn            wvth0=0+dwvthn            pvth0=0+dpvthn
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ lvsat=0+dlvsatn           wvsat=0+dwvsatn           pvsat=0+dpvsatn
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
 
     25: type=n 
+ lmin=6e-08                lmax=1e-007-(dxln+dlmisn) wmin=1.2e-07
+ wmax=3e-007-(dxwn+dwmisn) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxn+toxmisn)       toxm=2e-009               dtox=2.4905e-010
+ epsrox=3.9                wint=0                    lint=2.8625e-10
+ ll=0.0050965              wl=0                      lln=-0.875
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+(dxln+dlmisn)
+ xw=1.6e-08+(dxwn+dwmisn)  dlc=2.8625e-10+ddlcn      dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=0.31703+(dvthn+vthmisn)-0.00273517*ss_flag+0.00373758*ff_flag-0.00299007*sf_flag+0.00299007*fs_flag
+ kvth0=19e-10              pkvth0=0                  wkvth0=5e-8
+ lkvth0=-0.4e-8            k1=0.24753                k2=0.036728546+dk2n
+ lk2=-1.6197396e-009+dlk2n wk2=-1.2017274e-009+dwk2n pk2=6.4292462e-017+dpk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00040913491-0.000968095*ff_flag+0.000774476*sf_flag-0.000774476*fs_flag
+ lcit=3.0553092e-010+dlcitn+7.56757e-11*ff_flag-6.05406e-11*sf_flag+6.05406e-11*fs_flag
+ wcit=-2.3399974e-010+dwcitn+1.31661e-10*ff_flag-1.05329e-10*sf_flag+1.05329e-10*fs_flag
+ pcit=7.7373911e-018+dpcitn-1.02919e-17*ff_flag+8.23352e-18*sf_flag-8.23352e-18*fs_flag
+ voff=-0.11692241+dvoffn+0.00277929*ff_flag-0.0022901*sf_flag+0.0022901*fs_flag
+ lvoff=-1.9321447e-009+dlvoffn-2.17256e-10*ff_flag+1.79016e-10*sf_flag-1.79016e-10*fs_flag
+ wvoff=-3.9742035e-009+dwvoffn-3.55485e-10*ff_flag+3.05453e-10*sf_flag-3.05453e-10*fs_flag
+ pvoff=2.8093554e-016+dpvoffn+2.77881e-17*ff_flag-2.38772e-17*sf_flag+2.38772e-17*fs_flag
+ nfactor=0.6+dnfactorn     eta0=0.17742597+deta0n+0.000866629*sf_flag-0.000866629*fs_flag
+ leta0=6.1011734e-012+dleta0n-6.77441e-11*sf_flag+6.77441e-11*fs_flag
+ weta0=-9.8599453e-009+dweta0n-2.73855e-10*sf_flag+2.73855e-10*fs_flag
+ peta0=2.5251951e-018+dpeta0n+2.14071e-17*sf_flag-2.14071e-17*fs_flag
+ etab=-0.030484029         letab=5.2859207e-010      wetab=7.2121031e-009
+ petab=-3.2939474e-016     u0=0.018970264+du0n-0.000387238*ss_flag+0.00103672*ff_flag-0.000829375*sf_flag+0.000829375*fs_flag
+ ku0=-2.9e-8               pku0=2e-14                wku0=1.2e-7
+ lku0=2.2e-7               lu0=6.6603747e-014+dlu0n+3.02703e-11*ss_flag-8.10401e-11*ff_flag+6.48321e-11*sf_flag-6.48321e-11*fs_flag
+ wu0=-5.5369196e-010+dwu0n+5.26643e-11*ss_flag-1.18495e-10*ff_flag+9.47954e-11*sf_flag-9.47954e-11*fs_flag
+ pu0=-9.0581096e-021+dpu0n-4.11676e-18*ss_flag+9.26273e-18*ff_flag-7.41016e-18*sf_flag+7.41016e-18*fs_flag
+ ua=-1.5787744e-009        lua=1.9085204e-017        wua=-1.0773324e-016
+ pua=5.5491317e-024        ub=1.6904476e-018+2.20579e-20*ss_flag-4.14198e-20*ff_flag+3.31358e-20*sf_flag-3.31358e-20*fs_flag
+ lub=2.3723237e-027-1.72426e-27*ss_flag+3.23777e-27*ff_flag-2.59021e-27*sf_flag+2.59021e-27*fs_flag
+ wub=1.2886079e-025+4.8e-33*ss_flag+2.63322e-27*ff_flag-2.10657e-27*sf_flag+2.10657e-27*fs_flag
+ pub=-8.7073075e-033+1.2e-40*ss_flag-2.05838e-34*ff_flag+1.6467e-34*sf_flag-1.6467e-34*fs_flag
+ uc=4.6333783e-11          luc=4.6604655e-018        wuc=-2.4824599e-018
+ puc=-9.211725e-025        vsat=101530+dvsatn-1654.33*ff_flag+1323.47*sf_flag-1323.47*fs_flag
+ kvsat=1                   a0=2.3647317+da0n         la0=-7.8208403e-008+dla0n
+ wa0=-2.6060851e-007+dwa0n pa0=1.1227434e-014+dpa0n  ags=1.9603468+dagsn
+ lags=-1.7108885e-013+dlagsn                         wags=-1.727985e-008
+ pags=6.38185e-021+dpagsn  a1=0                      a2=1
+ b0=0                      b1=0                      keta=-0.1743017
+ lketa=8.885979e-009       wketa=-1.4752473e-008     pketa=7.3461803e-016
+ dwg=0                     dwb=0                     pclm=0.091058931+dpclmn
+ lpclm=3.1586056e-009      wpclm=1.8821285e-008      ppclm=-2.6790695e-016+dppclmn
+ pdiblc1=0                 pdiblc2=0.024553965       lpdiblc2=-1.3476113e-009
+ wpdiblc2=-3.3793089e-009  ppdiblc2=2.9673986e-016   pdiblcb=-0.03716
+ drout=0.5                 pvag=0.7                  delta=0.01
+ pscbe1=4.24e+008          pscbe2=1e-020             fprout=0
+ pdits=0.44984             pditsd=1                  pditsl=264000
+ rsh=16                    rsw=45+drdswn             rdw=45+drdswn
+ prwg=0                    prwb=0                    wr=1
+ alpha0=3.3929e-010        alpha1=0.0034             beta0=5.808
+ agidl=1.5797e-008         bgidl=1.4527e+009         cgidl=1.4892
+ egidl=0.81976             aigbacc=0.013432          bigbacc=0.0065981
+ cigbacc=0.39315           nigbacc=4.8               aigbinv=0.024468
+ bigbinv=0.012141          cigbinv=0.0855            eigbinv=1.1
+ nigbinv=3.8771            aigc=0.010744             bigc=0.000824385
+ cigc=-0.087762            aigsd=0.0093701           bigsd=0.0012397
+ cigsd=0.081703            nigc=1.5                  poxedge=1
+ pigcd=3.11                ntox=ntoxn                xrcrg1=12
+ xrcrg2=1                  cgso=cgon                 cgdo=cgon
+ cgbo=0                    cgdl=cgln                 cgsl=cgln
+ clc=1e-007                cle=0.6                   cf=cfn
+ ckappas=0.6               ckappad=0.6               acde=0.6
+ moin=7.6133               noff=2.4067               voffcv=-0.12779
+ kt1=-0.3072922+dkt1n      lkt1=-2.1152041e-009+dlkt1n
+ wkt1=1.6531689e-009+dwkt1n                          pkt1=-1.1451303e-018+dpkt1n
+ kt1l=0                    kt2=-0.048109142+dkt2n    lkt2=-7.40148e-010+dlkt2n
+ wkt2=-2.4913653e-009+dwkt2n                         pkt2=1.349433e-016+dpkt2n
+ ute=-1                    ua1=1.6482392e-009+dua1n  lua1=-8.6524068e-018+dlua1n
+ wua1=-1.9636659e-017+dwua1n                         pua1=-2.3028499e-024+dpua1n
+ ub1=-1.6859929e-018+dub1n lub1=2.2756071e-026+dlub1n
+ wub1=3.7761185e-026+dwub1n                          pub1=-3.3012692e-034+dpub1n
+ uc1=-1.2387624e-10        luc1=9.216049e-018        wuc1=4.3823379e-017
+ puc1=-2.2549052e-024      prt=0                     at=64191.937+datn
+ lat=-0.00045465632+dlatn  wat=-0.0012363781+dwatn   pat=2.1722425e-011+dpatn
+ jss=1.35e-07              jsd=1.35e-07              jsws=2.5e-13
+ jswd=2.5e-13              jswgs=2.5e-13             jswgd=2.5e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.03                  bvd=9.03                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjn                   cjd=cjn                   mjs=0.32
+ mjd=0.32                  pbsws=1.12                pbswd=1.12
+ cjsws=cjswn               cjswd=cjswn               mjsws=0.05
+ mjswd=0.05                pbswgs=1.15               pbswgd=1.15
+ cjswgs=cjswgn             cjswgd=cjswgn             mjswgs=0.98
+ mjswgd=0.98               tpb=0.0016                tcj=0.0008
+ tpbsw=0.003               tcjsw=0.0004              tpbswg=0.0019
+ tcjswg=0.0016             xtis=3                    xtid=3
+ jtsswgs=7.86078e-009      jtsswgd=7.86078e-009      njtsswg=5.64
+ xtsswgs=-0.103            xtsswgd=-0.103            tnjtsswg=-0.485
+ vtsswgs=17.7              vtsswgd=17.7              dmcg=7.15e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-1.163e-8
+ lvth0=0+dlvthn+2.13808e-10*ss_flag-2.92166e-10*ff_flag+2.33733e-10*sf_flag-2.33733e-10*fs_flag
+ wvth0=0+dwvthn+2.36989e-10*ss_flag-6.58305e-10*ff_flag+5.26643e-10*sf_flag-5.26643e-10*fs_flag
+ pvth0=0+dpvthn-1.85254e-17*ss_flag+5.14595e-17*ff_flag-4.11676e-17*sf_flag+4.11676e-17*fs_flag
+ lnfactor=0+dlnfactorn     wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn
+ lvsat=0+dlvsatn+0.000129319*ff_flag-0.000103456*sf_flag+0.000103456*fs_flag
+ wvsat=0+dwvsatn+3.9e-10*ff_flag+9e-11*sf_flag-9e-11*fs_flag
+ pvsat=0+dpvsatn-9e-18*ff_flag+4.7e-17*sf_flag-4.7e-17*fs_flag
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   llodku0=1                 wlodku0=1
+ lodeta0=1                 steta0=0e-10              tku0=0
+ wec=-3010                 web=-210                  scref=1e-6
+ wpemod=1                  kvth0we=0.0036            pkvth0we=0.15e-17
+ wkvth0we=-9.5e-11         lkvth0we=-5.6e-11         ku0we=-0.0017
+ pku0we=-1.4e-17           wku0we=-2.0e-10           lku0we=1.88e-10
+ k2we=0.00045              pk2we=-0.26e-17           wk2we=0.4e-10
+ lk2we=0.1e-12             fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noian
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibn
+ rnoib=0                   noic=noicn                em=3e+8
+ ef=0.9                    lintnoi=-1e-8             minr=1e-3
 
     } 
ends nch_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.0V STD-VT PMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
// *********************************
//        Mismatch   model         *
// *********************************
inline subckt pch_mac ( n1 n2 n3 n4 ) 
parameters l=1u w=1u multi=1 nf=1 factor=1 sigma=1 dmcg=7e-008 xw= + 1.6e-08 
+ + dxwp ad=2 * dmcg / factor * (w / nf + xw / factor) as=2 * dmcg / factor * (w 
+ / nf + xw / factor) pd=4 * dmcg / factor + 2 * (w / nf + xw / factor) ps=4 * dmcg 
+ / factor + 2 * (w / nf + xw / factor) nrd=dmcg / factor / (w / nf + xw / factor) 
+ nrs=dmcg / factor / (w / nf + xw / factor) sa=0.405e-6 / factor sb=0.405e-6 / 
+ factor sd=2 * dmcg / factor sca=0e-6 / factor scb=0e-6 / factor scc=0e-6 / factor 
+ mismatchflag=1 temp1=parp1 temp2=parp2 fac1=0.836583 * temp1 * sigma + 0.547841 
+ * temp2 * sigma fac2=0.836583 * temp1 * sigma - 0.547841 * temp2 * sigma lef=l 
+ * factor - 1.09e-08 wef=w / nf * factor + 1.6e-08 geo_fac=1 / sqrt(multi * nf 
+ * lef * wef * 1e12) vthmisp=0.00215161 * geo_fac * fac1 * mismatchflag dlmisp=0.00170787 
+ * geo_fac * lef * fac2 * mismatchflag dwmisp= - 0.00170787 * geo_fac * wef * fac2 
+ * mismatchflag toxmisp=0.00170787 * geo_fac * toxp * fac2 * mismatchflag tnoiax=3.163e05 
+ / (l * 1e6) + 5.918e07 rnoiax=0.02751 / (l * 1e6) + 0.3577 
pch_mac ( n1 n2 n3 n4 ) pch w=w l=l ad=ad as=as pd=pd ps=ps nrd=nrd nrs=nrs m=multi 
+ nf=nf sa=sa sb=sb sd=sd sca=sca scb=scb scc=scc
// *** mismatch ***
model pch bsim4  { 
     1: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2.00001e-05          wmin=1e-005-(dxwp+dwmisp)
+ wmax=0.0009000001         version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.0074532975+dk2p      k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.000869203+dcitp
+ voff=-0.12476237+dvoffp   nfactor=0.52254+dnfactorp eta0=0.19+deta0p
+ etab=-0.25914             u0=0.0073729957+du0p      ua=-6.2355876e-010
+ ub=1.3725583e-018         ku0=-0.5354e-9            pku0=2e-16
+ wku0=0e-7                 lku0=-4.0055e-8           uc=2.1478427e-011
+ vsat=90000+dvsatp         a0=2.6676428+da0p         kvsat=1
+ ags=0.90689921+dagsp      a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=0.016225333
+ dwg=0                     dwb=0                     pclm=1.013+dpclmp
+ pdiblc1=0                 pdiblc2=0.002             pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.22772509           kt1l=0                    kt2=-0.018271317
+ ute=-1                    ua1=1.704375e-009         ub1=-1.77067e-018
+ lute=0+dlutep             uc1=2e-010                prt=0
+ at=180000                 lat=0+dlatp               jss=1.73e-07
+ jsd=1.73e-07              jsws=1.86e-13             jswd=1.86e-13
+ jswgs=1.86e-13            jswgd=1.86e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.59
+ bvd=9.59                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp
+ cjd=cjp                   mjs=0.31                  mjd=0.31
+ pbsws=0.96                pbswd=0.96                cjsws=cjswp
+ cjswd=cjswp               mjsws=0.063               mjswd=0.063
+ pbswgs=0.42               pbswgd=0.42               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.98               mjswgd=0.98
+ tpb=0.00155               tcj=0.00085               tpbsw=0.003
+ tcjsw=0.0002              tpbswg=0.0004             tcjswg=0.0024
+ xtis=3                    xtid=3                    jtsswgs=jtsswgp
+ jtsswgd=jtsswgp           njtsswg=6.62              xtsswgs=0.3645
+ xtsswgd=0.3645            tnjtsswg=0.565            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             wk2=0+dwk2p
+ pcit=0+dpcitp             lcit=0+dlcitp             wcit=0+dwcitp
+ pvoff=0+dpvoffp           wvoff=0+dwvoffp           lvoff=0+dlvoffp
+ weta0=0+dweta0p           wu0=0+dwu0p               pa0=0+dpa0p
+ wa0=0+dwa0p               la0=0+dla0p               pags=0+dpagsp
+ lags=0+dlagsp             wags=0+dwagsp             lk2=0+dlk2p
+ pk2=0+dpk2p               lu0=0+dlu0p               pu0=0+dpu0p
+ lvth0=0+dlvthp            wvth0=0+dwvthp            pvth0=0+dpvthp
+ lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp
+ leta0=0+dleta0p           peta0=0+dpeta0p           lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     2: type=p 
+ lmin=1.000003e-006-(dxlp+dlmisp)                    lmax=1e-005-(dxlp+dlmisp)
+ wmin=1e-005-(dxwp+dwmisp) wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.0077038485+dk2p      lk2=-2.4920827e-009+dlk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00086249531+dcitp   lcit=6.6717475e-011+dlcitp
+ voff=-0.12502046+dvoffp   lvoff=2.5670188e-009+dlvoffp
+ nfactor=0.52254+dnfactorp eta0=0.19+deta0p          etab=-0.25914
+ u0=0.0073204169+du0p      lu0=5.2297004e-10+dlu0p   ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ ua=-6.5211033e-010        lua=2.8398563e-016        ub=1.3765443e-018
+ lub=-3.9646592e-026       uc=1.9187751e-011         luc=2.2784e-017
+ vsat=90000+dvsatp         a0=2.6876308+da0p         la0=-1.9880926e-007+dla0p
+ kvsat=1                   ags=0.84370016+dagsp      lags=6.2860381e-07+dlagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=0.024617043          lketa=-8.3467389e-008
+ dwg=0                     dwb=0                     pclm=1.013+dpclmp
+ pdiblc1=0                 pdiblc2=0.0017896867      lpdiblc2=2.0918626e-009
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.060315            pditsd=0.95634
+ pditsl=0                  rsh=15.5                  rsw=110+drdswp
+ rdw=110+drdswp            prwg=0                    prwb=0
+ wr=1                      alpha0=1.49e-9            alpha1=0.00383
+ beta0=10.7                agidl=1e-008              bgidl=1.75963e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.014358
+ bigbacc=0.0069774         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0061361
+ bigc=0.00026197           cigc=-0.03984             aigsd=0.0049603
+ bigsd=0.000207349         cigsd=0.0042644           nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.079               noff=2.1891
+ voffcv=-0.080796          kt1=-0.22649778           lkt1=-1.2207347e-008
+ kt1l=0                    kt2=-0.0156353            lkt2=-2.6218912e-008
+ ute=-1                    ua1=1.6852102e-009        lua1=1.9062098e-016
+ lute=0+dlutep             ub1=-1.7452904e-018       lub1=-2.5243552e-025
+ uc1=2.1173664e-010        luc1=-1.1673744e-016      prt=0
+ at=180000                 lat=0+dlatp               jss=1.73e-07
+ jsd=1.73e-07              jsws=1.86e-13             jswd=1.86e-13
+ jswgs=1.86e-13            jswgd=1.86e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.59
+ bvd=9.59                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp
+ cjd=cjp                   mjs=0.31                  mjd=0.31
+ pbsws=0.96                pbswd=0.96                cjsws=cjswp
+ cjswd=cjswp               mjsws=0.063               mjswd=0.063
+ pbswgs=0.42               pbswgd=0.42               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.98               mjswgd=0.98
+ tpb=0.00155               tcj=0.00085               tpbsw=0.003
+ tcjsw=0.0002              tpbswg=0.0004             tcjswg=0.0024
+ xtis=3                    xtid=3                    jtsswgs=jtsswgp
+ jtsswgd=jtsswgp           njtsswg=6.62              xtsswgs=0.3645
+ xtsswgd=0.3645            tnjtsswg=0.565            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             wk2=0+dwk2p
+ pcit=0+dpcitp             wcit=0+dwcitp             pvoff=0+dpvoffp
+ wvoff=0+dwvoffp           weta0=0+dweta0p           wu0=0+dwu0p
+ pa0=0+dpa0p               wa0=0+dwa0p               pags=0+dpagsp
+ wags=0+dwagsp             pk2=0+dpk2p               pu0=0+dpu0p
+ lvth0=0+dlvthp            wvth0=0+dwvthp            pvth0=0+dpvthp
+ lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp
+ leta0=0+dleta0p           peta0=0+dpeta0p           lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     3: type=p 
+ lmin=2.39995e-007-(dxlp+dlmisp)                     lmax=1.000003e-006-(dxlp+dlmisp)
+ wmin=1e-005-(dxwp+dwmisp) wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=5.0965e-03             wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=5.0965e-03
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ k2=0.0040264877+dk2p      kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.330e-8          lk2=9.8820827e-010+dlk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00069317025+dcitp   lcit=2.269684e-010+dlcitp voff=-0.11955179+dvoffp
+ lvoff=-2.6085788e-009+dlvoffp                       nfactor=0.52254+dnfactorp
+ eta0=0.19+deta0p          etab=-0.25914             u0=0.007873+du0p
+ ua=-3.7155346e-010        lua=1.8463797e-017        ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ ub=1.3944482e-018         lub=-5.6591032e-026       uc=4.1404662e-011
+ luc=1.7576929e-018        vsat=90000+dvsatp         a0=2.5452408+da0p
+ kvsat=1                   la0=-6.4049913e-008+dla0p ags=0.70293767+dagsp
+ lags=7.6182275e-007+dlagsp                          a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=-0.052817647         lketa=-1.0182424e-008     dwg=0
+ dwb=0                     pclm=0.75681439+dpclmp    lpclm=2.4245662e-007
+ pdiblc1=0                 pdiblc2=0.004             pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.23120259           lkt1=-7.7546663e-009      kt1l=0
+ kt2=-0.041490026          lkt2=-1.7497402e-009      ute=-1
+ ua1=1.8915172e-009        lua1=-4.6300321e-018      lute=0+dlutep
+ ub1=-1.8820702e-018       lub1=-1.2298575e-025      uc1=1.499746e-010
+ luc1=-5.8285232e-017      prt=0                     at=193037.72
+ lat=-0.012339033+dlatp    jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             wk2=0+dwk2p               pcit=0+dpcitp
+ wcit=0+dwcitp             pvoff=0+dpvoffp           wvoff=0+dwvoffp
+ weta0=0+dweta0p           wu0=0+dwu0p               pa0=0+dpa0p
+ wa0=0+dwa0p               pags=0+dpagsp             wags=0+dwagsp
+ pk2=0+dpk2p               lu0=0+dlu0p               pu0=0+dpu0p
+ lvth0=0+dlvthp            wvth0=0+dwvthp            pvth0=0+dpvthp
+ lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp
+ leta0=0+dleta0p           peta0=0+dpeta0p           lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     4: type=p 
+ lmin=1e-007-(dxlp+dlmisp) lmax=2.39995e-007-(dxlp+dlmisp)
+ wmin=1e-005-(dxwp+dwmisp) wmax=0.0009000001         version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29576369+(dvthp+vthmisp)                    lvth0=9.0719854e-010+dlvthp
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k1=0.22699184             lk1=3.5259378e-009
+ k2=0.026577244+dk2p       lk2=-3.8784706e-009+dlk2p k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=-9.1754066e-005+dcitp
+ lcit=3.9636292e-010+dlcitp                          voff=-0.11836716+dvoffp
+ lvoff=-2.8642355e-009+dlvoffp                       nfactor=0.52254+dnfactorp
+ eta0=0.19+deta0p          etab=-0.29791556          letab=8.3681545e-009
+ u0=0.0081015014+du0p      lu0=-4.9312891e-011+dlu0p ku0=-0.5354e-9
+ pku0=2e-16                wku0=0e-7                 lku0=-4.0055e-8
+ ua=-3.1696469e-010        lua=6.6829952e-018        ub=1.344608e-018
+ lub=-4.5835006e-026       uc=5.7440204e-011         luc=-1.7029373e-018
+ vsat=77502.872+dvsatp     lvsat=0.0026970053+dlvsatp
+ kvsat=1                   a0=3.0132596+da0p         la0=-1.6505306e-007+dla0p
+ ags=4.233+dagsp           a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.11285315
+ lketa=2.7738375e-009      dwg=0                     dwb=0
+ pclm=2.3582942+dpclmp     lpclm=-1.0315873e-007     pdiblc1=0
+ pdiblc2=0.0015495827      lpdiblc2=5.2882456e-010   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.2294432            lkt1=-8.1343596e-009      kt1l=0
+ kt2=-0.04624023           lkt2=-7.2459867e-010      ute=-1
+ lute=0+dlutep             ua1=1.8900638e-009        lua1=-4.3163824e-018
+ ub1=-2.3886435e-018       lub1=-1.3662183e-026      uc1=-8.4866224e-011
+ luc1=-7.6042328e-018      prt=0                     at=174923.98
+ lat=-0.0084299055+dlatp   jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             wk2=0+dwk2p               pcit=0+dpcitp
+ wcit=0+dwcitp             pvoff=0+dpvoffp           wvoff=0+dwvoffp
+ weta0=0+dweta0p           wu0=0+dwu0p               pa0=0+dpa0p
+ wa0=0+dwa0p               pags=0+dpagsp             lags=0+dlagsp
+ wags=0+dwagsp             pk2=0+dpk2p               pu0=0+dpu0p
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp                rnoib=0
+ noic=noicp                em=3e+8                   ef=1.1 
+ lintnoi=-1e-8             minr=1e-3
 
 
     5: type=p 
+ lmin=6e-08                lmax=1e-007-(dxlp+dlmisp) wmin=1e-005-(dxwp+dwmisp)
+ wmax=0.0009000001         version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=1.25625e-09
+ ll=0.0050965              wl=0                      lln=-0.9
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29858652+(dvthp+vthmisp)-0.00230485*ff_flag-0.00184388*sf_flag+0.00184388*fs_flag
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=1.1386228e-009+dlvthp+1.88958e-10*ff_flag+1.51166e-10*sf_flag-1.51166e-10*fs_flag
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.016598865+dk2p
+ lk2=-3.060413e-009+dlk2p  k3=-2.39941               k3b=1.88101
+ w0=0                      dvt0=1.44595              dvt1=0.91219
+ dvt2=0.16184              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.5                  minv=-0.1
+ voffl=0                   dvtp0=1.10431e-007        dvtp1=3.5
+ lpe0=3.77983e-008         lpeb=4.1935e-009          xj=1.1e-007
+ ngate=1.812e+020          ndep=6.3687e+017          nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=8.0345555e-005+dcitp  lcit=3.8225368e-010+dlcitp
+ voff=-0.13328857+dvoffp-0.00172864*ff_flag-0.00138291*sf_flag+0.00138291*fs_flag
+ lvoff=-1.6409329e-009+dlvoffp+1.41719e-10*ff_flag+1.13375e-10*sf_flag-1.13375e-10*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.16427685+deta0p-0.00288106*ss_flag+0.00806697*ff_flag+0.00645357*sf_flag-0.00645357*fs_flag
+ leta0=2.1088608e-009+dleta0p+2.36198e-10*ss_flag-6.61353e-10*ff_flag-5.29083e-10*sf_flag+5.29083e-10*fs_flag
+ etab=-0.32945655          letab=1.0953979e-008      u0=0.0075+du0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           ua=-3.9364996e-010        lua=1.2969884e-017
+ ub=8.6123513e-019         lub=-6.2066515e-027       uc=6.4347439e-011
+ luc=-2.2692131e-018       vsat=135361.12+dvsatp     lvsat=-0.0020463874+dlvsatp
+ kvsat=1                   a0=-2.4572186+da0p        la0=2.8343315e-007+dla0p
+ ags=4.233+dagsp           a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.2309279
+ lketa=1.245396e-008       dwg=0                     dwb=0
+ pclm=1.6762031+dpclmp-0.115242*ff_flag-0.0921939*sf_flag+0.0921939*fs_flag
+ ppclm=0+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag         wpclm=0+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ lpclm=-4.7238859e-008+9.4479e-09*ff_flag+7.55832e-09*sf_flag-7.55832e-09*fs_flag
+ pdiblc1=0                 pdiblc2=0.0056951876      lpdiblc2=1.8895544e-010
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.060315            pditsd=0.95634
+ pditsl=0                  rsh=15.5                  rsw=110+drdswp
+ rdw=110+drdswp            prwg=0                    prwb=0
+ wr=1                      alpha0=1.49e-9            alpha1=0.00383
+ beta0=10.7                agidl=1e-008              bgidl=1.75963e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.014358
+ bigbacc=0.0069774         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0061361
+ bigc=0.00026197           cigc=-0.03984             aigsd=0.0049603
+ bigsd=0.000207349         cigsd=0.0042644           nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.079               noff=2.1891
+ voffcv=-0.080796          kt1=-0.27827977           lkt1=-4.1305914e-009
+ kt1l=0                    kt2=-0.056201526          lkt2=9.2058238e-011
+ ute=-1                    lute=0+dlutep             ua1=1.4250627e-009
+ lua1=3.3805803e-017       ub1=-2.1971682e-018       lub1=-2.9359896e-026
+ uc1=-2.338701e-010        luc1=4.6115519e-018       prt=0
+ at=143181.27              lat=-0.0058275427+dlatp   jss=1.73e-07
+ jsd=1.73e-07              jsws=1.86e-13             jswd=1.86e-13
+ jswgs=1.86e-13            jswgd=1.86e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.59
+ bvd=9.59                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp
+ cjd=cjp                   mjs=0.31                  mjd=0.31
+ pbsws=0.96                pbswd=0.96                cjsws=cjswp
+ cjswd=cjswp               mjsws=0.063               mjswd=0.063
+ pbswgs=0.42               pbswgd=0.42               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.98               mjswgd=0.98
+ tpb=0.00155               tcj=0.00085               tpbsw=0.003
+ tcjsw=0.0002              tpbswg=0.0004             tcjswg=0.0024
+ xtis=3                    xtid=3                    jtsswgs=jtsswgp
+ jtsswgd=jtsswgp           njtsswg=6.62              xtsswgs=0.3645
+ xtsswgd=0.3645            tnjtsswg=0.565            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             wk2=0+dwk2p
+ pcit=0+dpcitp             wcit=0+dwcitp             pvoff=0+dpvoffp+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ wvoff=0+dwvoffp+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ weta0=0+dweta0p+0.0*ss_flag+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ wu0=0+dwu0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag     pa0=0+dpa0p
+ wa0=0+dwa0p               pags=0+dpagsp             lags=0+dlagsp
+ wags=0+dwagsp             pk2=0+dpk2p               lu0=0+dlu0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ pu0=0+dpu0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag     wvth0=0+dwvthp+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ pvth0=0+dpvthp+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag  lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     peta0=0+dpeta0p+0.0*ss_flag+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     6: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2.00001e-05          wmin=1e-006-(dxwp+dwmisp)
+ wmax=1e-005-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.0081689243+dk2p      wk2=-7.1677174e-009+dwk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00091088192+dcitp   wcit=-4.1745603e-010+dwcitp
+ voff=-0.12490763+dvoffp   wvoff=1.4549016e-009+dwvoffp
+ nfactor=0.52254+dnfactorp eta0=0.19395111+deta0p    weta0=-3.9574329e-008+dweta0p
+ etab=-0.27202514          wetab=1.2905754e-007      u0=0.007310781+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=6.2314224e-10+dwu0p   ua=-6.2485993e-010
+ wua=1.3032437e-017        ub=1.3839682e-018         wub=-1.1428192e-025
+ uc=1.8896581e-011         wuc=2.5859769e-017        vsat=90000+dvsatp
+ a0=2.5967305+da0p         wa0=7.1025688e-007+dwa0p  kvsat=1
+ ags=0.90444932+dagsp      wags=2.453821e-08+dwagsp  a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.017863466          wketa=-1.6407538e-008     dwg=0
+ dwb=0                     pclm=1.013+dpclmp         pdiblc1=0
+ pdiblc2=0.002             pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswp            rdw=110+drdswp            prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp                xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.22824122
+ wkt1=5.1695946e-009       kt1l=0                    kt2=-0.017214986
+ wkt2=-1.058021e-008       ute=-1                    lute=0+dlutep
+ ua1=1.705518e-009         wua1=-1.1448288e-017      ub1=-1.7903567e-018
+ wub1=1.9718192e-025       uc1=2e-010                prt=0
+ at=180000                 lat=0+dlatp               jss=1.73e-07
+ jsd=1.73e-07              jsws=1.86e-13             jswd=1.86e-13
+ jswgs=1.86e-13            jswgd=1.86e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.59
+ bvd=9.59                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp
+ cjd=cjp                   mjs=0.31                  mjd=0.31
+ pbsws=0.96                pbswd=0.96                cjsws=cjswp
+ cjswd=cjswp               mjsws=0.063               mjswd=0.063
+ pbswgs=0.42               pbswgd=0.42               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.98               mjswgd=0.98
+ tpb=0.00155               tcj=0.00085               tpbsw=0.003
+ tcjsw=0.0002              tpbswg=0.0004             tcjswg=0.0024
+ xtis=3                    xtid=3                    jtsswgs=jtsswgp
+ jtsswgd=jtsswgp           njtsswg=6.62              xtsswgs=0.3645
+ xtsswgd=0.3645            tnjtsswg=0.565            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             pcit=0+dpcitp
+ lcit=0+dlcitp             pvoff=0+dpvoffp           lvoff=0+dlvoffp
+ pa0=0+dpa0p               la0=0+dla0p               pags=0+dpagsp
+ lags=0+dlagsp             lk2=0+dlk2p               pk2=0+dpk2p
+ lu0=0+dlu0p               pu0=0+dpu0p               lvth0=0+dlvthp
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp
+ rnoib=0                   noic=noicp                em=3e+8
+ ef=1.1                   lintnoi=-1e-8             minr=1e-3
 
 
     7: type=p 
+ lmin=1.000003e-006-(dxlp+dlmisp)                    lmax=1e-005-(dxlp+dlmisp)
+ wmin=1e-006-(dxwp+dwmisp) wmax=1e-005-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.008458461+dk2p       lk2=-2.8798508e-009+dlk2p
+ wk2=-7.5581984e-009+dwk2p pk2=3.8838843e-015+dpk2p  k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00090415248+dcitp
+ lcit=6.6933685e-011+dlcitp                          wcit=-4.172383e-010+dwcitp
+ pcit=-2.1655612e-018+dpcitp                         voff=-0.12520791+dvoffp-1.54323e-05*ff_flag-1.23459e-05*sf_flag+1.23459e-05*fs_flag
+ lvoff=2.9867489e-009+dlvoffp+1.53496e-10*ff_flag+1.22797e-10*sf_flag-1.22797e-10*fs_flag
+ wvoff=1.8775684e-009+dwvoffp+1.5457e-10*ff_flag+1.23656e-10*sf_flag-1.23656e-10*fs_flag
+ pvoff=-4.204017e-015+dpvoffp-1.53742e-15*ff_flag-1.22993e-15*sf_flag+1.22993e-15*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.19395111+deta0p    weta0=-3.9574329e-008+dweta0p
+ etab=-0.27202514          wetab=1.2905754e-007      u0=0.00725166+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=5.8804232e-10+dlu0p   wu0=6.8866988e-10+dwu0p
+ pu0=-6.5176404e-16+dpu0p  ua=-6.5621049e-010        lua=3.1182559e-016
+ wua=4.1067187e-017        pua=-2.7884512e-022       ub=1.3905337e-018
+ lub=-6.5302984e-026       wub=-1.4011782e-025       pub=2.5697442e-031
+ uc=1.6080946e-011         luc=2.8005458e-017        wuc=3.1117759e-017
+ puc=-5.2298127e-023       vsat=90000+dvsatp         a0=2.6131938+da0p
+ la0=-1.637501e-007+dla0p  kvsat=1                   wa0=7.4556133e-007+dwa0p
+ pa0=-3.5115254e-013+dpa0p ags=0.84074276+dagsp      lags=6.3365155e-07+dlagsp
+ wags=2.962126e-08+dwagsp  pags=-5.055811e-14+dpagsp a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.026567445          lketa=-8.6573351e-008     wketa=-1.9535231e-008
+ pketa=3.1109318e-014      dwg=0                     dwb=0
+ pclm=1.013+dpclmp         pdiblc1=0                 pdiblc2=0.0018134287
+ lpdiblc2=1.8557146e-009   wpdiblc2=-2.3780026e-010  ppdiblc2=2.3652589e-015
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.060315            pditsd=0.95634
+ pditsl=0                  rsh=15.5                  rsw=110+drdswp
+ rdw=110+drdswp            prwg=0                    prwb=0
+ wr=1                      alpha0=1.49e-9            alpha1=0.00383
+ beta0=10.7                agidl=1e-008              bgidl=1.75963e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.014358
+ bigbacc=0.0069774         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0061361
+ bigc=0.00026197           cigc=-0.03984             aigsd=0.0049603
+ bigsd=0.000207349         cigsd=0.0042644           nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.079               noff=2.1891
+ voffcv=-0.080796          kt1=-0.22699424           lkt1=-1.2403032e-008
+ wkt1=4.9725402e-009       pkt1=1.9599836e-015       kt1l=0
+ kt2=-0.014552653          lkt2=-2.648066e-008       wkt2=-1.0843791e-008
+ pkt2=2.6216765e-015       ute=-1                    lute=0+dlutep
+ ua1=1.6869542e-009        lua1=1.8464349e-016       wua1=-1.7467607e-017
+ pua1=5.9870615e-023       ub1=-1.766442e-018        lub1=-2.3786519e-025
+ wub1=2.118542e-025        pub1=-1.4593647e-031      uc1=2.1135215e-010
+ luc1=-1.1291314e-016      wuc1=3.8510563e-018       puc1=-3.8304185e-023
+ prt=0                     at=180000                 lat=0+dlatp
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ lvth0=0+dlvthp            wvth0=0+dwvthp            pvth0=0+dpvthp
+ lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp
+ leta0=0+dleta0p           peta0=0+dpeta0p           lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     8: type=p 
+ lmin=2.39995e-007-(dxlp+dlmisp)                     lmax=1.000003e-006-(dxlp+dlmisp)
+ wmin=1e-006-(dxwp+dwmisp) wmax=1e-005-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=5.0965e-03             wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=5.0965e-03
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ k2=0.0043966697+dk2p      kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.330e-8          lk2=9.6426911e-010+dlk2p
+ wk2=-3.7077429e-009+dwk2p pk2=2.3977462e-016+dpk2p  k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00074368874+dcitp
+ lcit=2.1879817e-010+dlcitp                          wcit=-5.0599326e-010+dwcitp
+ pcit=8.1833015e-017+dpcitp                          voff=-0.11919617+dvoffp+0.000190105*ff_flag+0.000152084*sf_flag-0.000152084*fs_flag
+ lvoff=-2.7028235e-009+dlvoffp-4.10266e-11*ff_flag-3.28213e-11*sf_flag+3.28213e-11*fs_flag
+ wvoff=-3.5619048e-009+dwvoffp-1.90409e-09*ff_flag-1.52328e-09*sf_flag+1.52328e-09*fs_flag
+ pvoff=9.4395477e-016+dpvoffp+4.10923e-16*ff_flag+3.28738e-16*sf_flag-3.28738e-16*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.19395111+deta0p    weta0=-3.9574329e-008+dweta0p
+ etab=-0.27202514          wetab=1.2905754e-007      u0=0.007873+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           ua=-3.480937e-010         lua=2.0220776e-017
+ wua=-2.3497303e-016       pua=-1.7597897e-023       ub=1.3846064e-018
+ lub=-5.9693323e-026       wub=9.8575646e-026        pub=3.1072542e-032
+ uc=4.4518454e-011         luc=1.0919164e-018        wuc=-3.1187737e-017
+ puc=6.6684176e-024        vsat=90000+dvsatp         a0=2.5010935+da0p
+ la0=-5.7657284e-008+dla0p kvsat=1                   wa0=4.421791e-007+dwa0p
+ pa0=-6.4028571e-014+dpa0p ags=0.70912157+dagsp      lags=7.5821908e-007+dlagsp
+ wags=-6.1937893e-008+dwagsp                         pags=3.6094403e-014+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.054542369         lketa=-9.8102113e-009
+ wketa=1.7274814e-008      pketa=-3.7280777e-015     dwg=0
+ dwb=0                     pclm=0.74229823+dpclmp    lpclm=2.5619486e-007
+ wpclm=1.4539385e-007      ppclm=-1.3760219e-013     pdiblc1=0
+ pdiblc2=0.0037742222      wpdiblc2=2.2613902e-009   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.23199188           lkt1=-7.6732111e-009      wkt1=7.9055596e-009
+ pkt1=-8.1585532e-016      kt1l=0                    kt2=-0.04099578
+ lkt2=-1.4546202e-009      wkt2=-4.950363e-009       pkt2=-2.9559223e-015
+ ute=-1                    ua1=1.8813326e-009        lua1=6.8177158e-019
+ lute=0+dlutep             wua1=1.0200877e-016       pua1=-5.3203025e-023
+ ub1=-1.8857447e-018       lub1=-1.2495598e-025      wub1=3.6802958e-026
+ pub1=1.973377e-032        uc1=1.5570922e-010        luc1=-6.0252111e-017
+ wuc1=-5.7437866e-017      puc1=1.9700264e-023       prt=0
+ at=193195.53              lat=-0.012488379+dlatp    wat=-0.0015805552
+ pat=1.4958533e-009        jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             wu0=0+dwu0p               lu0=0+dlu0p
+ pu0=0+dpu0p               lvth0=0+dlvthp            wvth0=0+dwvthp
+ pvth0=0+dpvthp            lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp
+ pnfactor=0+dpnfactorp     leta0=0+dleta0p           peta0=0+dpeta0p
+ lvsat=0+dlvsatp           wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp                rnoib=0
+ noic=noicp                em=3e+8                   ef=1.1 
+ lintnoi=-1e-8             minr=1e-3
 
 
     9: type=p 
+ lmin=1e-007-(dxlp+dlmisp) lmax=2.39995e-007-(dxlp+dlmisp)
+ wmin=1e-006-(dxwp+dwmisp) wmax=1e-005-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29576369+(dvthp+vthmisp)                    lvth0=9.0719854e-010+dlvthp
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k1=0.22699184             lk1=3.5259378e-009
+ k2=0.026943317+dk2p       lk2=-3.9015228e-009+dlk2p wk2=-3.6665798e-009+dwk2p
+ pk2=2.3089123e-016+dpk2p  k3=-2.39941               k3b=1.88101
+ w0=0                      dvt0=1.44595              dvt1=0.91219
+ dvt2=0.16184              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.5                  minv=-0.1
+ voffl=0                   dvtp0=1.10431e-007        dvtp1=3.5
+ lpe0=3.77983e-008         lpeb=4.1935e-009          xj=1.1e-007
+ ngate=1.812e+020          ndep=6.3687e+017          nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-0.00012999806+dcitp  lcit=4.0734852e-010+dlcitp
+ wcit=3.8305183e-010+dwcitp                          pcit=-1.100318e-016+dpcitp
+ voff=-0.11734135+dvoffp   lvoff=-3.1031126e-009+dlvoffp
+ wvoff=-1.0274471e-008+dwvoffp                       pvoff=2.3925938e-015+dpvoffp
+ nfactor=0.52254+dnfactorp eta0=0.19395111+deta0p    weta0=-3.9574329e-008+dweta0p
+ etab=-0.31266109          letab=8.7696452e-009      wetab=1.476912e-007
+ petab=-4.0213308e-015     u0=0.0081272967+du0p      lu0=-5.4879768e-011+dlu0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=-2.5836543e-010+dwu0p pu0=5.5757844e-017+dpu0p
+ ua=-2.8713742e-010        lua=7.0658019e-018        wua=-2.9874999e-016
+ pua=-3.8341918e-024       ub=1.3341522e-018         lub=-4.880481e-026
+ wub=1.0472447e-025        pub=2.9745564e-032        uc=5.7359538e-011
+ luc=-1.6793179e-018       wuc=8.0795147e-019        puc=-2.3657195e-025
+ vsat=76565.113+dvsatp     lvsat=0.0028993829+dlvsatp
+ kvsat=1                   wvsat=0.0093925879+dwvsatp
+ pvsat=-2.0270144e-009+dpvsatp                       a0=2.9898354+da0p
+ la0=-1.6313268e-007+dla0p wa0=2.3461709e-007+dwa0p  pa0=-1.9234613e-014+dpa0p
+ ags=4.2224855+dagsp       wags=1.0531294e-007+dwagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.11067949          lketa=2.3047411e-009
+ wketa=-2.1771325e-008     pketa=4.6984696e-015      dwg=0
+ dwb=0                     pclm=2.4444577+dpclmp     lpclm=-1.1114817e-007
+ wpclm=-8.6301362e-007     ppclm=8.0022223e-014      pdiblc1=0
+ pdiblc2=0.00097802378     lpdiblc2=6.0344759e-010   wpdiblc2=5.7247338e-009
+ ppdiblc2=-7.4742419e-016  pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswp            rdw=110+drdswp            prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp                xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.23072588
+ lkt1=-7.9464265e-009      wkt1=1.2847325e-008       pkt1=-1.8823377e-015
+ kt1l=0                    kt2=-0.043763468          lkt2=-8.573255e-010
+ wkt2=-2.4807247e-008      pkt2=1.3293919e-015       ute=-1
+ lute=0+dlutep             ua1=1.9204408e-009        lua1=-7.758166e-018
+ wua1=-3.0425567e-016      pua1=3.4472905e-023       ub1=-2.4001647e-018
+ lub1=-1.3938985e-026      wub1=1.1539672e-025       pub1=2.7724504e-033
+ uc1=-9.1643267e-011       luc1=-6.8709721e-018      wuc1=6.7878865e-017
+ puc1=-7.3443395e-024      prt=0                     at=170459.52
+ lat=-0.0075817218+dlatp   wat=0.044716009           pat=-8.4954082e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsp             lags=0+dlagsp             wvth0=0+dwvthp
+ pvth0=0+dpvthp            lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp
+ pnfactor=0+dpnfactorp     leta0=0+dleta0p           peta0=0+dpeta0p
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp                rnoib=0
+ noic=noicp                em=3e+8                   ef=1.1 
+ lintnoi=-1e-8             minr=1e-3
 
 
     10: type=p 
+ lmin=6e-08                lmax=1e-007-(dxlp+dlmisp) wmin=1e-006-(dxwp+dwmisp)
+ wmax=1e-005-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=1.25625e-09
+ ll=0.0050965              wl=0                      lln=-0.9
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29872784+(dvthp+vthmisp)-0.00256504*ff_flag-0.00205203*sf_flag+0.00205203*fs_flag
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=1.1502081e-009+dlvthp+2.10289e-10*ff_flag+1.68231e-10*sf_flag-1.68231e-10*fs_flag
+ wvth0=1.4153925e-009+dwvthp+2.60608e-09*ff_flag+2.08486e-09*sf_flag-2.08486e-09*fs_flag
+ pvth0=-1.1603812e-016+dpvthp-2.13654e-16*ff_flag-1.70923e-16*sf_flag+1.70923e-16*fs_flag
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.016705963+dk2p
+ lk2=-3.0622338e-009+dlk2p wk2=-1.0726945e-009+dwk2p pk2=1.8236725e-017+dpk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00014675011+dcitp   lcit=3.8465988e-010+dlcitp
+ wcit=-6.6510802e-010+dwcitp                         pcit=-2.4100516e-017+dpcitp
+ voff=-0.13554627+dvoffp-0.00192378*ff_flag-0.00153902*sf_flag+0.00153902*fs_flag
+ lvoff=-1.6106189e-009+dlvoffp+1.57717e-10*ff_flag+1.26174e-10*sf_flag-1.26174e-10*fs_flag
+ wvoff=2.2613071e-008+dwvoffp+1.95456e-09*ff_flag+1.56365e-09*sf_flag-1.56365e-09*fs_flag
+ pvoff=-3.0362561e-016+dpvoffp-1.60241e-16*ff_flag-1.28192e-16*sf_flag+1.28192e-16*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.17100596+deta0p-0.0032063*ss_flag+0.00884754*ff_flag+0.00707803*sf_flag-0.00707803*fs_flag
+ leta0=1.8811126e-009+dleta0p+2.62862e-10*ss_flag-7.25347e-10*ff_flag-5.80278e-10*sf_flag+5.80278e-10*fs_flag
+ weta0=-6.7398703e-008+dweta0p+3.2576e-09*ss_flag-7.81824e-09*ff_flag-6.25459e-09*sf_flag+6.25459e-09*fs_flag
+ peta0=2.2811256e-015+dpeta0p-2.67067e-16*ss_flag+6.40962e-16*ff_flag+5.1277e-16*sf_flag-5.1277e-16*fs_flag
+ etab=-0.34775733          letab=1.164694e-008       wetab=1.8330063e-007
+ petab=-6.9406985e-015     u0=0.0074093674+du0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=3.9782258e-012+dlu0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ wu0=9.0777576e-010+dwu0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ pu0=-3.9845909e-017+dpu0p+0.0*ff_flag+0.0*sf_flag+0.0*fs_flag
+ ua=-3.1739587e-010        lua=9.5464802e-018        wua=-7.6376103e-016
+ pua=3.4288809e-023        ub=7.346529e-019          lub=3.4394381e-028
+ wub=1.2678476e-024        pub=-6.5610763e-032       uc=6.5388509e-011
+ luc=-2.3375571e-018       wuc=-1.0427362e-017       puc=6.8453272e-025
+ vsat=137687.82+dvsatp     lvsat=-0.0021116397+dlvsatp
+ kvsat=1                   wvsat=-0.023304207+dwvsatp
+ pvsat=6.5356692e-010+dpvsatp                        a0=-2.4572186+da0p
+ la0=2.8343315e-007+dla0p  ags=4.2224855+dagsp       wags=1.0531294e-007+dwagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.23693636          lketa=1.2655658e-008
+ wketa=6.0180664e-008      pketa=-2.0202003e-015     dwg=0
+ dwb=0                     pclm=1.6519048+dpclmp-0.119145*ff_flag-0.0953162*sf_flag+0.0953162*fs_flag
+ lpclm=-4.6172311e-008+9.76787e-09*ff_flag+7.8143e-09*sf_flag-7.8143e-09*fs_flag
+ wpclm=2.4337152e-007+3.90912e-08*ff_flag+3.1273e-08*sf_flag-3.1273e-08*fs_flag
+ ppclm=-1.0682549e-014-3.20481e-15*ff_flag-2.56385e-15*sf_flag+2.56385e-15*fs_flag
+ pdiblc1=0                 pdiblc2=0.0057736665      lpdiblc2=2.1028641e-010
+ wpdiblc2=-7.8604521e-010  ppdiblc2=-2.1365099e-016  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.27609462           lkt1=-4.2269617e-009      wkt1=-2.1886485e-008
+ pkt1=9.6524418e-016       kt1l=0                    kt2=-0.055277267
+ lkt2=8.661024e-011        wkt2=-9.2573803e-009      pkt2=5.4567146e-017
+ ute=-1                    lute=0+dlutep             ua1=1.3880396e-009
+ lua1=3.5889685e-017       wua1=3.7082419e-016       pua1=-2.0872167e-023
+ ub1=-2.2253259e-018       lub1=-2.8272798e-026      wub1=2.8202664e-025
+ pub1=-1.088837e-032       uc1=-2.292058e-010        luc1=4.4068173e-018
+ wuc1=-4.6717596e-017      puc1=2.0506222e-024       prt=0
+ at=157087.06              lat=-0.0064854075+dlatp   wat=-0.13928046
+ pat=6.589174e-009         jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             pa0=0+dpa0p               wa0=0+dwa0p
+ pags=0+dpagsp             lags=0+dlagsp             lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     11: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2.00001e-05          wmin=6e-007-(dxwp+dwmisp)
+ wmax=1e-006-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.0075845539+dk2p      wk2=-6.5739971e-009+dwk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0005+dcitp          voff=-0.12720039+dvoffp   wvoff=3.784351e-009+dwvoffp
+ nfactor=0.52254+dnfactorp eta0=0.1704+deta0p        weta0=-1.56464e-008+dweta0p
+ etab=-0.21992716          wetab=7.6125995e-008      u0=0.0074570933+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=4.74489e-10+dwu0p     ua=-6.2090777e-010
+ wua=9.0170516e-018        ub=1.3139675e-018         wub=-4.316122e-026
+ uc=4.1493108e-011         wuc=2.9016976e-018        vsat=90000+dvsatp
+ a0=3.4727979+da0p         wa0=-1.798276e-007+dwa0p  kvsat=1
+ ags=1.0401521+dagsp       wags=-1.1333583e-07+dwagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=0.0082485028         wketa=-6.6387361e-009
+ dwg=0                     dwb=0                     pclm=1.013+dpclmp
+ pdiblc1=0                 pdiblc2=0.00277           wpdiblc2=-7.8232e-010
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.060315            pditsd=0.95634
+ pditsl=0                  rsh=15.5                  rsw=110+drdswp
+ rdw=110+drdswp            prwg=0                    prwb=0
+ wr=1                      alpha0=1.49e-9            alpha1=0.00383
+ beta0=10.7                agidl=1e-008              bgidl=1.75963e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.014358
+ bigbacc=0.0069774         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0061361
+ bigc=0.00026197           cigc=-0.03984             aigsd=0.0049603
+ bigsd=0.000207349         cigsd=0.0042644           nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.079               noff=2.1891
+ voffcv=-0.080796          kt1=-0.22775579           wkt1=4.676396e-009
+ kt1l=0                    kt2=-0.026598118          wkt2=-1.0469491e-009
+ ute=-1                    ua1=1.808595e-009         wua1=-1.1617452e-016
+ lute=0+dlutep             ub1=-1.925686e-018        wub1=3.346765e-025
+ uc1=2e-010                prt=0                     at=180000
+ lat=0+dlatp               jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             pcit=0+dpcitp             lcit=0+dlcitp
+ wcit=0+dwcitp             pvoff=0+dpvoffp           lvoff=0+dlvoffp
+ pa0=0+dpa0p               la0=0+dla0p               pags=0+dpagsp
+ lags=0+dlagsp             lk2=0+dlk2p               pk2=0+dpk2p
+ lu0=0+dlu0p               pu0=0+dpu0p               lvth0=0+dlvthp
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp
+ rnoib=0                   noic=noicp                em=3e+8
+ ef=1.1                   lintnoi=-1e-8             minr=1e-3
 
 
     12: type=p 
+ lmin=1.000003e-006-(dxlp+dlmisp)                    lmax=1e-005-(dxlp+dlmisp)
+ wmin=6e-007-(dxwp+dwmisp) wmax=1e-006-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.0075066004+dk2p      lk2=7.7535709e-010+dlk2p
+ wk2=-6.5911081e-009+dwk2p pk2=1.7019314e-016+dpk2p  k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.00048345155+dcitp
+ lcit=1.6459766e-010+dlcitp                          wcit=1.0193844e-011+dwcitp
+ pcit=-1.0139216e-016+dpcitp                         voff=-0.12766923+dvoffp+0.000347227*ff_flag+0.000277782*sf_flag-0.000277782*fs_flag
+ lvoff=4.6632316e-009+dlvoffp-3.45366e-09*ff_flag-2.76293e-09*sf_flag+2.76293e-09*fs_flag
+ wvoff=4.3782661e-009+dwvoffp-2.13892e-10*ff_flag-1.71114e-10*sf_flag+1.71114e-10*fs_flag
+ pvoff=-5.9073235e-015+dpvoffp+2.12746e-15*ff_flag+1.70197e-15*sf_flag-1.70197e-15*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.1704+deta0p        weta0=-1.56464e-008+dweta0p
+ etab=-0.21992716          wetab=7.6125995e-008      u0=0.0075517205+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-9.412016e-10+dlu0p   wu0=3.8380823e-10+dwu0p
+ pu0=9.0194783e-16+dpu0p   ua=-5.9929141e-010        lua=-2.1500519e-016
+ wua=-1.6762598e-017       pua=2.5641496e-022        ub=1.2922715e-018
+ lub=2.1579806e-025        wub=-4.0283374e-026       pub=-2.8624241e-032
+ uc=4.6162171e-011         luc=-4.6440418e-017       wuc=5.5523463e-019
+ puc=2.3338883e-023        vsat=90000+dvsatp         a0=3.5803162+da0p
+ la0=-1.0694208e-006+dla0p kvsat=1                   wa0=-2.3703506e-007+dwa0p
+ pa0=5.6900894e-013+dpa0p  ags=0.99153878+dagsp      lags=4.8352768e-07+dlagsp
+ wags=-1.2358754e-07+dwagsp                          pags=1.0196775e-13+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=0.014402087          lketa=-6.1206067e-008
+ wketa=-7.1752269e-009     pketa=5.3361569e-015      dwg=0
+ dwb=0                     pclm=1.013+dpclmp         pdiblc1=0
+ pdiblc2=0.0025922852      lpdiblc2=1.7676239e-009   wpdiblc2=-1.0291185e-009
+ ppdiblc2=2.454759e-015    pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswp            rdw=110+drdswp            prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp                xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.22728628
+ lkt1=-4.6699235e-009      wkt1=5.2692587e-009       pkt1=-5.8968547e-015
+ kt1l=0                    kt2=-0.023368155          lkt2=-3.2126533e-008
+ wkt2=-1.8872405e-009      pkt2=8.357883e-015        ute=-1
+ lute=0+dlutep             ua1=1.872563e-009         lua1=-6.3625205e-016
+ wua1=-2.0604619e-016      pua1=8.9390048e-022       ub1=-2.001455e-018
+ lub1=7.5362929e-025       wub1=4.5062736e-025       pub1=-1.1532949e-030
+ uc1=2.2544575e-010        luc1=-2.5309385e-016      wuc1=-1.046804e-017
+ puc1=1.0411942e-022       prt=0                     at=180000
+ lat=0+dlatp               jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp            wvth0=0+dwvthp
+ pvth0=0+dpvthp            lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp
+ pnfactor=0+dpnfactorp     leta0=0+dleta0p           peta0=0+dpeta0p
+ lvsat=0+dlvsatp           wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp                rnoib=0
+ noic=noicp                em=3e+8                   ef=1.1 
+ lintnoi=-1e-8             minr=1e-3
 
 
     13: type=p 
+ lmin=2.39995e-007-(dxlp+dlmisp)                     lmax=1.000003e-006-(dxlp+dlmisp)
+ wmin=6e-007-(dxwp+dwmisp) wmax=1e-006-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=5.0965e-03             wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=5.0965e-03
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ k2=0.0074717323+dk2p      kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.330e-8          lk2=8.0835664e-010+dlk2p
+ wk2=-6.8320064e-009+dwk2p pk2=3.9818169e-016+dpk2p  k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0004125782+dcitp
+ lcit=2.3167291e-010+dlcitp                          wcit=-1.6958494e-010+dwcitp
+ pcit=6.8752286e-017+dpcitp                          voff=-0.11947208+dvoffp-0.00427737*ff_flag-0.0034219*sf_flag+0.0034219*fs_flag
+ lvoff=-3.0946325e-009+dlvoffp+9.23099e-10*ff_flag+7.38479e-10*sf_flag-7.38479e-10*fs_flag
+ wvoff=-3.2815812e-009+dwvoffp+2.63486e-09*ff_flag+2.10789e-09*sf_flag-2.10789e-09*fs_flag
+ pvoff=1.3420327e-015+dpvoffp-5.68629e-16*ff_flag-4.54903e-16*sf_flag+4.54903e-16*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.1704+deta0p        weta0=-1.56464e-008+dweta0p
+ etab=-0.21992716          wetab=7.6125995e-008      u0=0.006247559+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=2.9307004e-010+dlu0p  wu0=1.651448e-009+dwu0p
+ pu0=-2.9775916e-016+dpu0p ua=-8.3425443e-010        lua=7.3661505e-018
+ wua=2.5896627e-016        pua=-4.5375981e-024       ub=1.4315673e-018
+ lub=8.3967084e-026        wub=5.0863371e-026        pub=-1.1488643e-031
+ uc=-3.3319575e-011        luc=2.8781901e-017        wuc=4.78957e-017
+ puc=-2.1464607e-023       vsat=90000+dvsatp         a0=2.1759005+da0p
+ la0=2.5973223e-007+dla0p  kvsat=1                   wa0=7.7257521e-007+dwa0p
+ pa0=-3.8649632e-013+dpa0p ags=0.13865539+dagsp      lags=1.290705e-006+dlagsp
+ wags=5.1765575e-007+dwagsp                          pags=-5.0491131e-013+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.035580054         lketa=-1.3902468e-008
+ wketa=-1.9908973e-009     pketa=4.2965554e-016      dwg=0
+ dwb=0                     pclm=1.0487735+dpclmp     lpclm=-3.3856392e-008
+ wpclm=-1.6598502e-007     ppclm=1.5708988e-013      pdiblc1=0
+ pdiblc2=0.00446           wpdiblc2=1.56464e-009     pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.23002689           lkt1=-2.0761888e-009      wkt1=5.9091243e-009
+ pkt1=-6.50243e-015        kt1l=0                    kt2=-0.052456745
+ lkt2=-4.5968009e-009      wkt2=6.6939766e-009       pkt2=2.365333e-016
+ ute=-1                    ua1=9.5391841e-010        lua1=2.3316238e-016
+ lute=0+dlutep             wua1=1.0442616e-015       pua1=-2.8940333e-022
+ ub1=-6.2663128e-019       lub1=-5.4751761e-025      wub1=-1.2424562e-024
+ pub1=4.4905639e-031       uc1=-2.4073635e-012       luc1=-3.745139e-017
+ wuc1=1.0320858e-016       puc1=-3.4652688e-024      prt=0
+ at=196454.83              lat=-0.01557302+dlatp     wat=-0.0048920114
+ pat=4.6298485e-009        jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp            wvth0=0+dwvthp
+ pvth0=0+dpvthp            lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp
+ pnfactor=0+dpnfactorp     leta0=0+dleta0p           peta0=0+dpeta0p
+ lvsat=0+dlvsatp           wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp                rnoib=0
+ noic=noicp                em=3e+8                   ef=1.1 
+ lintnoi=-1e-8             minr=1e-3
 
 
     14: type=p 
+ lmin=1e-007-(dxlp+dlmisp) lmax=2.39995e-007-(dxlp+dlmisp)
+ wmin=6e-007-(dxwp+dwmisp) wmax=1e-006-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29576369+(dvthp+vthmisp)                    lvth0=9.0719854e-010+dlvthp
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k1=0.22699184             lk1=3.5259378e-009
+ k2=0.03091297+dk2p        lk2=-4.2504968e-009+dlk2p wk2=-7.6997473e-009+dwk2p
+ pk2=5.8544885e-016+dpk2p  k3=-2.39941               k3b=1.88101
+ w0=0                      dvt0=1.44595              dvt1=0.91219
+ dvt2=0.16184              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.5                  minv=-0.1
+ voffl=0                   dvtp0=1.10431e-007        dvtp1=3.5
+ lpe0=3.77983e-008         lpeb=4.1935e-009          xj=1.1e-007
+ ngate=1.812e+020          ndep=6.3687e+017          nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-8.6885462e-005+dcitp lcit=3.3946216e-010+dlcitp
+ wcit=3.3924943e-010+dwcitp                          pcit=-4.105926e-017+dpcitp
+ voff=-0.13057397+dvoffp   lvoff=-6.9873453e-010+dlvoffp
+ wvoff=3.169867e-009+dwvoffp                         pvoff=-5.0254392e-017+dpvoffp
+ nfactor=0.52254+dnfactorp eta0=0.1704+deta0p        weta0=-1.56464e-008+dweta0p
+ etab=-0.27655807          letab=1.2221516e-008      wetab=1.1101053e-007
+ petab=-7.5284313e-015     u0=0.0076055944+du0p      lu0=-7.5738254e-015+dlu0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=2.7168411e-010+dwu0p  pu0=7.6950066e-021+dpu0p
+ ua=-7.9656463e-010        lua=-7.6768419e-019       wua=2.1882806e-016
+ pua=4.1246301e-024        ub=1.9380097e-018         lub=-2.5328244e-026
+ wub=-5.0879468e-025       pub=5.8933735e-033        uc=1.3013354e-010
+ luc=-6.4929155e-018       wuc=-7.3130435e-017       puc=4.6540432e-024
+ vsat=79356.857+dvsatp     lvsat=0.0022968966+dlvsatp
+ kvsat=1                   wvsat=0.0065561759+dwvsatp
+ pvsat=-1.4148883e-009+dpvsatp                       a0=4.971014+da0p
+ la0=-3.4348122e-007+dla0p wa0=-1.7782604e-006+dwa0p pa0=1.6399951e-013+dpa0p
+ ags=6.1193988+dagsp       lags=7.8995813e-013+dlagsp
+ wags=-1.8219509e-006+dwagsp                         pags=-8.0259746e-019+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.12546103          lketa=5.4947443e-009
+ wketa=-6.7532846e-009     pketa=1.4574264e-015      dwg=0
+ dwb=0                     pclm=0.61031361+dpclmp    lpclm=6.0767635e-008
+ wpclm=1.0004768e-006      ppclm=-9.4644237e-014     pdiblc1=0
+ pdiblc2=0.006016015       lpdiblc2=-3.358036e-010   wpdiblc2=6.0613476e-010
+ ppdiblc2=2.0685502e-016   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswp            rdw=110+drdswp            prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp                xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.16893655
+ lkt1=-1.5260094e-008      wkt1=-4.9930633e-008      pkt1=5.548348e-015
+ kt1l=0                    kt2=-0.076688374          lkt2=6.3262708e-010
+ wkt2=8.6444572e-009       pkt2=-1.8439993e-016      ute=-1
+ lute=0+dlutep             ua1=2.1379915e-009        lua1=-2.2372423e-017
+ wua1=-5.2528714e-016      pua1=4.932099e-023        ub1=-3.8122845e-018
+ lub1=1.3997821e-025       wub1=1.5501104e-024       pub1=-1.5360742e-031
+ uc1=-5.2955612e-011       luc1=-2.6542572e-017      wuc1=2.8572208e-017
+ puc1=1.2642006e-023       prt=0                     at=184411.39
+ lat=-0.012973923+dlatp    wat=0.030540915           pat=-3.0169314e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp
+ rnoib=0                   noic=noicp                em=3e+8
+ ef=1.1                   lintnoi=-1e-8             minr=1e-3
 
 
     15: type=p 
+ lmin=6e-08                lmax=1e-007-(dxlp+dlmisp) wmin=6e-007-(dxwp+dwmisp)
+ wmax=1e-006-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=1.25625e-09
+ ll=0.0050965              wl=0                      lln=-0.9
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29540698+(dvthp+vthmisp)-0.0159726*ss_flag-0.00177473*ff_flag-0.00141979*sf_flag+0.00141979*fs_flag
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=8.7795407e-010+dlvthp+1.30948e-09*ss_flag+1.45498e-10*ff_flag+1.16398e-10*sf_flag-1.16398e-10*fs_flag
+ wvth0=-1.9586003e-009+dwvthp+1.62282e-08*ss_flag+1.80313e-09*ff_flag+1.4425e-09*sf_flag-1.4425e-09*fs_flag
+ pvth0=1.6057193e-016+dpvthp-1.33043e-15*ss_flag-1.47826e-16*ff_flag-1.18261e-16*sf_flag+1.18261e-16*fs_flag
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.016174181+dk2p
+ lk2=-3.0421667e-009+dlk2p wk2=-5.324044e-010+dwk2p  pk2=-2.1514249e-018+dpk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.00062909018+dcitp  lcit=3.8391373e-010+dlcitp
+ wcit=1.2314572e-010+dwcitp                          pcit=-2.334243e-017+dpcitp
+ voff=-0.10938425+dvoffp-0.00354947*ff_flag-0.00283957*sf_flag+0.00283957*fs_flag
+ lvoff=-2.4359313e-009+dlvoffp+2.90995e-10*ff_flag+2.32796e-10*sf_flag-2.32796e-10*fs_flag
+ wvoff=-3.9675416e-009+dwvoffp+3.60626e-09*ff_flag+2.88501e-09*sf_flag-2.88501e-09*fs_flag
+ pvoff=5.3489177e-016+dpvoffp-2.95651e-16*ff_flag-2.36521e-16*sf_flag+2.36521e-16*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.10118848+deta0p-0.0053242*ss_flag+0.00292716*ff_flag+0.00234173*sf_flag-0.00234173*fs_flag
+ leta0=5.6741682e-009+dleta0p+4.36493e-10*ss_flag-2.39977e-10*ff_flag-1.91981e-10*sf_flag+1.91981e-10*fs_flag
+ weta0=3.5358559e-009+dweta0p+5.40939e-09*ss_flag-1.80313e-09*ff_flag-1.4425e-09*sf_flag+1.4425e-09*fs_flag
+ peta0=-1.5726189e-015+dpeta0p-4.43477e-16*ss_flag+1.47826e-16*ff_flag+1.18261e-16*sf_flag-1.18261e-16*fs_flag
+ etab=-0.19164554          letab=5.260132e-009       wetab=2.4691051e-008
+ petab=-4.5170152e-016     u0=0.007993289+du0p+0.000354947*ss_flag
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-3.1791941e-011+dlu0p-2.90995e-11*ss_flag
+ wu0=3.1451146e-010+dwu0p-3.60626e-10*ss_flag        pu0=-3.5034197e-018+dpu0p+2.95651e-17*ss_flag
+ ua=-1.6703285e-009        lua=7.0866099e-017        wua=6.1081852e-016
+ pua=-2.8011924e-023       ub=2.901488e-018          lub=-1.0431709e-025
+ wub=-9.3365687e-025       pub=4.072485e-032         uc=7.905756e-011
+ luc=-2.3055534e-018       wuc=-2.4315118e-017       puc=6.5201705e-025
+ vsat=142324.79+dvsatp     lvsat=-0.0028654031+dlvsatp
+ kvsat=1                   wvsat=-0.028015368+dwvsatp
+ pvsat=1.4193905e-009+dpvsatp                        a0=-2.9278421+da0p
+ la0=3.040907e-007+dla0p   wa0=4.7815343e-007+dwa0p  pa0=-2.0988067e-014+dpa0p
+ ags=6.1194084+dagsp       wags=-1.8219607e-006+dwagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.19346001          lketa=1.1069505e-008
+ wketa=1.6008697e-008      pketa=-4.0866915e-016     dwg=0
+ dwb=0                     pclm=2.2176108+dpclmp-0.08067*ff_flag-0.0645358*sf_flag+0.0645358*fs_flag
+ lpclm=-7.1003406e-008+6.61357e-09*ff_flag+5.29083e-09*sf_flag-5.29083e-09*fs_flag
+ wpclm=-3.313857e-007-1e-14*ff_flag+1.9e-13*sf_flag-1.9e-13*fs_flag
+ ppclm=1.4545844e-014+1e-21*ff_flag+1e-21*sf_flag-1e-21*fs_flag
+ pdiblc1=0                 pdiblc2=0.0036947056      lpdiblc2=-1.4549569e-010
+ wpdiblc2=1.3261792e-009   ppdiblc2=1.4782362e-016   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.32553899           lkt1=-2.4213564e-009      wkt1=2.8348995e-008
+ pkt1=-8.6925076e-016      kt1l=0                    kt2=-0.070439129
+ lkt2=1.2029518e-010       wkt2=6.1470714e-009       pkt2=2.034325e-017
+ ute=-1                    lute=0+dlutep             ua1=1.5842866e-009
+ lua1=2.302196e-017        wua1=1.7143716e-016       pua1=-7.7985591e-024
+ ub1=-1.3227127e-018       lub1=-6.4124354e-026      wub1=-6.3502833e-025
+ pub1=2.5536811e-032       uc1=-7.3502816e-010       luc1=2.9375781e-017
+ wuc1=4.6719792e-016       puc1=-2.3317845e-023      prt=0
+ at=26160                  wat=-0.00625856           lat=0+dlatp
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsp             lags=0+dlagsp             lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     16: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2.00001e-05          wmin=3e-007-(dxwp+dwmisp)
+ wmax=6e-007-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.0016724762+dk2p      wk2=-2.9321573e-009+dwk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0005+dcitp          voff=-0.12100081+dvoffp   wvoff=-3.4593615e-011+dwvoffp
+ nfactor=0.52254+dnfactorp eta0=0.1608+deta0p        weta0=-9.7328e-009+dweta0p
+ etab=0.00154448           wetab=-6.0300536e-008     u0=0.0081220001+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=6.490636e-11+dwu0p    ua=-4.2144557e-010
+ wua=-1.1385167e-016       ub=1.1992203e-018         wub=2.752308e-026
+ uc=4.0104879e-011         wuc=3.7568467e-018        vsat=90000+dvsatp
+ a0=2.5851249+da0p         wa0=3.6697899e-007+dwa0p  kvsat=1
+ ags=0.9001539+dagsp       wags=-2.709691e-08+dwagsp a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.0056834926         wketa=-5.0586899e-009     dwg=0
+ dwb=0                     pclm=1.013+dpclmp         pdiblc1=0
+ pdiblc2=0.00097333333     wpdiblc2=3.2442667e-010   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.22016424           kt1l=0                    kt2=-0.021920789
+ wkt2=-3.9281833e-009      ute=-1                    lute=0+dlutep
+ ua1=1.573785e-009         wua1=2.846844e-017        ub1=-1.4406293e-018
+ wub1=3.5881589e-026       uc1=2e-010                prt=0
+ at=180000                 lat=0+dlatp               jss=1.73e-07
+ jsd=1.73e-07              jsws=1.86e-13             jswd=1.86e-13
+ jswgs=1.86e-13            jswgd=1.86e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.59
+ bvd=9.59                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp
+ cjd=cjp                   mjs=0.31                  mjd=0.31
+ pbsws=0.96                pbswd=0.96                cjsws=cjswp
+ cjswd=cjswp               mjsws=0.063               mjswd=0.063
+ pbswgs=0.42               pbswgd=0.42               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.98               mjswgd=0.98
+ tpb=0.00155               tcj=0.00085               tpbsw=0.003
+ tcjsw=0.0002              tpbswg=0.0004             tcjswg=0.0024
+ xtis=3                    xtid=3                    jtsswgs=jtsswgp
+ jtsswgd=jtsswgp           njtsswg=6.62              xtsswgs=0.3645
+ xtsswgd=0.3645            tnjtsswg=0.565            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             pcit=0+dpcitp
+ lcit=0+dlcitp             wcit=0+dwcitp             pvoff=0+dpvoffp
+ lvoff=0+dlvoffp           pa0=0+dpa0p               la0=0+dla0p
+ pags=0+dpagsp             lags=0+dlagsp             lk2=0+dlk2p
+ pk2=0+dpk2p               lu0=0+dlu0p               pu0=0+dpu0p
+ lvth0=0+dlvthp            wvth0=0+dwvthp            pvth0=0+dpvthp
+ lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp
+ leta0=0+dleta0p           peta0=0+dpeta0p           lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     17: type=p 
+ lmin=1.000003e-006-(dxlp+dlmisp)                    lmax=1e-005-(dxlp+dlmisp)
+ wmin=3e-007-(dxwp+dwmisp) wmax=6e-007-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=0.0018357189+dk2p      lk2=-1.6236787e-009+dlk2p
+ wk2=-3.0978451e-009+dwk2p pk2=1.6479992e-015+dpk2p  k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0005+dcitp
+ voff=-0.12018988+dvoffp   lvoff=-8.0658778e-009+dlvoffp
+ wvoff=-2.2901632e-010+dwvoffp                       pvoff=1.9338079e-015+dpvoffp
+ nfactor=0.52254+dnfactorp eta0=0.1608+deta0p        weta0=-9.7328e-009+dweta0p
+ etab=0.00154448           wetab=-6.0300536e-008     u0=0.0080583383+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=6.3320649e-10+dlu0p   wu0=7.173169e-11+dwu0p
+ pu0=-6.788757e-17+dpu0p   ua=-4.3979279e-010        lua=1.8248899e-016
+ wua=-1.1501375e-016       pua=1.1558548e-023        ub=1.1792189e-018
+ lub=1.9894221e-025        wub=2.9357011e-026        pub=-1.8241032e-032
+ uc=3.9697292e-011         luc=4.0540258e-018        wuc=4.5376001e-018
+ puc=-7.7656943e-024       vsat=90000+dvsatp         a0=2.5217924+da0p
+ la0=6.2993067e-007+dla0p  kvsat=1                   wa0=4.1501557e-007+dwa0p
+ pa0=-4.7779159e-013+dpa0p ags=0.85005705+dagsp      lags=4.9828308e-07+dlagsp
+ wags=-3.64348e-08+dwagsp  pags=9.287841e-14+dpagsp  a1=0
+ a2=0.8                    b0=0                      b1=0
+ keta=0.011864644          lketa=-6.1480262e-008     wketa=-5.612162e-009
+ pketa=5.5050612e-015      dwg=0                     dwb=0
+ pclm=1.013+dpclmp         pdiblc1=0                 pdiblc2=0.00011805911
+ lpdiblc2=8.5069081e-009   wpdiblc2=4.950048e-010    ppdiblc2=-1.6966401e-015
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.060315            pditsd=0.95634
+ pditsl=0                  rsh=15.5                  rsw=110+drdswp
+ rdw=110+drdswp            prwg=0                    prwb=0
+ wr=1                      alpha0=1.49e-9            alpha1=0.00383
+ beta0=10.7                agidl=1e-008              bgidl=1.75963e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.014358
+ bigbacc=0.0069774         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0061361
+ bigc=0.00026197           cigc=-0.03984             aigsd=0.0049603
+ bigsd=0.000207349         cigsd=0.0042644           nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.079               noff=2.1891
+ voffcv=-0.080796          kt1=-0.21836987           lkt1=-1.7847514e-008
+ wkt1=-2.2325048e-010      pkt1=2.2205408e-015       kt1l=0
+ kt2=-0.0191872            lkt2=-2.7189402e-008      wkt2=-4.4627089e-009
+ pkt2=5.3166102e-015       ute=-1                    lute=0+dlutep
+ ua1=1.4831799e-009        lua1=9.011956e-016        wua1=3.3813813e-017
+ pua1=-5.316727e-023       ub1=-1.3478704e-018       lub1=-9.2261867e-025
+ wub1=4.8019247e-026       pub1=-1.2072612e-031      uc1=2.0026696e-010
+ luc1=-2.6553282e-018      wuc1=5.0420918e-018       puc1=-5.0150712e-023
+ prt=0                     at=180000                 lat=0+dlatp
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pcit=0+dpcitp             lcit=0+dlcitp             wcit=0+dwcitp
+ lvth0=0+dlvthp            wvth0=0+dwvthp            pvth0=0+dpvthp
+ lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp
+ leta0=0+dleta0p           peta0=0+dpeta0p           lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     18: type=p 
+ lmin=2.39995e-007-(dxlp+dlmisp)                     lmax=1.000003e-006-(dxlp+dlmisp)
+ wmin=3e-007-(dxwp+dwmisp) wmax=6e-007-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=5.0965e-03             wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=5.0965e-03
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ k2=-0.0022465804+dk2p     kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.330e-8          lk2=2.2398502e-009+dlk2p
+ wk2=-8.4552582e-010+dwk2p pk2=-4.8361835e-016+dpk2p k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=5.5701571e-005+dcitp
+ lcit=4.2048848e-010+dlcitp                          wcit=5.0251059e-011+dwcitp
+ pcit=-4.7558105e-017+dpcitp                         voff=-0.12730697+dvoffp
+ lvoff=-1.330193e-009+dlvoffp                        wvoff=1.5447075e-009+dwvoffp
+ pvoff=2.5513797e-016+dpvoffp                        nfactor=0.52254+dnfactorp
+ eta0=0.1608+deta0p        weta0=-9.7328e-009+dweta0p
+ etab=0.00154448           wetab=-6.0300536e-008     u0=0.0090533921+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-3.0852217e-010+dlu0p wu0=-7.6945132e-011+dwu0p
+ pu0=7.2821643e-017+dpu0p  ua=-2.3627045e-010        lua=-1.0126595e-017
+ wua=-1.0939186e-016       pua=6.2379329e-024        ub=1.5465185e-018
+ lub=-1.4867382e-025       wub=-1.9946565e-026       pub=2.8420365e-032
+ uc=5.6589438e-011         luc=-1.193287e-017        wuc=-7.488252e-018
+ puc=3.6156924e-024        vsat=90000+dvsatp         a0=3.3930098+da0p
+ la0=-1.9459819e-007+dla0p kvsat=1                   wa0=2.2835847e-008+dwa0p
+ pa0=-1.0662878e-013+dpa0p ags=1.1928491+dagsp       lags=1.7386125e-007+dlagsp
+ wags=-1.3172756e-007+dwagsp                         pags=1.8306445e-013+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.039242327         lketa=-1.3112113e-008
+ wketa=2.650629e-010       pketa=-5.7203224e-017     dwg=0
+ dwb=0                     pclm=0.78947575+dpclmp    lpclm=2.1154559e-007
+ wpclm=-6.2576075e-009     ppclm=5.9222623e-015      pdiblc1=0
+ pdiblc2=0.0091066667      wpdiblc2=-1.2977067e-009  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.21802429           lkt1=-1.8174572e-008      wkt1=-1.4844726e-009
+ pkt1=3.414174e-015        kt1l=0                    kt2=-0.040894388
+ lkt2=-6.6455023e-009      wkt2=-4.2843527e-010      pkt2=1.4985334e-015
+ ute=-1                    ua1=2.8909535e-009        lua1=-4.3113543e-016
+ lute=0+dlutep             wua1=-1.48952e-016        pua1=1.1980412e-022
+ ub1=-2.7937227e-018       lub1=4.4575042e-025       wub1=9.2472067e-026
+ pub1=-1.6279671e-031      uc1=2.5672711e-010        luc1=-5.6089777e-017
+ wuc1=-5.6418258e-017      puc1=8.0159777e-024       prt=0
+ at=161754.96              lat=0.017267284+dlatp     wat=0.016483108
+ pat=-1.5599779e-008       jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             lvth0=0+dlvthp            wvth0=0+dwvthp
+ pvth0=0+dpvthp            lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp
+ pnfactor=0+dpnfactorp     leta0=0+dleta0p           peta0=0+dpeta0p
+ lvsat=0+dlvsatp           wvsat=0+dwvsatp           pvsat=0+dpvsatp
+ saref=0.405e-6            sbref=0.405e-6            wlod=0
+ llodvth=1                 wlodvth=1                 stk2=0
+ lodk2=1                   lodeta0=1                 llodku0=1
+ wlodku0=1                 steta0=0                  tku0=0
+ wec=-3510                 web=-310                  scref=1e-6
+ wpemod=1                  kvth0we=-0.0039           pkvth0we=0.55e-17
+ wkvth0we=1.5e-11          lkvth0we=1.5e-11          ku0we=-0.0108
+ pku0we=-0.3e-17           wku0we=-4.5e-10           lku0we=-0.15e-10
+ k2we=0.00060              wk2we=3.2e-10             lk2we=4e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=1                 noia=noiap                rnoia=rnoiax
+ tnoia=tnoiax              noib=noibp                rnoib=0
+ noic=noicp                em=3e+8                   ef=1.1 
+ lintnoi=-1e-8             minr=1e-3
 
 
     19: type=p 
+ lmin=1e-007-(dxlp+dlmisp) lmax=2.39995e-007-(dxlp+dlmisp)
+ wmin=3e-007-(dxwp+dwmisp) wmax=6e-007-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29576369+(dvthp+vthmisp)                    lvth0=9.0719854e-010+dlvthp
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k1=0.22699184             lk1=3.5259378e-009
+ k2=0.026889145+dk2p       lk2=-4.0479306e-009+dlk2p wk2=-5.2210711e-009+dwk2p
+ pk2=4.6066807e-016+dpk2p  k3=-2.39941               k3b=1.88101
+ w0=0                      dvt0=1.44595              dvt1=0.91219
+ dvt2=0.16184              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.5                  minv=-0.1
+ voffl=0                   dvtp0=1.10431e-007        dvtp1=3.5
+ lpe0=3.77983e-008         lpeb=4.1935e-009          xj=1.1e-007
+ ngate=1.812e+020          ndep=6.3687e+017          nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=0.0012332077+dcitp    lcit=1.6637089e-010+dlcitp
+ wcit=-4.7392794e-010+dwcitp                         pcit=6.5564964e-017+dpcitp
+ voff=-0.13190294+dvoffp   lvoff=-3.3833675e-010+dlvoffp
+ wvoff=3.9885118e-009+dwvoffp                        pvoff=-2.7225943e-016+dpvoffp
+ nfactor=0.52254+dnfactorp eta0=0.1608+deta0p        weta0=-9.7328e-009+dweta0p
+ etab=0.013759218          letab=-2.6360627e-009     wetab=-6.7824919e-008
+ petab=1.6238371e-015      u0=0.0072003635+du0p      lu0=9.1379936e-011+dlu0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=5.2130635e-010+dwu0p  pu0=-5.6287011e-017+dpu0p
+ ua=-3.1026811e-010        lua=5.842842e-018         wua=-8.0730594e-017
+ pua=5.254592e-026         ub=7.9129894e-019         lub=1.4310112e-026
+ wub=1.9757913e-025        pub=-1.8523854e-032       uc=-1.7951932e-011
+ luc=4.1539028e-018        wuc=1.8090216e-017        puc=-1.9043968e-024
+ vsat=90000+dvsatp         a0=3.4898988+da0p         la0=-2.1550781e-007+dla0p
+ kvsat=1                   wa0=-8.6589342e-007+dwa0p pa0=8.5167885e-014+dpa0p
+ ags=1.9984758+dagsp       lags=-1.0532775e-012+dlagsp
+ wags=7.1653765e-007+dwagsp                          pags=3.3283569e-019+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.13036042          lketa=6.552083e-009
+ wketa=-3.7352568e-009     pketa=8.0610576e-016      dwg=0
+ dwb=0                     pclm=2.1769738+dpclmp     lpclm=-8.7890376e-008
+ wpclm=3.5414071e-008      ppclm=-3.0709025e-015     pdiblc1=0
+ pdiblc2=0.01039722        lpdiblc2=-2.7851427e-010  wpdiblc2=-2.0926874e-009
+ ppdiblc2=1.7156479e-016   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswp            rdw=110+drdswp            prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp                xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.29134227
+ lkt1=-2.3518199e-009      wkt1=2.5471288e-008       pkt1=-2.4031486e-015
+ kt1l=0                    kt2=-0.078121559          lkt2=1.3884935e-009
+ wkt2=9.527299e-009        pkt2=-6.5001366e-016      ute=-1
+ lute=0+dlutep             ua1=3.2227621e-010        lua1=1.2321082e-016
+ wua1=5.9319346e-016       pua1=-4.0358288e-023      ub1=2.8228004e-019
+ lub1=-2.1808173e-025      wub1=-9.7214134e-025      pub1=6.6957505e-032
+ uc1=2.4656826e-011        luc1=-6.0066889e-018      wuc1=-1.9237054e-017
+ puc1=-8.0978581e-027      prt=0                     at=378781.44
+ lat=-0.0295692+dlatp      wat=-0.089191039          pat=7.205759e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp
+ rnoib=0                   noic=noicp                em=3e+8
+ ef=1.1                   lintnoi=-1e-8             minr=1e-3
 
 
     20: type=p 
+ lmin=6e-08                lmax=1e-007-(dxlp+dlmisp) wmin=3e-007-(dxwp+dwmisp)
+ wmax=6e-007-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=1.25625e-09
+ ll=0.0050965              wl=0                      lln=-0.9
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29990507+(dvthp+vthmisp)+0.0103718*ss_flag-0.00370312*ff_flag-0.0029625*sf_flag+0.0029625*fs_flag
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=1.2467216e-009+dlvthp-8.50309e-10*ss_flag+3.03593e-10*ff_flag+2.42874e-10*sf_flag-2.42874e-10*fs_flag
+ wvth0=8.1222793e-010+dwvthp-3.6e-15*ss_flag+2.99102e-09*ff_flag+2.39282e-09*sf_flag-2.39282e-09*fs_flag
+ pvth0=-6.6588882e-017+dpvthp-4e-22*ss_flag-2.45212e-16*ff_flag-1.9617e-16*sf_flag+1.9617e-16*fs_flag
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.01517714+dk2p
+ lk2=-3.0877453e-009+dlk2p wk2=8.1772999e-011+dwk2p  pk2=2.5925006e-017+dpk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=-0.001672082+dcitp    lcit=4.0455525e-010+dlcitp
+ wcit=7.6562867e-010+dwcitp                          pcit=-3.6057605e-017+dpcitp
+ voff=-0.10703117+dvoffp+0.00230485*ff_flag+0.00184388*sf_flag-0.00184388*fs_flag
+ lvoff=-2.3773985e-009+dlvoffp-1.88958e-10*ff_flag-1.51166e-10*sf_flag+1.51166e-10*fs_flag
+ wvoff=-5.417036e-009+dwvoffp+1.9e-15*ff_flag+3.5e-15*sf_flag-3.5e-15*fs_flag
+ pvoff=4.988356e-016+dpvoffp+9e-23*ff_flag-2.9e-23*sf_flag+2.9e-23*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.13316451+deta0p+0.0192378*ss_flag+0.0267055*ff_flag+0.0213644*sf_flag-0.0213644*fs_flag
+ leta0=2.2656402e-009+dleta0p-1.57717e-09*ss_flag-2.1894e-09*ff_flag-1.75152e-09*sf_flag+1.75152e-09*fs_flag
+ weta0=-1.6161381e-008+dweta0p-9.7208e-09*ss_flag-1.64506e-08*ff_flag-1.31605e-08*sf_flag+1.31605e-08*fs_flag
+ peta0=5.2703436e-016+dpeta0p+7.96939e-16*ss_flag+1.34867e-15*ff_flag+1.07893e-15*sf_flag-1.07893e-15*fs_flag
+ etab=0.0083317143         letab=-2.1910996e-009     wetab=-9.8494937e-008
+ petab=4.1382572e-015      u0=0.0088992355+du0p-0.000473262*ss_flag-0.000242777*ff_flag-0.000194222*sf_flag+0.000194222*fs_flag
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-4.7898691e-011+dlu0p+3.87994e-11*ss_flag+1.99036e-11*ff_flag+1.59229e-11*sf_flag-1.59229e-11*fs_flag
+ wu0=-2.435516e-010+dwu0p+1.49551e-10*ss_flag+1.49551e-10*ff_flag+1.19641e-10*sf_flag-1.19641e-10*fs_flag
+ pu0=6.4183385e-018+dpu0p-1.22606e-17*ss_flag-1.22606e-17*ff_flag-9.80849e-18*sf_flag+9.80849e-18*fs_flag
+ ua=-4.0733745e-010        lua=1.3800877e-017        wua=-1.6718396e-016
+ pua=7.1402524e-024        ub=1.3795278e-018         lub=-3.3914654e-026
+ wub=3.8706478e-027        pub=-2.6430519e-033       uc=3.3198775e-011
+ luc=-3.9585723e-020       wuc=3.9338937e-018        puc=-7.4381906e-025
+ vsat=94441.834+dvsatp     lvsat=-0.00036415492+dlvsatp
+ kvsat=1                   wvsat=0.0014805304+dwvsatp
+ pvsat=-1.2137832e-010+dpvsatp                       a0=-2.7559514+da0p
+ la0=2.9654573e-007+dla0p  wa0=3.7226877e-007+dwa0p  pa0=-1.6340365e-014+dpa0p
+ ags=1.9984629+dagsp       wags=7.1654171e-007+dwagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.16006209          lketa=8.9871146e-009
+ wketa=-4.5644227e-009     pketa=8.7408328e-016      dwg=0
+ dwb=0                     pclm=1.6867881+dpclmp-0.165642*ff_flag-0.132513*sf_flag+0.132513*fs_flag
+ lpclm=-4.7703476e-008+1.35798e-08*ff_flag+1.08638e-08*sf_flag-1.08638e-08*fs_flag
+ wpclm=-4.3989281e-009+5.23428e-08*ff_flag+4.18742e-08*sf_flag-4.18742e-08*fs_flag
+ ppclm=1.9308655e-016-4.29121e-15*ff_flag-3.43297e-15*sf_flag+3.43297e-15*fs_flag
+ pdiblc1=0                 pdiblc2=0.0070614617      lpdiblc2=-5.0388116e-012
+ wpdiblc2=-7.4774261e-010  ppdiblc2=6.1302182e-017   pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.24434121           lkt1=-6.2051076e-009      wkt1=-2.1668834e-008
+ pkt1=1.46154e-015         kt1l=0                    kt2=-0.057021092
+ lkt2=-3.4138603e-010      wkt2=-2.118439e-009       pkt2=3.0473887e-016
+ ute=-1                    lute=0+dlutep             ua1=9.6867314e-010
+ lua1=7.021726e-017        wua1=5.5065508e-016       pua1=-3.6870864e-023
+ ub1=-6.888145e-019        lub1=-1.3846849e-025      wub1=-1.0255096e-024
+ pub1=7.1332797e-032       uc1=3.2467131e-010        luc1=-3.0602776e-017
+ wuc1=-1.8557696e-016      puc1=1.3628946e-023       prt=0
+ at=18106.667              wat=-0.0012977067         lat=0+dlatp
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsp             lags=0+dlagsp             lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     21: type=p 
+ lmin=1e-005-(dxlp+dlmisp) lmax=2.00001e-05          wmin=1.2e-07
+ wmax=3e-007-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=2.134663e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=-0.0065697142+dk2p     wk2=-3.2762511e-010+dwk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0005+dcitp          voff=-0.12232237+dvoffp   wvoff=3.8302073e-010+dwvoffp
+ nfactor=0.52254+dnfactorp eta0=0.13755556+deta0p    weta0=-2.3875556e-009+dweta0p
+ etab=-0.17923867          wetab=-3.1730613e-009     u0=0.0083274+du0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           ua=-5.2982568e-010        wua=-7.9603551e-017
+ ub=1.2078705e-018         wub=2.478961e-026         uc=5.1993634e-011
+ vsat=90000+dvsatp         kvsat=1                   a0=3.579304+da0p
+ wa0=5.2818385e-008+dwa0p  ags=0.91045797+dagsp      wags=-3.0353001e-08+dwagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.01032502          dwg=0
+ dwb=0                     pclm=1.013+dpclmp         pdiblc1=0
+ pdiblc2=0.0027555556      wpdiblc2=-2.3875556e-010  pdiblcb=0
+ drout=0.5                 pvag=0.74                 delta=0.01
+ pscbe1=1e+009             pscbe2=8e-011             fprout=0
+ pdits=0.060315            pditsd=0.95634            pditsl=0
+ rsh=15.5                  rsw=110+drdswp            rdw=110+drdswp
+ prwg=0                    prwb=0                    wr=1
+ alpha0=1.49e-9            alpha1=0.00383            beta0=10.7
+ agidl=1e-008              bgidl=1.75963e+009        cgidl=0.225
+ egidl=0.8                 aigbacc=0.014358          bigbacc=0.0069774
+ cigbacc=0                 nigbacc=5.82              aigbinv=0.008002
+ bigbinv=1e-005            cigbinv=0.006             eigbinv=1.1
+ nigbinv=1.355             aigc=0.0061361            bigc=0.00026197
+ cigc=-0.03984             aigsd=0.0049603           bigsd=0.000207349
+ cigsd=0.0042644           nigc=1.4052               poxedge=1
+ pigcd=2.688               ntox=ntoxp                xrcrg1=12
+ xrcrg2=1                  cgso=cgop                 cgdo=cgop
+ cgbo=0                    cgdl=cglp                 cgsl=cglp
+ clc=1e-007                cle=0.6                   cf=cfp
+ ckappas=0.6               ckappad=0.6               acde=0.4
+ moin=13.079               noff=2.1891               voffcv=-0.080796
+ kt1=-0.22746161           wkt1=2.305968e-009        kt1l=0
+ kt2=-0.033760614          wkt2=-1.8679881e-010      ute=-1
+ lute=0+dlutep             ua1=1.690225e-009         wua1=-8.3266e-018
+ ub1=-1.2152804e-018       wub1=-3.532866e-026       uc1=2.5584462e-010
+ wuc1=-1.7646901e-017      prt=0                     at=180000
+ lat=0+dlatp               jss=1.73e-07              jsd=1.73e-07
+ jsws=1.86e-13             jswd=1.86e-13             jswgs=1.86e-13
+ jswgd=1.86e-13            njs=1                     njd=1
+ ijthsfwd=0.01             ijthdfwd=0.01             ijthsrev=0.01
+ ijthdrev=0.01             bvs=9.59                  bvd=9.59
+ xjbvs=1                   xjbvd=1                   pbs=0.7
+ pbd=0.7                   cjs=cjp                   cjd=cjp
+ mjs=0.31                  mjd=0.31                  pbsws=0.96
+ pbswd=0.96                cjsws=cjswp               cjswd=cjswp
+ mjsws=0.063               mjswd=0.063               pbswgs=0.42
+ pbswgd=0.42               cjswgs=cjswgp             cjswgd=cjswgp
+ mjswgs=0.98               mjswgd=0.98               tpb=0.00155
+ tcj=0.00085               tpbsw=0.003               tcjsw=0.0002
+ tpbswg=0.0004             tcjswg=0.0024             xtis=3
+ xtid=3                    jtsswgs=jtsswgp           jtsswgd=jtsswgp
+ njtsswg=6.62              xtsswgs=0.3645            xtsswgd=0.3645
+ tnjtsswg=0.565            vtsswgs=10                vtsswgd=10
+ dmcg=7e-008               dmci=1.05e-007            dmdg=0
+ dmcgt=0                   dwj=0                     xgw=0
+ xgl=-0.656e-8             pcit=0+dpcitp             lcit=0+dlcitp
+ wcit=0+dwcitp             pvoff=0+dpvoffp           lvoff=0+dlvoffp
+ wu0=0+dwu0p               pa0=0+dpa0p               la0=0+dla0p
+ pags=0+dpagsp             lags=0+dlagsp             lk2=0+dlk2p
+ pk2=0+dpk2p               lu0=0+dlu0p               pu0=0+dpu0p
+ lvth0=0+dlvthp            wvth0=0+dwvthp            pvth0=0+dpvthp
+ lnfactor=0+dlnfactorp     wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp
+ leta0=0+dleta0p           peta0=0+dpeta0p           lvsat=0+dlvsatp
+ wvsat=0+dwvsatp           pvsat=0+dpvsatp           saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
 
     22: type=p 
+ lmin=1.000003e-006-(dxlp+dlmisp)                    lmax=1e-005-(dxlp+dlmisp)
+ wmin=1.2e-07              wmax=3e-007-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=2.134663e-08         ll=0                      wl=0
+ lln=0                     wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=2.134663e-08+ddlcp    dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k2=-0.0069186753+dk2p     lk2=3.47091e-009+dlk2p
+ wk2=-3.3145656e-010+dwk2p pk2=3.8109137e-017+dpk2p  k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=0.0005+dcitp
+ voff=-0.12132505+dvoffp-0.000238355*ss_flag         lvoff=-9.9198231e-009+dlvoffp+2.37078e-09*ss_flag
+ wvoff=1.2969771e-010+dwvoffp+7.53202e-11*ss_flag    pvoff=2.5196547e-015+dpvoffp-7.49166e-16*ss_flag
+ nfactor=0.52254+dnfactorp eta0=0.13755556+deta0p    weta0=-2.3875556e-009+dweta0p
+ etab=-0.17923867          wetab=-3.1730613e-009     u0=0.0082853373+du0p-3.97259e-06*ss_flag
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           ua=-5.5327161e-010        lua=2.3320276e-016
+ wua=-7.9154444e-017       pua=-4.4670019e-024       ub=1.1949371e-018-1.58903e-21*ss_flag
+ lub=1.2864101e-025+1.58052e-26*ss_flag              wub=2.4390054e-026+5.02135e-28*ss_flag
+ pub=3.974147e-033-4.99444e-33*ss_flag               uc=5.3892567e-011
+ luc=-1.8887567e-017       wuc=5.1893188e-020        puc=-5.1615092e-025
+ vsat=90000+dvsatp         a0=3.6612104+da0p         la0=-8.1467478e-007+dla0p
+ kvsat=1                   wa0=5.4959486e-008+dwa0p  pa0=-2.1296272e-014+dpa0p
+ ags=0.83518102+dagsp      lags=7.4873515e-07+dlagsp wags=-3.1733957e-08+dwagsp
+ pags=1.3735559e-14+dpagsp a1=0                      a2=0.8
+ b0=0                      b1=0                      keta=-0.0051229835
+ lketa=-5.1741584e-008     wketa=-2.4407189e-010     pketa=2.4276391e-015
+ dwg=0                     dwb=0                     pclm=1.013+dpclmp
+ pdiblc1=0                 pdiblc2=0.002598989+3.97259e-05*ff_flag+3.17807e-05*sf_flag-3.17807e-05*fs_flag
+ lpdiblc2=1.5572755e-009-3.9513e-10*ff_flag-3.16104e-10*sf_flag+3.16104e-10*fs_flag
+ wpdiblc2=-2.8896903e-010-1.25534e-11*ff_flag-1.00427e-11*sf_flag+1.00427e-11*fs_flag
+ ppdiblc2=4.9944383e-016+1.24861e-16*ff_flag+9.98887e-17*sf_flag-9.98887e-17*fs_flag
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.060315            pditsd=0.95634
+ pditsl=0                  rsh=15.5                  rsw=110+drdswp
+ rdw=110+drdswp            prwg=0                    prwb=0
+ wr=1                      alpha0=1.49e-9            alpha1=0.00383
+ beta0=10.7                agidl=1e-008              bgidl=1.75963e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.014358
+ bigbacc=0.0069774         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0061361
+ bigc=0.00026197           cigc=-0.03984             aigsd=0.0049603
+ bigsd=0.000207349         cigsd=0.0042644           nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.079               noff=2.1891
+ voffcv=-0.080796          kt1=-0.22739795           lkt1=-6.3313728e-010
+ wkt1=2.6296227e-009       pkt1=-3.2192021e-015      kt1l=0
+ kt2=-0.030965069          lkt2=-2.780564e-008       wkt2=-7.4090238e-010
+ pkt2=5.5113413e-015       ute=-1                    lute=0+dlutep
+ ua1=1.6210901e-009        lua1=6.8764392e-016       wua1=-9.7658187e-018
+ pua1=1.4315059e-023       ub1=-1.0654003e-018       lub1=-1.4907694e-024
+ wub1=-4.1241296e-026      pub1=5.8809511e-032       uc1=2.7520118e-010
+ luc1=-1.9252825e-016      wuc1=-1.863712e-017       puc1=9.8491322e-024
+ prt=0                     at=180000                 lat=0+dlatp
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pcit=0+dpcitp             lcit=0+dlcitp             wcit=0+dwcitp
+ wu0=0+dwu0p+1.25534e-12*ss_flag                     lu0=4.1837242e-10+dlu0p+3.9513e-11*ss_flag
+ pu0=0+dpu0p-1.24861e-17*ss_flag                     lvth0=0+dlvthp
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp
+ rnoib=0                   noic=noicp                em=3e+8
+ ef=1.1                   lintnoi=-1e-8             minr=1e-3
 
 
     23: type=p 
+ lmin=2.39995e-007-(dxlp+dlmisp)                     lmax=1.000003e-006-(dxlp+dlmisp)
+ wmin=1.2e-07              wmax=3e-007-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=5.0965e-03             wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=5.0965e-03
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29156+(dvthp+vthmisp)                       k1=0.24333
+ k2=-0.0039829818+dk2p     kvth0=-0.8e-10            pkvth0=-1e-17
+ wkvth0=0                  lkvth0=-4.330e-8          lk2=6.925403e-010+dlk2p
+ wk2=-2.9682299e-010+dwk2p pk2=5.3315791e-018+dpk2p  k3=-2.39941
+ k3b=1.88101               w0=0                      dvt0=1.44595
+ dvt1=0.91219              dvt2=0.16184              dvt0w=0
+ dvt1w=0                   dvt2w=0                   dsub=0.5
+ minv=-0.1                 voffl=0                   dvtp0=1.10431e-007
+ dvtp1=3.5                 lpe0=3.77983e-008         lpeb=4.1935e-009
+ xj=1.1e-007               ngate=1.812e+020          ndep=6.3687e+017
+ nsd=1e+020                phin=0                    cdsc=0
+ cdscb=0                   cdscd=0                   cit=6.3643017e-005+dcitp
+ lcit=4.1297261e-010+dlcitp                          wcit=4.7741562e-011+dwcitp
+ pcit=-4.5183092e-017+dpcitp                         voff=-0.13379519+dvoffp+0.00293621*ss_flag
+ lvoff=1.8820411e-009+dlvoffp-6.33664e-10*ss_flag    wvoff=3.5949851e-009+dwvoffp-9.27843e-10*ss_flag
+ pvoff=-7.5992803e-016+dpvoffp+2.00238e-16*ss_flag   nfactor=0.52254+dnfactorp
+ eta0=0.13755556+deta0p    weta0=-2.3875556e-009+dweta0p
+ etab=-0.17923867          wetab=-3.1730613e-009     u0=0.0086652457+du0p+4.89369e-05*ss_flag
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=5.882346e-011+dlu0p-1.05611e-11*ss_flag
+ wu0=4.5709129e-011+dwu0p-1.5464e-11*ss_flag         pu0=-4.3259577e-017+dpu0p+3.3373e-18*ss_flag
+ ua=-2.8263231e-010        lua=-2.2932978e-017       wua=-9.4741507e-017
+ pua=1.028475e-023         ub=1.2725505e-018+1.95747e-20*ss_flag
+ lub=5.5186948e-026-4.22443e-27*ss_flag              wub=6.6627334e-026-6.18562e-27*ss_flag
+ pub=-3.5999637e-032+1.33492e-33*ss_flag             uc=3.0028103e-011
+ luc=3.6980004e-018        wuc=9.0513008e-019        puc=-1.3236628e-024
+ vsat=90000+dvsatp         a0=3.5570216+da0p         la0=-7.1606944e-007+dla0p
+ kvsat=1                   wa0=-2.8991875e-008+dwa0p pa0=5.8156135e-014+dpa0p
+ ags=0.74114628+dagsp      lags=8.3773052e-007+dlagsp
+ wags=1.1010522e-008+dwagsp                          pags=-2.6718243e-014+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.042255062         lketa=-1.6599414e-008
+ wketa=1.217087e-009       pketa=1.0447837e-015      dwg=0
+ dwb=0                     pclm=0.66393792+dpclmp    lpclm=3.3035585e-007
+ wpclm=3.3412347e-008      ppclm=-3.1621779e-014     pdiblc1=0
+ pdiblc2=0.0042444444-0.000489369*ff_flag-0.000391495*sf_flag+0.000391495*fs_flag
+ ppdiblc2=0-3.3373e-17*ff_flag-2.66984e-17*sf_flag+2.66984e-17*fs_flag
+ lpdiblc2=0+1.05611e-10*ff_flag+8.44885e-11*sf_flag-8.44885e-11*fs_flag
+ wpdiblc2=2.3875556e-010+1.5464e-10*ff_flag+1.23712e-10*sf_flag-1.23712e-10*fs_flag
+ pdiblcb=0                 drout=0.5                 pvag=0.74
+ delta=0.01                pscbe1=1e+009             pscbe2=8e-011
+ fprout=0                  pdits=0.060315            pditsd=0.95634
+ pditsl=0                  rsh=15.5                  rsw=110+drdswp
+ rdw=110+drdswp            prwg=0                    prwb=0
+ wr=1                      alpha0=1.49e-9            alpha1=0.00383
+ beta0=10.7                agidl=1e-008              bgidl=1.75963e+009
+ cgidl=0.225               egidl=0.8                 aigbacc=0.014358
+ bigbacc=0.0069774         cigbacc=0                 nigbacc=5.82
+ aigbinv=0.008002          bigbinv=1e-005            cigbinv=0.006
+ eigbinv=1.1               nigbinv=1.355             aigc=0.0061361
+ bigc=0.00026197           cigc=-0.03984             aigsd=0.0049603
+ bigsd=0.000207349         cigsd=0.0042644           nigc=1.4052
+ poxedge=1                 pigcd=2.688               ntox=ntoxp
+ xrcrg1=12                 xrcrg2=1                  cgso=cgop
+ cgdo=cgop                 cgbo=0                    cgdl=cglp
+ cgsl=cglp                 clc=1e-007                cle=0.6
+ cf=cfp                    ckappas=0.6               ckappad=0.6
+ acde=0.4                  moin=13.079               noff=2.1891
+ voffcv=-0.080796          kt1=-0.22130316           lkt1=-6.4013135e-009
+ wkt1=-4.4835248e-010      pkt1=-3.0617567e-016      kt1l=0
+ kt2=-0.059719284          lkt2=-5.9236202e-010      wkt2=5.5202321e-009
+ pkt2=-4.1425897e-016      ute=-1                    ua1=2.2821138e-009
+ lua1=6.2044467e-017       lute=0+dlutep             wua1=4.3441334e-017
+ pua1=-3.6040723e-023      ub1=-2.4470685e-018       lub1=-1.8314477e-025
+ wub1=-1.7070645e-026      pub1=3.5934164e-032       uc1=1.242009e-010
+ luc1=-4.9620074e-017      wuc1=-1.4539974e-017      puc1=5.9715516e-024
+ prt=0                     at=235598.61              lat=-0.052619076+dlatp
+ wat=-0.006851482          pat=6.4843111e-009        jss=1.73e-07
+ jsd=1.73e-07              jsws=1.86e-13             jswd=1.86e-13
+ jswgs=1.86e-13            jswgd=1.86e-13            njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.59
+ bvd=9.59                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjp
+ cjd=cjp                   mjs=0.31                  mjd=0.31
+ pbsws=0.96                pbswd=0.96                cjsws=cjswp
+ cjswd=cjswp               mjsws=0.063               mjswd=0.063
+ pbswgs=0.42               pbswgd=0.42               cjswgs=cjswgp
+ cjswgd=cjswgp             mjswgs=0.98               mjswgd=0.98
+ tpb=0.00155               tcj=0.00085               tpbsw=0.003
+ tcjsw=0.0002              tpbswg=0.0004             tcjswg=0.0024
+ xtis=3                    xtid=3                    jtsswgs=jtsswgp
+ jtsswgd=jtsswgp           njtsswg=6.62              xtsswgs=0.3645
+ xtsswgd=0.3645            tnjtsswg=0.565            vtsswgs=10
+ vtsswgd=10                dmcg=7e-008               dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-0.656e-8             lvth0=0+dlvthp
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           lvsat=0+dlvsatp           wvsat=0+dwvsatp
+ pvsat=0+dpvsatp           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp
+ rnoib=0                   noic=noicp                em=3e+8
+ ef=1.1                   lintnoi=-1e-8             minr=1e-3
 
 
     24: type=p 
+ lmin=1e-007-(dxlp+dlmisp) lmax=2.39995e-007-(dxlp+dlmisp)
+ wmin=1.2e-07              wmax=3e-007-(dxwp+dwmisp) version=4.5
+ gbmin=1.00e-12            rbsb=50                   ud=0
+ rbdb=50                   rgeomod=1                 rbpb=50
+ rshg=15.882               rbps=50                   rbpd=50
+ ngcon=1                   binunit=2                 paramchk=1
+ mobmod=0                  capmod=2                  igcmod=1
+ igbmod=1                  diomod=1                  rdsmod=1
+ rbodymod=0                rgatemod=1*rgflag         permod=1
+ acnqsmod=0                trnqsmod=0                tempmod=0
+ tnom=25                   toxe=(toxp+toxmisp)       toxm=2.2e-009
+ dtox=3.2067e-010          epsrox=3.9                wint=0
+ lint=1.25625e-09          ll=0.0050965              wl=0
+ lln=-0.9                  wln=1                     lw=0
+ ww=0                      lwn=1                     wwn=1
+ lwl=0                     wwl=0                     llc=0.0050965
+ wlc=0                     lwc=0                     wwc=0
+ lwlc=0                    wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29576369+(dvthp+vthmisp)                    lvth0=9.0719854e-010+dlvthp
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          k1=0.22699184             lk1=3.5259378e-009
+ k2=0.013644637+dk2p       lk2=-3.1116761e-009+dlk2p wk2=-1.0358066e-009+dwk2p
+ pk2=1.6481164e-016+dpk2p  k3=-2.39941               k3b=1.88101
+ w0=0                      dvt0=1.44595              dvt1=0.91219
+ dvt2=0.16184              dvt0w=0                   dvt1w=0
+ dvt2w=0                   dsub=0.5                  minv=-0.1
+ voffl=0                   dvtp0=1.10431e-007        dvtp1=3.5
+ lpe0=3.77983e-008         lpeb=4.1935e-009          xj=1.1e-007
+ ngate=1.812e+020          ndep=6.3687e+017          nsd=1e+020
+ phin=0                    cdsc=0                    cdscb=0
+ cdscd=0                   cit=-2.6193918e-005+dcitp lcit=4.3236032e-010+dlcitp
+ wcit=-7.5957036e-011+dwcitp                         pcit=-1.8487697e-017+dpcitp
+ voff=-0.11653502+dvoffp   lvoff=-1.8428749e-009+dlvoffp
+ wvoff=-8.6774897e-010+dwvoffp                       pvoff=2.0317462e-016+dpvoffp
+ nfactor=0.52254+dnfactorp eta0=0.13755556+deta0p    weta0=-2.3875556e-009+dweta0p
+ etab=-0.19547303          letab=3.5035387e-009      wetab=-1.707527e-009
+ petab=-3.1627695e-016     u0=0.0095045942+du0p      lu0=-1.2231634e-010+dlu0p
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           wu0=-2.0683055e-010+dwu0p pu0=1.1241011e-017+dpu0p
+ ua=-3.9945876e-010        lua=2.2793384e-018        wua=-5.2546349e-017
+ pua=1.1786131e-024        ub=1.8329634e-018         lub=-6.5755774e-026
+ wub=-1.3158685e-025       pub=6.7769659e-033        uc=5.414484e-011
+ luc=-1.5066326e-018       wuc=-4.6923639e-018       puc=-1.1566767e-025
+ vsat=88846.098+dvsatp     lvsat=0.00024902349+dlvsatp
+ kvsat=1                   wvsat=0.00036463288+dwvsatp
+ pvsat=-7.8691422e-011+dpvsatp                       a0=-0.20375232+da0p
+ la0=9.5543184e-008+dla0p  wa0=3.0130034e-007+dwa0p  pa0=-1.3124228e-014+dpa0p
+ ags=4.6229449+dagsp       lags=-4.3951197e-013+dlagsp
+ wags=-1.1279459e-007+dwagsp                         pags=1.3888578e-019+dpagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.16384773          lketa=9.6415009e-009
+ wketa=6.8467337e-009      pketa=-1.7015031e-016     dwg=0
+ dwb=0                     pclm=2.7744289+dpclmp     lpclm=-1.2510921e-007
+ wpclm=-1.5338172e-007     ppclm=8.6902491e-015      pdiblc1=0
+ pdiblc2=0.0030192358      lpdiblc2=2.6441228e-010   wpdiblc2=2.3875556e-010
+ ppdiblc2=1.2444372e-031   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswp            rdw=110+drdswp            prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp                xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.18100996
+ lkt1=-1.5096988e-008      wkt1=-9.393722e-009       pkt1=1.6243245e-015
+ kt1l=0                    kt2=-0.052164784          lkt2=-2.2226988e-009
+ wkt2=1.324958e-009        pkt2=4.9112312e-016       ute=-1
+ lute=0+dlutep             ua1=2.4688309e-009        lua1=2.1749047e-017
+ wua1=-8.5117837e-017      pua1=-8.2963678e-024      ub1=-2.9384487e-018
+ lub1=-7.7100003e-026      wub1=4.5608959e-026       pub1=2.2407279e-032
+ uc1=-8.9441544e-011       luc1=-3.5138994e-018      wuc1=1.6818031e-017
+ puc1=-7.9581932e-025      prt=0                     at=-8386.0994
+ lat=3.5263115e-05+dlatp   wat=0.033153904           pat=-2.1492513e-009
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ wvth0=0+dwvthp            pvth0=0+dpvthp            lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     leta0=0+dleta0p
+ peta0=0+dpeta0p           saref=0.405e-6            sbref=0.405e-6
+ wlod=0                    llodvth=1                 wlodvth=1
+ stk2=0                    lodk2=1                   lodeta0=1
+ llodku0=1                 wlodku0=1                 steta0=0
+ tku0=0                    wec=-3510                 web=-310
+ scref=1e-6                wpemod=1                  kvth0we=-0.0039
+ pkvth0we=0.55e-17         wkvth0we=1.5e-11          lkvth0we=1.5e-11
+ ku0we=-0.0108             pku0we=-0.3e-17           wku0we=-4.5e-10
+ lku0we=-0.15e-10          k2we=0.00060              wk2we=3.2e-10
+ lk2we=4e-12               fnoimod=1                 af=1
+ kf=0                      tnoimod=1                 noia=noiap
+ rnoia=rnoiax              tnoia=tnoiax              noib=noibp
+ rnoib=0                   noic=noicp                em=3e+8
+ ef=1.1                   lintnoi=-1e-8             minr=1e-3
 
 
     25: type=p 
+ lmin=6e-08                lmax=1e-007-(dxlp+dlmisp) wmin=1.2e-07
+ wmax=3e-007-(dxwp+dwmisp) version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.882
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=(toxp+toxmisp)       toxm=2.2e-009             dtox=3.2067e-010
+ epsrox=3.9                wint=0                    lint=1.25625e-09
+ ll=0.0050965              wl=0                      lln=-0.9
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0.0050965             wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.09e-08+(dxlp+dlmisp)
+ xw=1.6e-08+(dxwp+dwmisp)  dlc=1.25625e-09+ddlcp     dwc=0
+ xpart=1                   toxref=3e-009             dlcig=2.5e-009
+ vth0=-0.29638894+(dvthp+vthmisp)+0.0182083*ss_flag+0.0101157*ff_flag+0.00809258*sf_flag-0.00809258*fs_flag
+ kvth0=-0.8e-10            pkvth0=-1e-17             wkvth0=0
+ lkvth0=-4.330e-8          lvth0=9.5845806e-010+dlvthp-1.49277e-09*ss_flag-8.29316e-10*ff_flag-6.63453e-10*sf_flag+6.63453e-10*fs_flag
+ wvth0=-2.9887175e-010+dwvthp-2.47633e-09*ss_flag-1.37574e-09*ff_flag-1.10059e-09*sf_flag+1.10059e-09*fs_flag
+ pvth0=2.4502403e-017+dpvthp+2.03017e-16*ss_flag+1.12787e-16*ff_flag+9.02296e-17*sf_flag-9.02296e-17*fs_flag
+ k1=0.23542781             lk1=2.8343315e-009        k2=0.015235307+dk2p
+ lk2=-3.242084e-009+dlk2p  wk2=6.3392361e-011+dwk2p  pk2=7.4696007e-017+dpk2p
+ k3=-2.39941               k3b=1.88101               w0=0
+ dvt0=1.44595              dvt1=0.91219              dvt2=0.16184
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.1                 voffl=0
+ dvtp0=1.10431e-007        dvtp1=3.5                 lpe0=3.77983e-008
+ lpeb=4.1935e-009          xj=1.1e-007               ngate=1.812e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.0024186717+dcitp    lcit=2.3192291e-010+dlcitp
+ wcit=-5.2704949e-010+dwcitp                         pcit=1.8494215e-017+dpcitp
+ voff=-0.12682496+dvoffp+0.00261216*ss_flag+0.00356739*ff_flag+0.00285391*sf_flag-0.00285391*fs_flag
+ lvoff=-9.9927462e-010+dlvoffp-2.14153e-10*ss_flag-2.92465e-10*ff_flag-2.33972e-10*sf_flag+2.33972e-10*fs_flag
+ wvoff=8.3780189e-010+dwvoffp-8.25443e-10*ss_flag-3.98964e-10*ff_flag-3.19171e-10*sf_flag+3.19171e-10*fs_flag
+ pvoff=6.3348446e-017+dpvoffp+6.76722e-17*ss_flag+3.27082e-17*ff_flag+2.61665e-17*sf_flag-2.61665e-17*fs_flag
+ nfactor=0.52254+dnfactorp eta0=0.07073972+deta0p-0.0202314*ss_flag-0.035802*ff_flag-0.0286415*sf_flag+0.0286415*fs_flag
+ leta0=5.4777627e-009+dleta0p+1.65863e-09*ss_flag+2.93515e-09*ff_flag+2.34812e-09*sf_flag-2.34812e-09*fs_flag
+ weta0=3.5648532e-009+dweta0p+2.75148e-09*ss_flag+3.30177e-09*ff_flag+2.64142e-09*sf_flag-2.64142e-09*fs_flag
+ peta0=-4.8799633e-016+dpeta0p-2.25574e-16*ss_flag-2.70689e-16*ff_flag-2.16551e-16*sf_flag+2.16551e-16*fs_flag
+ etab=-0.26592886          letab=9.279719e-009       wetab=-1.1828594e-008
+ petab=5.1347848e-016      u0=0.0086033713+du0p+0.000404629*ff_flag+0.000323703*sf_flag-0.000323703*fs_flag
+ ku0=-0.5354e-9            pku0=2e-16                wku0=0e-7
+ lku0=-4.0055e-8           lu0=-4.8431378e-011+dlu0p-3.31726e-11*ff_flag-2.65381e-11*sf_flag+2.65381e-11*fs_flag
+ wu0=-1.5005849e-010+dwu0p-5.50295e-11*ff_flag-4.40236e-11*sf_flag+4.40236e-11*fs_flag
+ pu0=6.5866674e-018+dpu0p+4.51148e-18*ff_flag+3.60918e-18*sf_flag-3.60918e-18*fs_flag
+ ua=-9.6007487e-010        lua=4.8240329e-017        wua=7.4810644e-018
+ pua=-3.7426144e-024       ub=1.8580108e-018         lub=-6.7809236e-026
+ wub=-1.4732999e-025       pub=8.0676359e-033        uc=8.7555285e-011
+ luc=-4.2457211e-018       wuc=-1.3242763e-017       puc=5.8531972e-025
+ vsat=106315.87+dvsatp     lvsat=-0.0011832011+dlvsatp
+ kvsat=1                   wvsat=-0.0022716662+dwvsatp
+ pvsat=1.3744029e-010+dpvsatp                        a0=-2.5397632+da0p+2.61216*ff_flag+2.08973*sf_flag-2.08973*fs_flag
+ la0=2.8705637e-007+dla0p-2.14153e-07*ff_flag-1.71322e-07*sf_flag+1.71322e-07*fs_flag
+ wa0=3.0395331e-007+dwa0p-8.25443e-07*ff_flag-6.60354e-07*sf_flag+6.60354e-07*fs_flag
+ pa0=-1.3341727e-014+dpa0p+6.76722e-14*ff_flag+5.41378e-14*sf_flag-5.41378e-14*fs_flag
+ ags=4.6229396+dagsp       wags=-1.127929e-007+dwagsp
+ a1=0                      a2=0.8                    b0=0
+ b1=0                      keta=-0.29206529          lketa=2.0153161e-008
+ wketa=3.7148588e-008      pketa=-2.6543872e-015     dwg=0
+ dwb=0                     pclm=2.039135+dpclmp      lpclm=-6.4827607e-008
+ wpclm=-1.1574054e-007     ppclm=5.6043122e-015      pdiblc1=0
+ pdiblc2=0.003939632       lpdiblc2=1.8895544e-010   wpdiblc2=2.3875556e-010
+ ppdiblc2=1.4122644e-031   pdiblcb=0                 drout=0.5
+ pvag=0.74                 delta=0.01                pscbe1=1e+009
+ pscbe2=8e-011             fprout=0                  pdits=0.060315
+ pditsd=0.95634            pditsl=0                  rsh=15.5
+ rsw=110+drdswp            rdw=110+drdswp            prwg=0
+ prwb=0                    wr=1                      alpha0=1.49e-9
+ alpha1=0.00383            beta0=10.7                agidl=1e-008
+ bgidl=1.75963e+009        cgidl=0.225               egidl=0.8
+ aigbacc=0.014358          bigbacc=0.0069774         cigbacc=0
+ nigbacc=5.82              aigbinv=0.008002          bigbinv=1e-005
+ cigbinv=0.006             eigbinv=1.1               nigbinv=1.355
+ aigc=0.0061361            bigc=0.00026197           cigc=-0.03984
+ aigsd=0.0049603           bigsd=0.000207349         cigsd=0.0042644
+ nigc=1.4052               poxedge=1                 pigcd=2.688
+ ntox=ntoxp                xrcrg1=12                 xrcrg2=1
+ cgso=cgop                 cgdo=cgop                 cgbo=0
+ cgdl=cglp                 cgsl=cglp                 clc=1e-007
+ cle=0.6                   cf=cfp                    ckappas=0.6
+ ckappad=0.6               acde=0.4                  moin=13.079
+ noff=2.1891               voffcv=-0.080796          kt1=-0.38386444
+ lkt1=1.5336308e-009       wkt1=2.2420506e-008       pkt1=-9.8390135e-016
+ kt1l=0                    kt2=-0.08865437           lkt2=7.6882694e-010
+ wkt2=7.8776768e-009       pkt2=-4.6088425e-017      ute=-1
+ lute=0+dlutep             ua1=3.8481829e-009        lua1=-9.1334364e-017
+ wua1=-3.5927001e-016      pua1=1.417945e-023        ub1=-5.9785043e-018
+ lub1=1.7213287e-025       wub1=6.4603234e-025       pub1=-2.6817231e-032
+ uc1=-3.703777e-010        luc1=1.9518089e-017       wuc1=3.405853e-017
+ puc1=-2.2092472e-024      prt=0                     at=-36740.999
+ lat=0.0023598828+dlatp    wat=0.016034156           pat=-7.4572297e-010
+ jss=1.73e-07              jsd=1.73e-07              jsws=1.86e-13
+ jswd=1.86e-13             jswgs=1.86e-13            jswgd=1.86e-13
+ njs=1                     njd=1                     ijthsfwd=0.01
+ ijthdfwd=0.01             ijthsrev=0.01             ijthdrev=0.01
+ bvs=9.59                  bvd=9.59                  xjbvs=1
+ xjbvd=1                   pbs=0.7                   pbd=0.7
+ cjs=cjp                   cjd=cjp                   mjs=0.31
+ mjd=0.31                  pbsws=0.96                pbswd=0.96
+ cjsws=cjswp               cjswd=cjswp               mjsws=0.063
+ mjswd=0.063               pbswgs=0.42               pbswgd=0.42
+ cjswgs=cjswgp             cjswgd=cjswgp             mjswgs=0.98
+ mjswgd=0.98               tpb=0.00155               tcj=0.00085
+ tpbsw=0.003               tcjsw=0.0002              tpbswg=0.0004
+ tcjswg=0.0024             xtis=3                    xtid=3
+ jtsswgs=jtsswgp           jtsswgd=jtsswgp           njtsswg=6.62
+ xtsswgs=0.3645            xtsswgd=0.3645            tnjtsswg=0.565
+ vtsswgs=10                vtsswgd=10                dmcg=7e-008
+ dmci=1.05e-007            dmdg=0                    dmcgt=0
+ dwj=0                     xgw=0                     xgl=-0.656e-8
+ pags=0+dpagsp             lags=0+dlagsp             lnfactor=0+dlnfactorp
+ wnfactor=0+dwnfactorp     pnfactor=0+dpnfactorp     saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ lodeta0=1                 llodku0=1                 wlodku0=1
+ steta0=0                  tku0=0                    wec=-3510
+ web=-310                  scref=1e-6                wpemod=1
+ kvth0we=-0.0039           pkvth0we=0.55e-17         wkvth0we=1.5e-11
+ lkvth0we=1.5e-11          ku0we=-0.0108             pku0we=-0.3e-17
+ wku0we=-4.5e-10           lku0we=-0.15e-10          k2we=0.00060
+ wk2we=3.2e-10             lk2we=4e-12               fnoimod=1
+ af=1                      kf=0                      tnoimod=1
+ noia=noiap                rnoia=rnoiax              tnoia=tnoiax
+ noib=noibp                rnoib=0                   noic=noicp
+ em=3e+8                   ef=1.1                   lintnoi=-1e-8
+ minr=1e-3
 
     } 
ends pch_mac
// 
// *********************************************************************************************
//                                                                            
//                   *
//                                1.0V STD-VT NMOS DEVICE MODELS              
//                   *
//                                                                            
//                   *
// *********************************************************************************************
model nch bsim4  { 
     1: type=n 
+ lmin=9.999997e-006-dxln   lmax=2.00001e-05          wmin=1e-005-dxwn
+ wmax=0.0009000001         version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn                 toxm=2e-009               dtox=2.4905e-010
+ epsrox=3.9                wint=0                    lint=2.058866e-08
+ ll=0                      wl=0                      lln=0
+ wln=1                     lw=0                      ww=0
+ lwn=1                     wwn=1                     lwl=0
+ wwl=0                     llc=0                     wlc=0
+ lwc=0                     wwc=0                     lwlc=0
+ wwlc=0                    xl=-1.46e-08+dxln         xw=1.6e-08+dxwn
+ dlc=2.058866e-08+ddlcn    dwc=0                     xpart=1
+ toxref=3e-009             dlcig=2.5e-009            vth0=0.31803+dvthn
+ k1=0.24753                kvth0=19e-10              pkvth0=0
+ wkvth0=5e-8               lkvth0=-0.4e-8            k2=-0.0076717973+dk2n
+ k3=-3.98252               k3b=2.24786               w0=0
+ dvt0=1.08116              dvt1=1.18773              dvt2=0.015579
+ dvt0w=0                   dvt1w=0                   dvt2w=0
+ dsub=0.5                  minv=-0.46494             voffl=0
+ dvtp0=4.20003e-007        dvtp1=0                   lpe0=6.10104e-009
+ lpeb=4.55849e-008         xj=1.1e-007               ngate=3.1592e+020
+ ndep=6.3687e+017          nsd=1e+020                phin=0
+ cdsc=0                    cdscb=0                   cdscd=0
+ cit=0.00057279971         voff=-0.13911744+dvoffn   nfactor=0.6+dnfactorn
+ eta0=0.12927+deta0n       etab=-0.057726            u0=0.021593681+du0n
+ ua=-1.7296441e-009        ub=2.0224332e-18          pub=0
+ wub=0                     lub=0                     ku0=-2.9e-8
+ pku0=2e-14                wku0=1.2e-7               lku0=2.2e-7
+ uc=4.269655e-11           puc=0                     wuc=0
+ luc=0                     vsat=101530+dvsatn        a0=3.373321+da0n
+ kvsat=1                   ags=0.6553773+dagsn       wags=0
+ a1=0                      a2=1                      b0=0
+ b1=0                      keta=-0.034718159         dwg=0
+ dwb=0                     pclm=0.053744831+dpclmn   pdiblc1=0
+ pdiblc2=0.00098156419     pdiblcb=-0.03716          drout=0.5
+ pvag=0.7                  delta=0.01                pscbe1=4.24e+008
+ pscbe2=1e-020             fprout=0                  pdits=0.44984
+ pditsd=1                  pditsl=264000             rsh=16
+ rsw=45+drdswn             rdw=45+drdswn             prwg=0
+ prwb=0                    wr=1                      alpha0=3.3929e-010
+ alpha1=0.0034             beta0=5.808               agidl=1.5797e-008
+ bgidl=1.4527e+009         cgidl=1.4892              egidl=0.81976
+ aigbacc=0.013432          bigbacc=0.0065981         cigbacc=0.39315
+ nigbacc=4.8               aigbinv=0.024468          bigbinv=0.012141
+ cigbinv=0.0855            eigbinv=1.1               nigbinv=3.8771
+ aigc=0.010744             bigc=0.000824385          cigc=-0.087762
+ aigsd=0.0093701           bigsd=0.0012397           cigsd=0.081703
+ nigc=1.5                  poxedge=1                 pigcd=3.11
+ ntox=ntoxn                xrcrg1=12                 xrcrg2=1
+ cgso=cgon                 cgdo=cgon                 cgbo=0
+ cgdl=cgln                 cgsl=cgln                 clc=1e-007
+ cle=0.6                   cf=cfn                    ckappas=0.6
+ ckappad=0.6               acde=0.6                  moin=7.6133
+ noff=2.4067               voffcv=-0.12779           kt1=-0.23137464+dkt1n
+ kt1l=0                    kt2=-0.037187286+dkt2n    ute=-1
+ ua1=2.945079e-009+dua1n   ub1=-1.225332e-018+dub1n  uc1=2.957975e-10
+ puc1=0                    wuc1=0                    luc1=0
+ prt=0                     at=200000+datn            jss=1.35e-07
+ jsd=1.35e-07              jsws=2.5e-13              jswd=2.5e-13
+ jswgs=2.5e-13             jswgd=2.5e-13             njs=1
+ njd=1                     ijthsfwd=0.01             ijthdfwd=0.01
+ ijthsrev=0.01             ijthdrev=0.01             bvs=9.03
+ bvd=9.03                  xjbvs=1                   xjbvd=1
+ pbs=0.7                   pbd=0.7                   cjs=cjn
+ cjd=cjn                   mjs=0.32                  mjd=0.32
+ pbsws=1.12                pbswd=1.12                cjsws=cjswn
+ cjswd=cjswn               mjsws=0.05                mjswd=0.05
+ pbswgs=1.15               pbswgd=1.15               cjswgs=cjswgn
+ cjswgd=cjswgn             mjswgs=0.98               mjswgd=0.98
+ tpb=0.0016                tcj=0.0008                tpbsw=0.003
+ tcjsw=0.0004              tpbswg=0.0019             tcjswg=0.0016
+ xtis=3                    xtid=3                    jtsswgs=7.86078e-009
+ jtsswgd=7.86078e-009      njtsswg=5.64              xtsswgs=-0.103
+ xtsswgd=-0.103            tnjtsswg=-0.485           vtsswgs=17.7
+ vtsswgd=17.7              dmcg=7.15e-008            dmci=1.05e-007
+ dmdg=0                    dmcgt=0                   dwj=0
+ xgw=0                     xgl=-1.163e-8             lvth0=0+dlvthn
+ wvth0=0+dwvthn            pvth0=0+dpvthn            lk2=0+dlk2n
+ wk2=0+dwk2n               pk2=0+dpk2n               lcit=0+dlcitn
+ wcit=0+dwcitn             pcit=0+dpcitn             lnfactor=0+dlnfactorn
+ wnfactor=0+dwnfactorn     pnfactor=0+dpnfactorn     leta0=0+dleta0n
+ weta0=0+dweta0n           peta0=0+dpeta0n           lu0=0+dlu0n
+ wu0=0+dwu0n               pu0=0+dpu0n               lvsat=0+dlvsatn
+ wvsat=0+dwvsatn           pvsat=0+dpvsatn           lags=0+dlagsn
+ pags=0+dpagsn             ppclm=0+dppclmn           lkt1=0+dlkt1n
+ pat=0+dpatn               lat=0+dlatn               lvoff=0+dlvoffn
+ wvoff=0+dwvoffn           pvoff=0+dpvoffn           la0=0+dla0n
+ wa0=0+dwa0n               pa0=0+dpa0n               wkt1=0+dwkt1n
+ pkt1=0+dpkt1n             lkt2=0+dlkt2n             wkt2=0+dwkt2n
+ pkt2=0+dpkt2n             lua1=0+dlua1n             wua1=0+dwua1n
+ pua1=0+dpua1n             lub1=0+dlub1n             wub1=0+dwub1n
+ pub1=0+dpub1n             wat=0+dwatn               saref=0.405e-6
+ sbref=0.405e-6            wlod=0                    llodvth=1
+ wlodvth=1                 stk2=0                    lodk2=1
+ llodku0=1                 wlodku0=1                 lodeta0=1
+ steta0=0e-10              tku0=0                    wec=-3010
+ web=-210                  scref=1e-6                wpemod=1
+ kvth0we=0.0036            pkvth0we=0.15e-17         wkvth0we=-9.5e-11
+ lkvth0we=-5.6e-11         ku0we=-0.0017             pku0we=-1.4e-17
+ wku0we=-2.0e-10           lku0we=1.88e-10           k2we=0.00045
+ pk2we=-0.26e-17           wk2we=0.4e-10             lk2we=0.1e-12
+ fnoimod=1                 af=1                      kf=0
+ tnoimod=0                 noia=noian                noib=noibn
+ noic=noicn                em=3e+8                   ef=0.9
+ lintnoi=-1e-8             minr=1e-3
 
 
     2: type=n 
+ lmin=9.999973e-007-dxln   lmax=9.999997e-006-dxln   wmin=1e-005-dxwn
+ wmax=0.0009000001         version=4.5               gbmin=1.00e-12
+ rbsb=50                   ud=0                      rbdb=50
+ rgeomod=1                 rbpb=50                   rshg=15.953
+ rbps=50                   rbpd=50                   ngcon=1
+ binunit=2                 paramchk=1                mobmod=0
+ capmod=2                  igcmod=1                  igbmod=1
+ diomod=1                  rdsmod=1                  rbodymod=0
+ rgatemod=1*rgflag         permod=1                  acnqsmod=0
+ trnqsmod=0                tempmod=0                 tnom=25
+ toxe=toxn                 toxm=2e-009               dtox=2.4905e-010
+ epsrox=3.9                wint=0                    lint=2.058866e-08
